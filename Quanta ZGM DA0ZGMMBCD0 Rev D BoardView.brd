# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
LED_PWR_LEFT on BOTTOM (solid shape): 150.1,200.63 150.1,199.12 149.98,199.01 149.72,199.01 149.48,199.25 149.48,200.2 148.03,201.66 147.68,201.66 147.68,201.66 147.54,201.69 147.41,201.66 147.4,201.66 147.05,201.66 146.98,201.73 146.98,202.01 147.04,202.07 148.65,202.07
LED_PWR_LOGO on TOP (solid shape): 266.35,199.2 266.5,199.05 266.35,198.9 265.68,198.9 265.53,198.75 265.53,198.42 265.06,197.95 265.05,197.95 264.9,197.85 264.81,197.7 264.8,197.69 264.77,197.66 264.77,197.28 264.93,197.11 265.13,197.11 265.31,196.93 265.37,196.89 265.56,196.7 266.35,196.7 266.5,196.55 266.35,196.4 265.43,196.4 265.2,196.63 265.16,196.59 263.84,196.59 263.6,196.83 263.6,198.46 264.24,199.11 265.45,199.11 265.55,199.2
LED_PWR_LOGO on IN2 (solid shape): 265.47,198.42 265.47,197.99 265.42,197.91 265.33,197.9 265.25,197.92 265.18,197.93 264.82,197.57 265.18,197.22 265.25,197.23 265.33,197.25 265.42,197.24 265.47,197.16 265.47,196.71 265.34,196.58 263.79,196.58 263.49,196.87 263.49,198.38 263.66,198.56 265.33,198.56
LED_PWR_RIGHT on BOTTOM (solid shape): 146.48,203.34 146.48,203 146.47,202.99 145.57,202.99 145.39,202.81 144.4,202.81 144.28,202.93 144.28,203.26 144.59,203.58 146.24,203.58
LINLVP on BOTTOM (solid shape): 292.3,72.77 293.1,72.77 293.1,71.98 292.3,71.98 292.3,71.89 291.1,71.89 290.75,71.54 290.75,70.76 290.56,70.57 290.21,70.57 290.03,70.75 290.03,70.95 289.45,71.53 289.45,72.74 289.53,72.82 292.3,72.82
LINLVP on IN2 (solid shape): 303.9,63.68 303.9,62.77 303.74,62.61 303.74,61.68 303.46,61.4 303.07,61.4 302.96,61.51 302.96,61.88 302.97,61.89 303.11,62.04 303.11,63.37 303.1,63.38 303.1,63.69 303.19,63.77 303.81,63.77
LIP on BOTTOM (solid shape): 288.75,72.64 288.75,71.51 288.66,71.41 288.66,71.41 288.36,71.11 288.36,69.53 288.23,69.39 287.8,69.39 287.6,69.59 287.6,70 287,70.6 287,72.06 287.72,72.78 288.62,72.78
LIP on IN2 (solid shape): 302.94,63.43 302.94,62.11 302.83,61.99 302.83,61.65 302.69,61.51 302.42,61.51 302.32,61.61 302.32,62.03 302.31,62.03 302.31,62.12 302.19,62.24 302.19,63.38 302.33,63.52 302.86,63.52
LVN on BOTTOM (solid shape): 289.53,74.85 289.53,74.54 289.76,74.31 290.91,74.31 291.2,74.02 293.1,74.02 293.1,73.23 288.85,73.23 288.61,73.48 288.61,75.06 289.31,75.06
LVN on IN2 (solid shape): 304.68,61.05 304.68,60.53 304.39,60.24 303.44,60.24 303.32,60.36 303.32,61.1 303.54,61.33 304.41,61.33
MAIND on TOP (solid shape): 123.91,57.51 123.91,56.54 123.06,55.69 123.06,55.48 122.13,54.55 122.11,54.54 122.09,54.54 119.61,54.54 119.6,54.55 119.6,55.33 119.67,55.4 120.8,55.4 121.5,56.11 121.5,57.24 121.9,57.63 123.79,57.63
MAINON_ON_G on TOP (solid shape): 62.72,63.77 62.72,61.08 62.56,60.92 58.96,60.92 58.88,61 58.88,62.02 58.8,62.09 57.33,62.09 57.25,62.17 57.25,62.6 57.1,62.75 56.04,62.75 55.96,62.83 55.96,63.82 56.09,63.95 59.41,63.95 59.52,63.84 59.52,62.85 59.85,62.52 60.89,62.52 61.09,62.73 61.09,63.89 61.19,64 62.49,64
MB_THRMTRIP# on BOTTOM (solid shape): 262.62,216.51 262.62,216.49 262.76,216.32 262.97,216.25 263.04,216.22 263.07,216.15 263.07,215.94 263.73,215.28 264.27,215.28 264.31,215.26 264.33,215.23 264.33,214.44 264.25,214.37 263.47,214.37 263.12,214.73 262.91,214.73 262.88,214.74 262.86,214.8 262.86,215.01 262.82,215.11 262.72,215.15 262.72,215.15 262.63,215.19 262.53,215.21 262.22,215.21 261.47,214.47 260.76,214.47 260.76,214.47 260.07,214.47 259.93,214.61 259.93,215.13 260.01,215.21 261.66,215.21 261.98,215.53 261.98,216.27 261.99,216.28 261.99,216.41 262.11,216.52 262.59,216.52
MIC_VCC on TOP (solid shape): 271.73,185.99 271.73,185.76 271.61,185.64 271.17,185.64 271.04,185.76 271.04,185.88 270.79,186.13 269.48,186.13 269.45,186.16 269.45,186.34 269.49,186.38 271.34,186.38
MIC_VCC on BOTTOM (solid shape): 268.85,185.89 269.37,185.89 269.55,186.07 270.74,186.07 270.94,186.27 271.5,186.27 271.66,186.12 271.66,185.73 271.45,185.53 268.71,185.53 268.61,185.64 268.07,185.64 267.87,185.43 267.06,185.43 267.06,185.52 266.47,185.52 266.31,185.68 266.31,185.97 266.48,186.13 267.58,186.13 267.95,186.51 268.22,186.51
NVVDD on TOP (solid shape): 269.22,75.68 269.22,74.94 268.77,74.49 268.25,74.49 268.07,74.66 268.07,75.02 268.2,75.15 268.63,75.15 268.81,75.32 268.81,75.71 268.89,75.78 269.12,75.78
NVVDD on TOP (solid shape): outline of 418 points within 213.69,104.98 293.46,111.21
NVVDD on TOP (solid shape): outline of 7850 points within 226.07,135.09 249.56,158.3
NVVDD on BOTTOM (solid shape): outline of 105 points within 226.46,151.92 238.75,153.1
NVVDD on BOTTOM (solid shape): outline of 130 points within 213.95,104.93 293.26,111.14
NVVDD on BOTTOM (solid shape): outline of 6419 points within 218.08,127.1 257.19,158.06
NVVDD on IN1 (solid shape): outline of 146 points within 214.07,104.84 291.61,111.24
NVVDD on IN1 (solid shape): outline of 8133 points within 225.99,135.17 257.68,157.31
NVVDD on SGND1 (solid shape): outline of 2215 points within 213.49,104.99 287.96,157.82
NVVDD on IN2 (solid shape): outline of 389 points within 214.07,104.84 291.67,111.24
NVVDD on IN2 (solid shape): outline of 9405 points within 226.22,131.46 271.1,157.44
NVVDD on SVCC (solid shape): outline of 2139 points within 213.56,104.99 292.74,157.82
NVVDD on SVCC1 (solid shape): outline of 2090 points within 213.56,104.99 287.96,157.82
NVVDD on IN3 (solid shape): outline of 411 points within 214.07,104.84 291.67,111.24
NVVDD on IN3 (solid shape): outline of 16837 points within 217.88,127.33 270.14,158
NVVDD on IN4 (solid shape): outline of 413 points within 214.07,104.84 291.67,111.24
NVVDD on IN4 (solid shape): outline of 14519 points within 219.64,125.37 277.76,157.66
NVVDD_CORE1 on BOTTOM (solid shape): 254.79,118.58 254.79,117.29 254.21,116.7 249.46,116.7 249.44,116.71 249.28,116.86 249.09,116.91 248.93,116.87 248.78,116.76 248.76,116.76 247.83,116.76 247.78,116.7 247.32,116.7 247.29,116.73 247.29,117.08 247.63,117.43 247.91,117.43 248.18,117.7 250.35,117.7 250.77,117.87 253.5,117.87 253.72,118.1 253.72,118.78 253.8,118.86 254.51,118.86
NVVDD_PG_LOOP_OVT on BOTTOM (solid shape): 258.28,118.02 258.28,117.62 258.15,117.49 257.37,117.49 257.32,117.5 257.29,117.5 257.25,117.5 257.2,117.49 257.1,117.49 256.87,117.26 256.87,117.11 256.52,116.75 256.16,116.75 255.96,116.55 255.96,116.54 255.96,116.09 255.96,116.09 255.96,115.48 255.93,115.46 255.62,115.46 255.62,116.57 255.63,116.6 255.65,116.62 255.81,116.78 255.85,117.01 255.88,117.09 255.95,117.12 256.35,117.12 256.64,117.41 256.66,117.44 256.66,117.96 256.77,118.07 258.24,118.07
PCIE_WAKE# on BOTTOM (solid shape): 315.07,81.95 315.07,81.58 315.08,81.57 315.31,81.34 315.31,81.34 315.64,81.01 315.82,81.01 315.87,81.06 316.15,81.06 316.15,81.06 316.73,81.06 316.76,81.05 316.78,81.01 316.78,80.81 316.76,80.77 316.73,80.76 316.15,80.76 315.96,80.76 315.88,80.67 315.88,79.95 315.58,79.65 314.64,79.65 314.56,79.73 314.56,79.75 314.52,79.78 314.52,80.74 314.58,80.79 314.58,81.09 314.55,81.12 314.55,81.92 314.66,82.03 314.99,82.03
PD_LDO_1V5 on TOP (solid shape): 64.98,90.67 64.98,90.16 64.82,90.01 64.47,90.01 64.18,89.72 62.88,89.72 62.81,89.71 62.76,89.67 62.52,89.43 62.5,89.43 62.37,89.37 62.31,89.24 62.31,89.22 62.18,89.09 62.03,89.09 61.96,89.16 61.95,89.17 61.95,89.27 62.08,89.39 62.2,89.39 62.35,89.54 62.35,89.71 62.4,89.76 62.41,89.76 62.55,89.83 62.63,89.96 62.65,89.98 62.68,89.99 63.67,89.99 64.44,90.77 64.88,90.77
PD_LDO_3V3 on TOP (solid shape): 64.9,91.86 65.61,91.86 65.67,91.8 65.67,91.57 65.68,91.49 65.73,91.41 65.74,91.39 65.74,91.12 65.52,90.91 65.42,90.91 65.38,90.91 64.38,90.91 63.67,90.2 62.67,90.2 62.48,90.39 62.2,90.39 62.01,90.2 62.01,90.02 61.97,89.98 61.94,89.94 61.92,89.89 61.87,89.84 61.87,89.52 61.82,89.47 61.65,89.47 61.6,89.52 61.6,90.02 61.6,90.02 61.6,90.28 61.9,90.58 61.9,90.58 61.96,90.64 63.05,90.64 63.91,91.49 63.91,91.78 64.07,91.95 64.81,91.95
R_CTL on TOP (solid shape): 250.59,217.97 250.59,217.59 250.57,217.57 250.57,217.05 250.49,216.97 250.49,216.68 250.46,216.65 250,216.65 249.91,216.74 249.91,217.13 249.96,217.18 250.25,217.18 250.34,217.27 250.34,217.65 250.22,217.77 249.71,217.77 249.53,217.95 248.57,217.95 248.54,217.97 248.54,218.33 248.54,218.33 250.23,218.33
R_SPK+ on TOP (solid shape): 310.37,72.76 310.37,71.64 311.45,70.56 311.45,69.04 311.43,69.02 311.27,69.02 311.25,69.05 311.25,70.22 309.68,71.78 309.68,72.78 309.76,72.86 310.26,72.86
R_SPK+ on BOTTOM (solid shape): 262.54,48.61 262.54,47.42 262.41,47.29 261.5,47.29 261.34,47.45 261.34,48.6 261.38,48.64 262.51,48.64
R_SPK+ on IN4 (solid shape): 262.51,48.83 262.51,47.16 262.26,46.9 261.55,46.9 261.32,47.13 261.32,48.93 261.45,49.06 262.28,49.06
R_SPK+ on IN4 (solid shape): 310.39,72.89 310.39,71.45 310.37,71.43 310.24,71.24 310.19,71 310.17,70.97 310.14,70.96 309.55,70.96 309.4,71.11 309.4,72.59 309.8,72.99 310.29,72.99
R_SPK+_C on BOTTOM (solid shape): 261.49,46.82 262.31,46.82 262.31,46.14 262.11,45.94 262.11,44.31 261.98,44.18 261.34,44.18 261.3,44.23 261.3,46.73 261.41,46.84
R_SPK- on TOP (solid shape): 311.15,72.91 311.15,71.49 311.85,70.8 311.85,70.03 311.85,70.03 311.85,69.23 311.83,69.19 311.8,69.18 311.7,69.18 311.66,69.19 311.65,69.23 311.65,70.03 311.55,70.13 311.55,70.6 311.55,70.62 310.52,71.65 310.52,72.94 310.62,73.04 311.03,73.04
R_SPK- on BOTTOM (solid shape): 260.96,48.65 261,48.63 261.01,48.6 261.01,47.52 260.76,47.27 259.96,47.27 259.85,47.38 259.85,47.59 259.85,47.59 259.85,48.61 259.88,48.65
R_SPK- on IN4 (solid shape): 311.69,72.89 311.69,71.18 311.51,71.01 310.8,71.01 310.65,71.16 310.65,72.86 310.77,72.99 311.58,72.99
R_SPK- on IN4 (solid shape): 261.04,48.78 261.04,47.21 260.68,46.85 260,46.85 259.82,47.03 259.82,47.96 259.97,48.2 260.02,48.48 259.99,48.66 259.93,48.84 259.93,48.94 260.02,48.98 260.84,48.98
R_SPK-_C on BOTTOM (solid shape): 261.04,46.67 261.04,44.29 260.91,44.16 260.35,44.16 260.23,44.29 260.23,45.73 259.87,46.09 259.87,46.83 259.96,46.82 260.77,46.82 260.8,46.83 260.86,46.85
RINRVP on TOP (solid shape): 305.41,62.96 305.71,62.96 305.91,62.76 305.91,62.29 305.91,62.23 306.03,62.12 306.5,62.12 306.59,62.03 306.59,60.38 306.53,60.32 305.77,60.32 305.69,60.4 305.68,60.42 305.67,60.44 305.67,61.61 305.67,61.67 305.26,62.09 304.81,62.09 304.54,62.36 304.54,63.17 304.76,63.39 304.98,63.39
RIP on TOP (solid shape): 297.59,74.34 297.59,73.28 297.49,73.18 296.62,73.18 296.26,73.54 296.26,74.41 296.39,74.54 297.39,74.54
RIP on TOP (solid shape): 304.36,62.97 304.36,62.24 304.83,61.76 304.83,60.36 304.82,60.32 304.78,60.31 304.01,60.31 303.97,60.35 303.97,61.95 303.51,62.41 303.46,62.41 303.46,62.41 303.34,62.41 303.32,62.43 303.32,63.43 303.89,63.43
RIP on BOTTOM (solid shape): 298,74.04 298,72.89 299.28,71.61 299.28,66.63 299.88,66.03 303.27,66.03 304.03,65.26 304.03,63.31 304.5,62.84 304.5,62.3 304.39,62.19 303.99,62.19 303.55,62.63 303.55,63.05 302.16,64.44 302.16,64.5 301.95,64.71 299.34,64.71 298.07,65.98 298.07,71.36 296.37,73.06 296.37,74.41 296.39,74.43 296.39,74.44 296.53,74.57 297.47,74.57
RVN on TOP (solid shape): 299.49,74.56 299.49,74.22 299.33,74.06 299.05,74.06 298.88,74.23 298.13,74.23 298,74.36 298,75.21 298.06,75.27 298.78,75.27
RVN on TOP (solid shape): 305.6,64.2 305.6,63.88 305.83,63.65 306.18,63.65 306.27,63.74 306.51,63.74 306.57,63.68 306.57,63.29 306.46,63.18 305.5,63.18 305.16,63.52 305.16,63.85 305.16,63.87 304.91,64.13 303.78,64.13 303.77,64.14 303.77,64.32 303.79,64.33 303.83,64.33 303.83,64.33 304.82,64.33 304.82,64.33 304.85,64.33 304.94,64.42 305.38,64.42
RVN on IN3 (solid shape): 305.59,65.11 305.59,64.05 305.45,63.91 305.29,63.91 304.63,64.57 304.63,65.01 304.98,65.37 305.34,65.37
RVN on IN3 (solid shape): 299.49,74.45 299.49,73.88 299.46,73.8 299.39,73.78 299.37,73.78 299.12,73.67 299.01,73.42 299.03,73.32 299.07,73.22 299.08,73.12 298.99,73.06 298.28,73.06 298.24,73.09 298.24,74.07 298.81,74.63 299.32,74.63
S5_ON_R on TOP (solid shape): 55.6,71.17 55.6,70.45 55.6,70.35 55.51,70.26 55.51,70.24 55.46,70.18 55.46,69.87 55.69,69.64 56.02,69.64 56.25,69.87 56.25,70.21 56.17,70.29 56.17,70.42 56.2,70.45 56.2,71.17 56.21,71.18 56.39,71.18 56.4,71.16 56.4,70.45 56.49,70.36 56.49,69.16 56.39,69.06 56.24,69.06 56.23,69.07 55.47,69.07 55.34,69.2 54.91,69.2 54.71,69.01 54.23,69.01 54.03,69.21 54.03,69.27 53.98,69.36 53.89,69.4 53.5,69.4 53.46,69.4 53.41,69.37 53.41,69.67 53.48,69.74 54.61,69.74 54.7,69.74 55.4,70.44 55.4,71.18 55.42,71.2 55.57,71.2
SPKLN_L on BOTTOM (solid shape): 289.5,70.94 289.5,70.56 289.68,70.38 289.68,69.5 289.6,69.41 289.11,69.41 288.87,69.65 288.87,70.98 289.05,71.16 289.28,71.16
SPKLP_L on BOTTOM (solid shape): 288.08,74.94 288.08,73.52 288,73.44 287.64,73.44 287.17,73.91 287.17,74.96 287.26,75.05 287.97,75.05
SUSCLK_32K on TOP (solid shape): 219.53,54.5 220.71,54.5 220.9,54.31 220.9,53.86 220.78,53.74 220.49,53.74 220.01,54.22 219.21,54.22 218.57,54.86 218.18,54.86 218.15,54.89 218.15,55.24 218.19,55.28 218.76,55.28
SUSD on TOP (solid shape): 55.79,54.84 55.79,51.56 55.58,51.35 54.76,51.35 54.59,51.53 54.59,52.28 54.37,52.5 53.21,52.5 53.06,52.64 53.06,54.52 53.19,54.65 54.16,54.65 54.29,54.77 54.29,55.05 54.36,55.12 55.51,55.12
SX9310_GND1 on BOTTOM (solid shape): 272.77,53.87 272.77,52.22 272.28,51.73 269.95,51.73 269.73,51.96 269.73,52.5 269.74,52.54 269.78,52.56 269.92,52.56 269.95,52.54 269.97,52.5 269.97,52.33 270.49,52.33 270.57,52.25 270.95,52.25 271.03,52.33 271.55,52.33 271.55,53.67 271.03,53.67 270.95,53.75 270.57,53.75 270.49,53.67 269.97,53.67 269.97,53.5 269.95,53.46 269.92,53.44 269.78,53.44 269.74,53.46 269.73,53.5 269.73,53.87 269.74,53.9 269.89,54.05 269.94,54.22 269.95,54.24 270.14,54.43 272.2,54.43
SX9310_GND2 on BOTTOM (solid shape): 283.72,55.26 283.72,53.34 284.07,52.99 285.56,52.99 285.95,53.38 286.43,53.38 286.54,53.27 286.54,51.74 286.29,51.49 275.01,51.49 274.53,51.97 274.53,52.45 274.64,52.56 274.92,52.56 274.95,52.54 274.97,52.5 274.97,52.33 275.49,52.33 275.57,52.25 275.95,52.25 276.03,52.33 276.55,52.33 276.55,53.67 276.03,53.67 275.95,53.75 275.57,53.75 275.49,53.67 274.97,53.67 274.97,53.5 274.95,53.46 274.92,53.44 274.5,53.44 274.43,53.47 274.4,53.55 274.4,53.73 275.01,54.34 277.9,54.34 278.08,54.16 278.02,54.05 277.99,53.91 278.11,53.63 278.39,53.52 278.51,53.54 278.63,53.6 278.74,53.38 278.96,53.27 278.98,53.27 279.25,53 281.51,53 282.48,53.96 282.48,54.98 282.82,55.33 283.65,55.33
TBT1_CC1 on BOTTOM (solid shape): 12.23,92.64 12.51,92.64 12.51,92.63 12.65,92.63 13.28,92 13.28,91.72 13.21,91.65 13.2,91.64 13.12,91.6 13.05,91.55 13.03,91.54 13.01,91.53 12.84,91.53 12.63,91.74 11.94,91.74 11.9,91.79 11.9,92.22 11.8,92.32 11.8,92.63 11.82,92.65 12.21,92.65
TBT1_CC2 on BOTTOM (solid shape): 11.34,91.4 11.34,91.36 11.41,91.29 11.75,91.29 11.91,91.46 11.91,91.54 11.94,91.57 12.58,91.57 12.83,91.31 12.83,90.83 12.62,90.62 12.43,90.62 12.15,90.89 11.65,90.89 11.45,90.69 11.09,90.69 10.82,90.96 10.82,91.46 10.94,91.58 11.16,91.58
TBT2_CC1 on BOTTOM (solid shape): 12.84,78.59 12.84,77.86 12.75,77.77 11.92,77.77 11.92,77.77 11.79,77.77 11.69,77.87 11.69,78.05 11.41,78.33 11.41,78.59 11.49,78.67 12.75,78.67
TBT2_CC2 on BOTTOM (solid shape): 13.05,77.38 13.05,76.87 12.89,76.7 12.55,76.7 12.4,76.85 12.12,76.85 12.05,76.87 11.98,76.87 11.91,76.87 11.84,76.85 11.79,76.85 11.7,76.76 11.65,76.71 11.31,76.71 11.24,76.78 11.24,77.27 11.27,77.3 11.38,77.3 11.39,77.29 11.6,77.29 11.69,77.38 11.69,77.57 11.75,77.63 12.8,77.63
TPM_VDD on TOP (solid shape): 238.3,76.48 238.3,74.9 238.44,74.75 238.44,74.5 238.26,74.32 238.22,74.32 238.04,74.14 238.04,73.11 238.29,72.87 238.29,72.05 238.28,72.05 238.28,71.06 237.97,71.06 237.97,72.66 237.57,73.07 237.57,75.12 237.51,75.18 237.51,76.52 237.56,76.57 238.22,76.57
TPM_VDD on TOP (solid shape): 243.08,65.19 243.08,64.28 242.98,64.17 242.01,64.17 242,64.19 240.38,64.19 240.37,64.17 240.26,64.17 239.12,63.03 238.46,63.03 237.97,63.52 237.12,63.52 236.9,63.74 236.9,63.83 237.02,63.83 237.02,64.5 237.98,64.5 238.1,64.37 238.44,64.37 238.56,64.38 238.77,64.49 238.88,64.7 238.88,64.7 239.53,65.34 239.98,65.34 240.44,65.8 240.44,65.83 240.47,65.86 240.47,65.86 240.47,66.85 240.49,66.87 241.4,66.87
TYPEC1_USB0 on TOP (solid shape): 59.54,89.76 59.76,89.76 59.84,89.68 59.84,89.31 59.84,89.15 59.85,89.14 59.85,88.76 59.76,88.67 57.58,88.67 57.42,88.83 57.42,89.87 57.52,89.97 57.54,89.98 57.56,89.99 59.31,89.99
TYPEC1_USB0 on TOP (solid shape): 10.9,91.56 11.59,91.56 11.69,91.45 12.17,91.45 12.25,91.38 12.25,91.17 12.04,90.97 9.76,90.97 9.63,91.1 9.1,91.1 8.84,91.35 8.05,91.35 7.95,91.46 7.95,91.7 8.05,91.8 8.91,91.8 8.94,91.83 10.62,91.83
TYPEC1_USB0 on TOP (solid shape): 11.31,95.16 11.31,94.91 11,94.6 11,94.44 10.79,94.23 10.78,94.23 10.63,94.18 10.5,94.1 10.24,94.1 10.22,94.1 10.2,94.11 9.94,94.23 9.67,94.11 9.66,94.1 9.64,94.1 8.76,94.1 8.75,94.1 8.66,94.1 8.61,94.15 8.09,94.15 7.97,94.27 7.97,94.48 8.08,94.6 8.64,94.6 8.74,94.5 8.76,94.5 9.09,94.59 9.37,94.79 9.79,95.21 11.26,95.21
TYPEC1_USB0 on BOTTOM (solid shape): 14.74,100.93 14.74,98.51 14.48,98.26 12.25,98.26 12.24,98.27 12.16,98.3 12.07,98.31 11.98,98.3 11.9,98.27 11.89,98.26 11.18,98.26 10.93,98.51 10.93,100.93 11.17,101.18 14.49,101.18
TYPEC1_USB0 on IN1 (solid shape): outline of 4383 points within 7.94,88.63 61.45,101.16
TYPEC1_USB0 on IN2 (solid shape): outline of 4112 points within 7.95,88.63 61.45,101.16
TYPEC1_USB0 on SVCC (solid shape): outline of 967 points within 5.33,76.54 59.95,101.18
TYPEC2_USB0 on TOP (solid shape): 10.77,77.51 11.56,77.51 11.69,77.38 11.69,76.92 11.64,76.87 9.32,76.87 8.93,77.27 8.83,77.27 8.75,77.35 8.07,77.35 7.97,77.46 7.97,77.68 8.09,77.81 8.85,77.81 8.86,77.81 10.47,77.81
TYPEC2_USB0 on TOP (solid shape): 59.7,87.8 59.74,87.78 59.75,87.75 59.75,87.72 59.78,87.69 59.78,87.56 59.78,87.29 59.78,87.16 59.78,86.89 59.78,86.76 59.06,86.03 57.48,86.03 57.37,86.15 57.37,86.2 57.31,86.26 57.31,87.64 57.46,87.8
TYPEC2_USB0 on TOP (solid shape): 11.28,81.12 11.28,80.78 11.27,80.75 11.2,80.68 11.18,80.61 11.18,80.28 11.02,80.12 10.64,80.12 10.51,80.11 10.46,80.1 10.24,80.34 9.93,80.43 9.71,80.38 9.52,80.26 9.36,80.1 8.76,80.1 8.74,80.1 8.73,80.11 8.69,80.15 8.05,80.15 7.95,80.24 7.95,80.5 8.05,80.59 8.99,80.59 9,80.6 9.13,80.68 9.25,80.78 9.63,81.17 11.23,81.17
TYPEC2_USB0 on BOTTOM (solid shape): 11.86,73.62 13.08,73.62 13.31,73.39 13.31,71.39 13.08,71.16 9.13,71.16 8.85,71.44 8.85,72.2 9.07,72.42 9.07,72.99 9.71,73.62 11.76,73.62
TYPEC2_USB0 on IN1 (solid shape): outline of 599 points within 7.97,71.16 15.2,81.14
TYPEC2_USB0 on IN2 (solid shape): outline of 8550 points within 7.95,51.7 61.5,88.15
TYPEC2_USB0 on SVCC1 (solid shape): outline of 1867 points within 3.91,68.92 59.95,101.18
WLAN_CLKREQ# on TOP (solid shape): 284.65,74.11 284.71,74.04 284.78,73.98 284.84,73.92 284.84,73.7 284.61,73.47 284.09,73.47 284,73.38 284,72.65 284.05,72.6 284.05,72.59 284.32,72.32 285.35,72.32 285.67,72 285.67,71.46 285.45,71.24 283.9,71.24 282.88,72.26 282.88,72.87 282.88,72.89 282.95,72.96 283.5,72.96 283.61,73.06 283.61,73.22 283.61,73.22 283.61,73.89 283.85,74.13 284.63,74.13
WWAN_SAR# on BOTTOM (solid shape): 297.52,86.51 297.52,85.71 298.2,85.03 298.2,84.49 298.78,84.49 298.82,84.54 299.21,84.54 299.28,84.46 299.28,84.05 299.23,83.99 298.86,83.99 298.78,84.08 298.78,84.26 298.73,84.31 297.95,84.31 296.99,85.27 296.99,86.53 297.51,86.53
WWAN_SIM1_PWR on BOTTOM (solid shape): 236.02,61.81 236.02,60.57 236.38,60.21 236.38,59.5 236.27,59.4 235.13,59.4 235.09,59.44 235.09,60.55 235.08,60.6 235.08,61.76 235.18,61.86 235.97,61.86
WWAN_SIM1_PWR on IN2 (solid shape): outline of 111 points within 243.11,58.6 309.88,90.73
N84238 on TOP (solid shape): 257.15,66.74 257.15,62.37 256.76,61.99 256.29,61.99 255.63,61.33 254.46,61.33 254.28,61.51 254.28,62.64 255.07,63.43 255.07,66.71 255.29,66.93 256.96,66.93
N84238 on BOTTOM (solid shape): 258.12,63.92 258.12,62.39 258.04,62.31 257.09,62.31 256.75,62.65 255.48,62.65 255.41,62.72 255.43,62.76 255.44,62.79 255.44,63.17 255.41,63.25 255.32,63.28 255.08,63.52 255.08,64.09 255.13,64.15 255.4,64.15 257.89,64.15
N19106721 on BOTTOM (solid shape): 111.89,194.04 111.89,192.7 111.97,192.63 115.82,192.63 115.95,192.49 115.95,187.4 115.86,187.31 112.05,187.31 111.89,187.47 111.89,191.73 111.58,192.04 111.58,192.18 111.21,192.55 111.21,194.06 111.22,194.07 111.86,194.07
N19107009 on BOTTOM (solid shape): 121.54,194.03 121.54,192.72 121.67,192.6 125.45,192.6 125.61,192.44 125.61,187.42 125.51,187.32 121.74,187.32 121.54,187.52 121.54,191.73 120.65,192.62 120.65,193.99 120.74,194.08 121.49,194.08
N19107293 on BOTTOM (solid shape): 150.5,194.07 150.5,192.78 150.63,192.65 154.4,192.65 154.56,192.49 154.56,187.48 154.47,187.39 152.74,187.39 152.73,187.39 150.64,187.39 150.5,187.52 150.5,191.73 149.61,192.62 149.61,193.89 149.61,193.9 149.61,194.05 149.67,194.11 150.46,194.11
N19107637 on BOTTOM (solid shape): 131.19,194.06 131.19,192.75 131.34,192.6 135.13,192.6 135.26,192.47 135.26,187.45 135.12,187.32 131.34,187.32 131.19,187.46 131.19,191.73 130.31,192.62 130.31,194.02 130.38,194.09 131.16,194.09
N19108408 on BOTTOM (solid shape): 160.15,193.89 160.15,192.72 160.27,192.59 164.07,192.59 164.21,192.45 164.21,187.43 164.13,187.35 160.35,187.35 160.15,187.54 160.15,191.73 159.26,192.62 159.26,193.89 159.39,194.02 160.02,194.02
N19109248 on BOTTOM (solid shape): 140.85,194.02 140.85,192.69 140.93,192.61 144.74,192.61 144.91,192.44 144.91,187.43 144.8,187.32 140.95,187.32 140.85,187.42 140.85,191.73 139.96,192.62 139.96,194.03 140.01,194.08 140.78,194.08
N19174209 on TOP (solid shape): 168.64,215.81 168.64,215.57 168.52,215.44 167.99,215.44 167.7,215.15 167.7,214.98 167.56,214.84 166.48,214.84 166.45,214.86 166.45,215.57 166.46,215.62 166.46,215.66 166.46,215.7 166.45,215.75 166.45,216.55 166.5,216.6 167.85,216.6
N19174209 on BOTTOM (solid shape): 168.8,215.7 168.8,214.82 168.96,214.66 168.96,214.12 168.91,214.07 168.1,214.07 167.61,214.56 167.61,215.21 167.45,215.37 167.45,215.64 167.78,215.97 168.52,215.97
N19174211 on TOP (solid shape): 169.56,215.09 169.56,214.77 169.42,214.64 169.21,214.64 168.8,214.22 168.8,213.32 168.54,213.05 168.3,213.06 168.02,213.05 168.02,213.05 167.64,213.05 167.49,213.2 167.49,213.54 167.3,213.73 166.37,213.73 166.14,213.5 165.89,213.5 165.86,213.52 165.86,213.86 165.93,213.92 165.97,213.92 165.99,213.94 166.01,213.94 166.27,214.03 166.4,214.27 166.4,214.29 166.43,214.32 166.53,214.42 167.89,214.42 168.07,214.6 168.07,215.19 168.08,215.21 168.09,215.23 168.16,215.3 168.58,215.3 168.68,215.4 169.25,215.4
N19174211 on BOTTOM (solid shape): 170.9,215.63 170.9,214.97 170.62,214.69 169.29,214.69 169.02,214.95 169.02,215.23 169.5,215.71 170.82,215.71
N19201693 on BOTTOM (solid shape): 126.57,217.35 126.57,216.21 126.64,216.14 126.64,215.82 126.63,215.76 126.63,215.46 126.64,215.4 126.64,214.81 126.62,214.64 126.62,214.59 126.62,214.54 126.64,214.32 126.62,214.3 126.06,214.3 126.02,214.26 125.86,214.26 125.58,213.98 125.58,213.38 125.53,213.33 125.01,213.33 124.96,213.38 124.96,215.04 125.06,215.15 125.67,215.15 125.75,215.22 125.75,215.81 125.66,215.9 125.66,216.16 125.73,216.24 125.73,217.34 125.9,217.51 126.41,217.51
N19940963 on BOTTOM (solid shape): 180.98,47.59 180.98,46.83 180.24,46.09 178.67,46.09 178.44,45.86 178.44,43.83 178.16,43.55 172.49,43.55 171.91,42.97 171.91,41.54 171.3,40.93 166.4,40.93 166.32,41.01 166.32,45.25 166.4,45.33 168.07,45.33 169.34,46.6 170.75,46.6 170.76,46.57 170.8,46.52 170.86,46.5 171.24,46.5 171.29,46.52 171.33,46.57 171.34,46.6 172.88,46.6 172.91,46.58 172.94,46.58 173.32,46.58 173.35,46.58 173.46,46.6 173.54,46.67 173.54,47.23 173.66,47.36 176.38,47.36 176.68,47.65 176.71,47.65 179.91,47.65 179.96,47.66 180,47.68 180.89,47.68
N19940986 on BOTTOM (solid shape): 163.59,53.52 163.59,52.97 164.17,52.39 165.31,52.39 165.51,52.59 165.51,53.07 165.52,53.09 165.52,53.26 165.66,53.4 169.04,53.4 169.24,53.2 169.53,53.2 169.55,53.2 169.57,53.18 169.87,53.04 170.18,53.18 170.2,53.2 170.22,53.2 171.05,53.2 171.22,53.03 171.25,52.95 171.21,52.88 171.09,52.74 171.05,52.56 171.16,52.28 171.44,52.16 171.55,52.18 171.66,52.23 171.76,52.23 171.81,52.14 171.81,50.79 171.66,50.64 169.01,50.64 168.74,50.36 168.74,49.7 168.53,49.49 167.69,49.49 167.52,49.67 167.52,50.13 167.49,50.15 165.59,50.15 165.23,49.8 165.23,48.93 165.12,48.82 163.14,48.82 163.13,48.82 163.03,48.82 162.89,48.96 162.89,53.53 162.97,53.61 163.06,53.61 163.09,53.64 163.47,53.64
N19941069 on BOTTOM (solid shape): 150.36,54.17 150.36,49.18 150.27,49.1 150.05,49.1 149.83,49.32 149.83,50.27 149.69,50.41 146.31,50.41 145.81,49.9 145.3,49.9 144.94,49.55 144.44,49.55 144.31,49.68 144.31,49.98 143.98,50.31 141.07,50.31 140.65,50.72 140.65,51.59 140.74,51.67 143.5,51.67 144.25,52.43 144.25,53.29 144.53,53.57 147.84,53.57 148.65,54.37 150.16,54.37
N19941106 on BOTTOM (solid shape): 136.75,48.9 136.75,48.1 136.75,47.52 136.68,47.49 136.65,47.42 136.65,47.04 136.68,46.97 136.75,46.94 136.75,46.92 136.92,46.74 137.2,46.74 137.24,46.69 137.28,46.65 137.42,46.54 137.59,46.51 137.71,46.53 137.82,46.58 138.01,46.39 138.01,45.75 138.3,45.46 139.98,45.46 140.27,45.75 140.27,46.65 140.57,46.95 143.71,46.95 144.02,47.26 146.99,47.26 147.4,46.85 147.4,41.36 147.07,41.03 142.37,41.03 141.2,42.21 136.21,42.21 135.54,42.88 135.54,46.22 135.58,46.26 136.09,46.26 136.3,46.47 136.3,48.9 136.33,48.93 136.71,48.93
N20974301 on BOTTOM (solid shape): 200.99,96.41 200.99,94.91 201.16,94.73 202.66,94.73 202.83,94.56 202.83,94.37 202.97,94.23 203.66,94.23 203.77,94.12 203.77,92.24 203.41,91.89 200.54,91.89 200.43,91.99 200.43,92.67 200.26,92.85 200,92.85 199.74,93.11 199.74,96.6 199.82,96.69 200.71,96.69
N20974305 on BOTTOM (solid shape): 201.29,89.61 201.29,87.37 201.22,87.3 200.04,87.3 199.11,88.23 199.11,89.62 199.22,89.73 201.17,89.73
N21715576 on TOP (solid shape): 130.11,71.87 130.31,71.87 130.31,72.58 130.5,72.58 130.51,72.57 130.51,71.86 130.2,71.54 128.63,71.54 128.58,71.49 128.58,70.22 128.48,70.12 126.95,70.12 126.8,70.27 126.8,71.64 127.43,72.28 129.59,72.28 129.9,72.58 130.11,72.58
N21715582 on TOP (solid shape): 132.11,71.87 132.31,71.87 132.31,72.58 132.82,72.58 133.2,72.2 135.21,72.2 135.65,71.76 135.65,71.76 135.78,71.64 138.02,71.64 138.18,71.48 138.18,70.55 137.93,70.3 134.65,70.3 134.55,70.4 134.55,71.18 134.37,71.36 132.62,71.36 132.24,71.74 132.04,71.74 131.91,71.86 131.91,72.56 131.93,72.58 132.11,72.58
N21715612 on TOP (solid shape): 136.15,76.14 136.15,74.51 135.85,74.21 132.85,74.21 132.52,73.88 132.31,73.88 132.31,74.59 132.11,74.59 132.11,73.88 131.92,73.88 131.91,73.89 131.91,76.27 132.06,76.42 135.88,76.42
N21715657 on TOP (solid shape): 129.72,76.52 129.72,75.38 130.1,75 130.23,75 130.51,74.72 130.51,73.89 130.5,73.88 130.31,73.88 130.31,74.59 130.11,74.59 130.11,73.88 129.78,73.88 129.43,74.23 127.51,74.23 127.31,74.44 127.31,74.72 127.51,74.92 128.27,74.92 128.6,75.25 128.6,76.42 128.88,76.7 129.54,76.7
N21716526 on TOP (solid shape): 143.83,70.99 144.03,70.99 144.03,71.69 144.21,71.69 144.23,71.67 144.23,70.74 143.99,70.5 142.45,70.5 142.12,70.17 142.12,69.41 141.99,69.28 138.66,69.28 138.48,69.46 138.48,70.37 138.5,70.38 138.48,70.4 138.48,71.21 138.69,71.41 143.29,71.41 143.57,71.69 143.83,71.69
N21716532 on TOP (solid shape): 145.83,70.99 146.03,70.99 146.03,71.69 146.31,71.69 146.74,71.26 150.56,71.26 151.49,70.34 151.49,69.33 151.34,69.18 147.96,69.18 147.81,69.33 147.81,70.3 147.63,70.47 146.01,70.47 145.63,70.86 145.63,71.68 145.64,71.69 145.83,71.69
N21716562 on TOP (solid shape): 149.48,75.43 149.48,74.56 148.68,73.76 148.68,73.51 148.49,73.32 146.64,73.32 146.31,72.99 146.03,72.99 146.03,73.7 145.83,73.7 145.83,72.99 145.63,72.99 145.63,73 145.63,74.16 145.62,74.16 145.62,75.4 145.77,75.55 149.36,75.55
N21716605 on TOP (solid shape): 143.78,75.03 143.78,74.22 144.23,73.77 144.23,73.01 144.21,72.99 144.03,72.99 144.03,73.7 143.83,73.7 143.83,72.99 143.51,72.99 143.16,73.34 140.2,73.34 139.98,73.57 139.98,75.35 140.06,75.43 143.39,75.43
N23334329 on BOTTOM (solid shape): 120.63,48.49 120.63,46.67 120.49,46.53 119.63,46.53 119.54,46.63 119.54,47.4 119.94,47.81 119.94,48.44 120.05,48.54 120.58,48.54
N23334555 on TOP (solid shape): 132.83,39.67 132.83,38.83 132.69,38.68 128.99,38.68 128.94,38.74 128.94,39.32 128.98,39.37 128.98,39.62 129,39.65 131.47,39.65 131.54,39.72 132.79,39.72
N24995566 on BOTTOM (solid shape): 108.55,131.81 108.55,128.52 108.46,128.43 107.37,128.43 107.22,128.58 107.22,131.81 107.35,131.94 108.41,131.94
N24995570 on BOTTOM (solid shape): 108.3,135.73 108.3,133.52 108.07,133.29 107.44,133.29 107.3,133.44 107.3,135.28 107.39,135.37 107.39,135.61 107.6,135.83 108.2,135.83
N24995581 on BOTTOM (solid shape): 110.66,134.92 110.66,134.51 110.21,134.07 110.21,133.37 110.06,133.22 109.38,133.22 109.23,133.37 109.23,135.22 109.32,135.32 109.92,135.32 109.94,135.32 110.26,135.32
N25272043 on TOP (solid shape): 263.8,68.77 263.8,67.58 263.72,67.5 263.08,67.5 262.88,67.3 261.79,67.3 261.68,67.41 261.68,68.2 261.69,68.2 261.69,68.83 261.79,68.93 263.64,68.93
N25272083 on TOP (solid shape): 265.88,67.1 266.13,67.1 266.14,67.1 267.06,67.1 267.06,67.1 267.69,67.1 267.76,67.03 267.76,66.19 267.1,65.52 267.1,63.68 267.01,63.59 266.65,63.59 266.47,63.77 266.47,63.97 266.09,64.35 264.93,64.35 264.83,64.44 264.83,64.6 265.53,64.6 265.53,64.85 264.83,64.85 264.83,65.15 264.8,65.19 264.8,66.92 265.13,67.25 265.73,67.25
N25272083 on BOTTOM (solid shape): 266.1,66.78 266.1,64.87 265.79,64.56 264.72,64.56 264.56,64.71 264.56,65.32 264.91,65.67 264.91,67.13 265.03,67.25 265.64,67.25
N25430994 on TOP (solid shape): 61.32,67.58 61.32,64.76 61.12,64.56 58.8,64.56 58.73,64.63 58.73,65.6 58.8,65.67 59.39,65.67 59.67,65.95 59.67,67.5 59.79,67.63 61.27,67.63
N25506978 on TOP (solid shape): 59.37,54.08 59.37,51.18 61.25,49.3 61.25,47.7 61.09,47.55 60.05,47.55 59.92,47.68 59.92,48.68 59.66,48.94 57.38,48.94 57.24,49.08 57.24,49.74 56.67,50.31 56.67,51.31 56.7,51.33 57.38,51.33 57.56,51.51 57.56,51.75 57.98,52.16 57.98,54.21 58.08,54.31 59.14,54.31
N25507004 on TOP (solid shape): 65.39,51.08 65.39,49.95 65.25,49.82 61.08,49.82 61.02,49.87 61.02,50.6 61.11,50.7 62.74,50.7 62.85,50.81 62.86,50.82 62.96,50.89 63.03,50.99 63.03,50.99 63.27,51.23 65.24,51.23
N31996495 on BOTTOM (solid shape): 305.06,65.04 305.06,64.54 305.06,64.53 305.05,64.51 304.91,64.37 304.91,63.94 305.16,63.69 307.05,63.69 307.21,63.53 307.21,62.96 307.12,62.87 304.73,62.87 304.58,63.02 304.58,63.61 304.34,63.85 304.34,64.96 304.5,65.12 304.98,65.12
N36119404 on TOP (solid shape): 203.51,102.3 203.51,100.74 201.98,99.2 201.63,99.2 201.5,99.07 200.86,99.07 200.59,98.79 199.83,98.79 199.31,99.32 199.31,100.79 199.58,101.06 200.52,101.06 200.66,101.2 200.66,101.76 200.56,101.86 200.56,101.86 200.52,101.9 200.27,101.9 200.24,101.92 200.24,102.34 200.67,102.77 203.04,102.77
N36119404 on BOTTOM (solid shape): 199.76,101.79 199.85,101.75 199.86,101.65 199.84,101.58 199.83,101.51 200.22,101.11 200.62,101.51 200.61,101.58 200.59,101.65 200.6,101.75 200.68,101.79 201.65,101.79 201.88,101.56 201.88,98.77 201.63,98.51 198.94,98.51 198.45,99 198.45,101.46 198.78,101.79
N36392478 on BOTTOM (solid shape): 306.34,62.25 306.34,61.87 306.34,61.87 306.34,61.73 306.6,61.47 307.53,61.47 307.6,61.39 307.6,60.78 307.46,60.64 307.46,60.39 307.35,60.28 306.6,60.28 306.47,60.4 306.47,60.66 305.88,61.25 304.96,61.25 304.87,61.34 304.87,62.27 305,62.39 306.2,62.39
N53565581 on TOP (solid shape): 287.92,80.67 287.92,79.2 287.71,78.98 285.94,78.98 285.89,79.04 285.89,79.57 285.98,79.67 287.33,79.67 287.51,79.85 287.51,80.61 287.58,80.68 287.91,80.68
N53716068 on TOP (solid shape): 83.19,95.8 83.19,94.37 83.65,93.92 83.65,92.59 83.31,92.25 82.32,92.25 81.94,92.64 81.94,95.77 82.02,95.85 83.14,95.85
N53716070 on TOP (solid shape): 85.14,92.58 85.14,91.9 85.02,91.78 84.06,91.78 83.89,91.6 83.89,90.02 84.09,89.83 84.09,88.79 84.08,88.79 84.68,88.19 86.09,88.19 86.16,88.11 86.16,87.16 86.01,87.02 84.26,87.02 82.8,88.47 82.8,91.55 83.9,92.64 85.07,92.64
N53788150 on TOP (solid shape): 258.28,213.75 258.28,213.16 258.78,212.66 260.39,212.66 260.49,212.56 260.49,212.1 260.41,212.03 259.44,212.03 259.18,211.77 258.7,211.77 258.66,211.81 258.66,212.37 258.19,212.84 257.61,212.84 257.49,212.97 257.49,213.77 257.56,213.84 258.19,213.84
N53789031 on TOP (solid shape): 258.45,216.8 258.45,215.55 258.48,215.52 258.48,215.1 258.43,215.04 257.98,215.04 257.95,215.07 257.95,215.99 257.67,216.28 255.92,216.28 255.81,216.39 255.81,217.05 255.9,217.15 258.1,217.15
N56077694 on BOTTOM (solid shape): outline of 405 points within 17.22,2.03 22.25,10.39
N56077756 on TOP (solid shape): 26.63,11.07 26.63,10.09 26.63,10.08 26.63,9.97 26.71,9.89 26.71,9.39 26.63,9.31 24.3,9.31 24.13,9.48 24.13,10.15 24.3,10.32 24.99,10.32 25.8,11.14 26.56,11.14
N56085203 on TOP (solid shape): 19.3,45.11 19.95,45.11 20.03,45.03 20.03,43.71 19.71,43.39 18.71,43.39 18.55,43.22 18.55,42.43 18.49,42.38 17.48,42.38 17.37,42.27 17.1,42.27 17.03,42.34 17.03,42.51 17.03,42.89 17.03,42.96 17.04,42.98 17.05,42.99 17.09,43.03 17.12,43.08 18.34,44.29 18.34,45 18.44,45.11 19.3,45.11
N56249956 on TOP (solid shape): 22.54,47.43 23.35,47.43 23.49,47.44 23.59,47.33 23.59,46.73 23.22,46.36 23.2,46.32 23.18,46.28 23.17,46.25 23.16,46.21 23.16,45.7 21.79,44.33 21.79,43.72 21.74,43.67 21.17,43.67 21.1,43.74 21.1,45.52 22.09,46.51 22.09,47.3 22.23,47.44
N56250018 on TOP (solid shape): 21.74,50.34 21.74,50.07 21.74,49.25 21.74,49.2 21.4,48.85 21.39,48.78 21.39,48.4 21.4,48.33 21.41,48.31 21.43,48.26 21.46,48.23 21.47,48.21 21.61,48.07 21.63,48.06 21.67,48.03 21.72,48.01 21.81,47.92 21.81,46.44 21.62,46.25 20.87,46.25 19.73,46.25 19.08,46.25 18.94,46.39 18.94,47.23 20.37,47.23 20.37,47.17 20.38,47.11 20.39,47.06 20.42,47.01 20.45,46.96 20.48,46.92 20.53,46.88 20.57,46.85 20.62,46.83 20.68,46.81 20.73,46.8 20.79,46.8 20.85,46.81 20.9,46.83 20.95,46.85 21,46.88 21.04,46.92 21.08,46.96 21.11,47.01 21.13,47.06 21.15,47.11 21.16,47.17 21.16,47.23 21.15,47.28 21.13,47.33 21.11,47.39 21.08,47.43 21.04,47.48 21,47.51 20.95,47.54 20.9,47.57 20.85,47.58 20.79,47.59 20.73,47.59 20.68,47.58 20.62,47.57 20.57,47.54 20.53,47.51 20.48,47.48 20.45,47.43 20.42,47.39 20.39,47.33 20.38,47.28 20.37,47.23 18.94,47.23 18.94,47.51 20.82,49.38 20.82,50.31 20.91,50.41 21.67,50.41
N56276780 on TOP (solid shape): 303.94,100.5 303.94,99.86 303.84,99.76 302.97,99.76 302.69,99.48 302.69,98.59 302.47,98.36 302.14,98.36 302.09,98.41 302.09,100.06 302.34,100.32 302.67,100.32 302.92,100.57 303.86,100.57
N56849294 on TOP (solid shape): 271.4,80.6 271.4,79.23 271.42,79.15 271.48,79.1 271.49,79.09 272.16,78.42 272.16,76.37 272.54,75.99 272.54,75.79 272.55,75.79 272.55,74.36 272.55,74.36 272.55,73.67 272.51,73.64 272.25,73.64 272.24,73.62 271.53,73.62 271.5,73.65 271.5,75.4 271.28,75.63 270.94,75.63 270.79,75.78 270.79,78.7 270.7,78.8 270.67,78.84 270.61,78.88 270.44,78.88 270.21,79.11 270.21,80.58 270.28,80.66 271.4,80.66
N56881941 on TOP (solid shape): 25.5,13.38 25.99,13.38 26.12,13.25 26.12,12.88 25.88,12.65 25.63,12.65 24.91,11.93 24.91,11.93 24.84,11.86 24.84,11.78 24.81,11.74 24.74,11.67 24.41,11.67 24.35,11.73 24.35,12.44 24.12,12.66 23.15,12.66 23.03,12.79 23.03,13.29 23.12,13.38 25.5,13.38
N59747615 on TOP (solid shape): 68.53,63.39 68.53,61.13 68.38,60.97 65.74,60.97 65.61,61.1 65.61,62.07 65.33,62.35 65.33,63.46 65.41,63.54 68.38,63.54
N59747617 on TOP (solid shape): 70.06,67.5 70.06,66.14 70.38,65.82 70.38,64.8 69.85,64.28 68.25,64.28 68.13,64.4 68.13,67.5 68.25,67.63 69.93,67.63
N60121159 on TOP (solid shape): 185.4,192.11 185.4,189.35 185.14,189.09 183.44,189.09 183.16,189.37 183.16,192.27 183.39,192.49 185.02,192.49
N60121159 on BOTTOM (solid shape): 183.34,195.57 183.34,195.21 183.47,195.09 183.8,195.09 183.95,194.93 183.95,194.04 184.46,193.54 184.46,192.8 184.84,192.42 185.85,192.42 186.01,192.27 186.01,189.12 185.89,189 183.66,189 183.21,189.45 183.21,189.7 182.73,190.18 182.3,190.18 182.22,190.26 182.22,193.51 182.63,193.92 182.63,195.09 182.5,195.21 181.87,195.21 181.79,195.29 181.79,195.85 181.84,195.9 183.01,195.9
N60121164 on TOP (solid shape): 55.63,42.76 55.63,40.22 55.25,39.84 51.35,39.84 51.18,40.01 51.18,42.9 51.3,43.02 55.38,43.02
N60121164 on BOTTOM (solid shape): 56.15,50.44 56.17,50.44 56.59,50.44 56.59,49.8 56.37,49.58 56.37,44.92 57.16,44.12 57.16,39.96 56.97,39.76 52.2,39.76 52.19,39.78 51.38,39.78 51.23,39.92 51.23,46.63 52.3,47.69 53.31,47.69 53.95,48.34 53.95,49.92 54.49,50.46 56.11,50.46
N60121246 on TOP (solid shape): 53.15,39.31 53.15,38.28 53.06,38.19 50.88,38.19 50.75,38.33 50.75,39.21 50.95,39.42 53.05,39.42
N60121271 on TOP (solid shape): 181.59,190.82 181.59,188.74 179.78,186.93 179.78,182.69 179.23,182.13 176.81,182.13 176.53,182.41 176.53,184.44 176.17,184.81 176.17,188.13 175.72,188.58 175.72,191.08 176.28,191.64 180.76,191.64
N60121271 on BOTTOM (solid shape): 181.59,193.82 181.59,188.74 180.83,187.97 180.83,187.69 179.78,186.65 179.78,182.69 179.44,182.35 179.44,182.35 179.37,182.32 179.34,182.25 179.33,182.24 179.33,181.83 179.28,181.78 178.78,181.78 178.51,182.05 176.8,182.05 176.53,182.31 176.53,184.44 176.14,184.83 176.14,188.2 175.72,188.63 175.72,191.8 176.01,192.09 176.01,192.7 177.01,193.71 177.01,193.97 177.14,194.1 181.31,194.1
N60121443 on TOP (solid shape): 30.8,41.14 30.9,41.08 31,41.05 31.01,41.04 31.01,39.8 30.87,39.67 29.44,39.67 29.25,39.86 29.25,40.42 29.32,40.49 29.53,40.49 29.6,40.56 29.63,40.58 29.65,40.61 29.76,40.72 29.76,41.08 29.85,41.17 30.77,41.17
N60121443 on BOTTOM (solid shape): 31.34,40.66 31.34,39.65 31.26,39.58 29.46,39.58 29.39,39.66 29.39,40.63 29.44,40.68 29.45,40.69 29.47,40.7 31.3,40.7
N60121455 on BOTTOM (solid shape): 31.58,46.73 31.58,45.35 31.37,45.14 30.25,45.14 29.9,45.5 29.37,45.5 29.27,45.6 29.27,46.69 29.35,46.76 30.48,46.76 30.48,46.77 31.54,46.77
N60121483 on TOP (solid shape): 43.76,47.73 43.76,45.57 43.68,45.49 42.79,45.49 42.61,45.67 42.61,46.57 42.31,46.87 42.31,47.85 42.38,47.91 43.57,47.91
N60415319 on BOTTOM (solid shape): 218.75,197.42 219.59,197.42 219.66,197.5 220.25,197.5 220.35,197.4 220.35,197.04 220.27,196.97 218.95,196.97 218.65,196.66 218.65,195.85 218.6,195.8 217.91,195.8 217.83,195.87 217.83,196.94 217.53,196.94 217.48,196.99 217.48,197.63 217.55,197.7 218.47,197.7
N60415324 on BOTTOM (solid shape): 217.68,196.25 217.68,194.55 217.5,194.37 216.92,194.37 216.89,194.4 216.89,195.29 217.1,195.49 217.1,196.2 217.22,196.33 217.6,196.33
N60415329 on TOP (solid shape): 219.26,203.21 219.26,201.46 219.79,200.93 220.78,200.93 220.86,200.85 220.86,198.44 220.45,198.03 217.38,198.03 217.3,198.11 217.3,198.44 217.15,198.59 216.41,198.59 216.21,198.79 216.21,203.21 216.28,203.29 219.18,203.29
N60415329 on BOTTOM (solid shape): 219.26,203.21 219.26,201.46 219.79,200.93 220.78,200.93 220.86,200.85 220.86,197.73 220.81,197.68 219.03,197.68 218.98,197.73 218.98,197.98 218.93,198.03 217.38,198.03 217.3,198.11 217.3,198.44 217.15,198.59 216.41,198.59 216.21,198.79 216.21,203.21 216.28,203.29 219.18,203.29
N60415356 on BOTTOM (solid shape): 186.69,197.75 186.69,195.24 186.67,195.21 186.03,195.21 186,195.23 185.98,195.26 185.98,196.03 185.75,196.25 184.58,196.25 184.51,196.18 184.51,195.67 184.36,195.52 184.05,195.52 183.49,196.08 181.41,196.08 180.22,194.88 178.79,194.88 178.69,194.98 178.69,195.47 178.79,195.57 179.68,195.57 181.08,196.97 185.45,196.97 185.75,197.27 185.75,197.83 185.88,197.96 186.49,197.96
N60415361 on BOTTOM (solid shape): 179.23,196.69 179.23,195.82 179.17,195.77 178.77,195.77 178.67,195.87 178.67,196.18 178.16,196.69 177.65,196.69 177.55,196.79 177.55,197.52 177.65,197.63 178.29,197.63
N60415366 on TOP (solid shape): 187.02,203.24 187.02,202.65 187.23,202.45 187.23,201 187.61,200.62 188.24,200.62 188.34,200.52 188.34,195.39 187.96,195.01 187.28,195.01 187,195.29 187,197.98 186.54,198.44 186.01,198.44 185.8,198.64 185.8,203.16 185.98,203.34 186.92,203.34
N60415366 on BOTTOM (solid shape): 187.23,203.24 187.23,201 187.61,200.62 188.24,200.62 188.34,200.52 188.34,195.39 187.96,195.01 187.28,195.01 187,195.29 187,197.98 186.54,198.44 186.01,198.44 185.8,198.64 185.8,203.27 185.95,203.42 187.05,203.42
N60434578 on TOP (solid shape): 203.76,201.23 204.04,201.23 204.37,200.9 204.37,196.89 204.14,196.66 202.57,196.66 202.49,196.74 202.49,196.94 202.36,197.07 201.22,197.07 200.84,197.45 200.84,197.96 200.51,198.29 199.95,198.29 199.88,198.36 199.88,202.43 199.9,202.45 202.54,202.45
N60434578 on BOTTOM (solid shape): 202.85,201.94 202.85,201.28 203.1,201.03 204.09,201.03 204.37,200.75 204.37,196.89 204.14,196.66 202.57,196.66 202.49,196.74 202.49,196.94 202.36,197.07 201.22,197.07 200.84,197.45 200.84,197.96 200.51,198.29 199.95,198.29 199.88,198.36 199.88,202.43 199.9,202.45 202.34,202.45
N62866886 on TOP (solid shape): 143.56,212.59 143.56,211.09 143.49,211.01 143.08,211.01 142.88,211.21 142.88,212.59 143.03,212.74 143.41,212.74
N65858616 on TOP (solid shape): 231.75,205.58 231.75,205.14 231.7,205.09 230.28,205.09 230.2,205.17 230.2,205.45 230.3,205.55 230.86,205.55 231.07,205.75 231.57,205.75
N79287282 on TOP (solid shape): 256.14,55.94 256.61,55.94 256.63,55.94 256.66,55.91 256.66,55.69 256.64,55.66 256.6,55.64 256.15,55.64 256.15,55.44 256.6,55.44 256.64,55.43 256.66,55.39 256.66,55.11 256.62,55.07 255.89,55.07 255.4,55.57 253.19,55.57 253.11,55.65 253.11,55.91 253.15,55.96 256.12,55.96
N79287301 on TOP (solid shape): 253.31,56.77 253.36,56.77 253.6,56.53 253.6,56.14 253.55,56.1 252.93,56.1 252.86,56.02 252.86,55.74 252.65,55.54 252.63,55.53 252.61,55.52 252.14,55.52 252.13,55.52 250.92,55.52 250.85,55.58 250.85,56.14 250.92,56.21 251.47,56.21 251.85,56.59 252.19,56.93 253.15,56.93
N79447335 on TOP (solid shape): 249.05,112.61 249.43,112.61 249.46,112.58 249.48,112.47 249.39,112.41 249.16,112.41 249.16,112.21 249.53,112.21 249.57,112.2 249.58,112.16 249.58,111.49 249.46,111.37 248.31,111.37 248.21,111.47 248.21,112.54 248.54,112.87 248.8,112.87
N79449214 on BOTTOM (solid shape): 231.52,117.92 231.52,117.26 231.68,117.11 231.68,116.67 231.53,116.52 229.5,116.52 229.21,116.81 229.21,117.74 229.44,117.97 231.47,117.97
N79575434 on TOP (solid shape): 242.58,113.1 242.62,113.09 242.63,113.05 242.63,112.59 242.83,112.59 242.83,113.05 242.84,113.09 242.88,113.1 243.1,113.1 243.14,113.06 243.14,112.31 243.11,112.28 243.11,112.21 243.11,111.87 243.03,111.8 242.22,111.8 242.17,111.85 242.17,112.21 242.34,112.38 242.34,113.08 242.37,113.1
N79667727 on TOP (solid shape): 241.1,114.19 241.1,113.05 240.69,113.05 240.59,113.01 240.55,112.91 240.55,112.88 240.46,112.79 240.16,112.79 240.11,112.84 240.11,113.48 240.52,113.88 240.52,114.19 240.57,114.24 241.05,114.24
N79956292 on TOP (solid shape): 233.73,44.41 233.73,37.45 233.63,37.35 233.02,37.35 232.91,37.35 232.69,37.57 232.69,37.78 232.49,37.99 230.61,37.99 230.15,38.44 227.16,38.44 227.08,38.37 226.06,38.37 224.54,39.89 223.75,39.89 223.68,39.95 223.68,40.89 223.81,41.02 227.32,41.02 227.82,41.52 227.82,44.08 228.4,44.67 233.48,44.67
N79956292 on BOTTOM (solid shape): 233.73,44.41 233.73,37.45 233.63,37.35 233.02,37.35 231.93,38.44 227.16,38.44 227.08,38.37 226.05,38.37 225.8,38.62 225.8,41.71 225.77,41.73 225.76,41.77 225.77,41.81 226.05,42.08 227.16,42.08 227.66,42.58 227.66,43.52 228.81,44.67 233.48,44.67
N79956312 on TOP (solid shape): 236.88,37.89 236.88,36.29 236.78,36.19 235.11,36.19 235.07,36.23 235.07,36.9 235.6,37.44 235.6,37.93 235.66,37.99 236.78,37.99
N79966658 on TOP (solid shape): 285.43,84.68 285.43,82.85 285.24,82.66 283.08,82.66 282.96,82.78 282.96,83.09 282.98,83.15 282.98,83.21 282.98,83.28 282.96,83.34 282.96,84.57 283.16,84.77 285.34,84.77
N79966696 on TOP (solid shape): 283.21,86.78 283.28,86.74 283.31,86.66 283.31,86.64 283.31,86.26 283.31,86.22 283.33,86.18 283.33,85.13 283.27,85.07 282.89,85.07 282.6,84.78 282.6,84.03 282.43,83.86 281.4,83.86 281.3,83.97 281.3,84.86 281.7,85.26 281.7,86.73 281.71,86.76 281.75,86.78
N79966767 on TOP (solid shape): 281.29,87.17 281.29,86.27 281.19,86.16 280.53,86.16 280.01,85.65 279.69,85.65 279.64,85.69 279.64,85.7 279.66,85.74 279.67,85.78 279.67,86.16 279.66,86.2 279.64,86.24 279.64,87.19 279.8,87.34 281.12,87.34
N80539359 on BOTTOM (solid shape): 286.01,200.78 286.01,200.63 286.58,200.06 286.58,198.03 286.35,197.79 284.29,197.79 284.2,197.88 284.2,198.74 284.52,199.06 284.52,200.84 284.66,200.98 285.81,200.98
N80539361 on BOTTOM (solid shape): 286.32,197.09 286.32,194.12 286.24,194.05 284.22,194.05 284.06,193.89 284.06,193.37 283.96,193.27 283.52,193.27 283.43,193.37 283.43,195.15 283.65,195.38 284.3,195.38 284.63,195.72 284.63,197.1 284.73,197.2 286.21,197.2
N81221898 on BOTTOM (solid shape): 145.57,211.93 145.77,211.72 145.77,211.06 145.57,210.86 145.16,210.86 145.06,210.96 145.06,211.77 145.21,211.93 145.21,212.54 145.32,212.64 145.57,212.64
N81223341 on BOTTOM (solid shape): 173.05,219.34 173.05,219.19 173,219.14 172.95,219.14 172.7,219.39 171.88,219.39 171.68,219.19 171.68,217.62 171.63,217.56 170.92,217.56 170.51,217.97 170.36,217.97 170.01,218.33 170.01,219.29 170.31,219.6 172.8,219.6
N81224802 on BOTTOM (solid shape): 226.34,219.29 226.34,216.96 225.89,216.5 224.31,216.5 223.95,216.85 223.95,217.16 224.82,218.02 224.82,219.44 225.12,219.75 225.89,219.75
N81224808 on TOP (solid shape): 227.66,219.51 227.66,218.68 227.46,218.48 226.19,218.48 226.14,218.53 226.14,219.27 226.5,219.63 227.54,219.63
N81224808 on BOTTOM (solid shape): 235.69,219.65 235.69,217.56 234.78,217.56 234.01,218.33 234.01,219.39 234.32,219.7 235.64,219.7
N81228094 on TOP (solid shape): 297.69,77.84 297.69,77.43 297.69,77.43 297.69,76.91 297.6,76.82 296.48,76.82 296.37,76.92 294.54,76.92 294.41,77.05 294.41,77.94 294.49,78.02 297.52,78.02
N81229156 on TOP (solid shape): 38.87,36.54 39.83,36.54 39.87,36.5 39.87,35.53 39.8,35.47 37.64,35.47 37.53,35.57 37.53,36.57 37.63,36.67 38.74,36.67
N81229158 on TOP (solid shape): 45.72,38.06 45.72,37.3 45.52,37.1 42.95,37.1 42.88,37.17 42.88,37.55 42.95,37.62 44.15,37.62 44.75,38.22 45.57,38.22
N81229164 on TOP (solid shape): 41.53,36.39 42.36,36.39 42.45,36.3 42.45,35.52 42.65,35.31 42.65,34.3 42.56,34.21 41.65,34.21 41.62,34.24 41.62,34.3 41.63,34.35 41.63,35.17 41.6,35.25 41.53,35.3 41.52,35.3 41.02,35.8 41.02,36.18 41.06,36.21 41.1,36.21 41.2,36.23 41.29,36.29 41.39,36.39
N81715961 on TOP (solid shape): 187.12,42.7 187.12,40.83 186.98,40.69 186.19,40.69 186.11,40.77 185.83,40.77 185.06,40 183.93,40 183.89,40.04 183.89,40.56 183.92,40.6 184.72,40.6 185.88,41.75 185.88,42.74 185.92,42.79 187.03,42.79
N81719173 on TOP (solid shape): 223.33,44.73 223.33,40.7 222.98,40.35 222.8,40.35 222.79,40.34 220.78,40.34 220.68,40.25 220.11,39.68 218.91,39.68 218.91,40.51 218.98,40.57 220.02,40.57 220.43,40.98 221.42,40.98 222.02,41.58 222.02,42.05 222.09,42.12 222.17,42.12 222.36,42.31 222.36,43.51 222.08,43.79 222.08,44.95 222.15,45.02 223.04,45.02
N81719224 on TOP (solid shape): 221.16,45.27 221.16,43.9 221,43.74 219.03,43.74 218.86,43.57 218.86,43.16 218.76,43.06 217.83,43.06 217.78,43.11 217.78,44.4 218.34,44.96 219.6,44.96 219.8,45.16 219.8,45.16 220.14,45.5 220.93,45.5
N81807638 on TOP (solid shape): 91.8,96.94 91.8,92.75 92.09,92.46 92.09,92.1 92.09,91.3 92.06,91.28 91.91,91.28 91.89,91.3 91.89,92.1 91.69,92.1 91.69,91.3 91.66,91.28 91.52,91.28 91.48,91.31 91.48,92.1 91.48,92.2 91.39,92.29 90.6,92.29 89.94,92.95 89.94,94.32 89.74,94.52 89.74,96.91 89.82,96.99 91.75,96.99
N81807642 on TOP (solid shape): 95.91,96.69 95.91,94.53 95.61,94.22 95.61,92.95 95.3,92.65 93.88,92.65 93.68,92.44 93.68,91.33 93.65,91.3 93.54,91.3 93.5,91.32 93.48,91.35 93.48,92.1 93.29,92.1 93.29,91.35 93.27,91.32 93.24,91.3 93.09,91.3 93.09,91.31 93.09,92.11 93.04,92.16 93.04,96.53 93.5,96.99 95.61,96.99
N81807757 on TOP (solid shape): 88.97,92.91 89.56,92.91 90.35,92.11 91.23,92.11 91.27,92.1 91.29,92.06 91.29,91.29 91.05,91.05 90.24,91.05 90.24,90.85 90.99,90.85 91.02,90.84 91.04,90.8 91.04,90.7 91.02,90.67 90.99,90.65 90.24,90.65 90.24,90.45 90.99,90.45 91.02,90.44 91.04,90.4 91.04,90.3 91.02,90.27 90.99,90.25 90.24,90.25 90.24,90.05 90.99,90.05 91.02,90.04 91.04,90 91.04,89.9 91.02,89.87 90.99,89.85 90.24,89.85 90.24,89.65 90.99,89.65 91.02,89.64 91.04,89.6 91.04,89.5 91.02,89.47 90.99,89.45 90.24,89.45 90.21,89.42 90.1,89.42 89.97,89.55 89.97,89.93 89.77,90.13 87.66,90.13 87.55,90.24 87.55,91.58 87.54,91.64 87.51,91.68 87.51,91.71 87.18,92.04 86.01,92.04 85.99,92.05 85.61,92.05 85.52,92.14 85.52,92.9 85.78,93.16 88.73,93.16
N81807781 on TOP (solid shape): 97.97,97.12 97.97,96.35 98,96.32 98.03,96.3 98.1,96.23 98.1,95.77 97.97,95.64 97.49,95.64 97.29,95.44 97.29,92.24 97.23,92.19 96.8,92.19 96.57,91.96 96.57,89.25 96.98,88.83 96.98,88.51 96.94,88.47 96.46,88.47 96.39,88.54 96.39,88.71 96.32,88.78 96.32,88.85 96.07,89.11 95.68,89.11 95.47,89.31 95.4,89.36 95.31,89.38 95.18,89.38 95.09,89.47 94.16,89.47 94.11,89.52 94.11,89.6 94.12,89.64 94.16,89.65 94.93,89.65 94.93,89.85 94.16,89.85 94.12,89.87 94.11,89.9 94.11,90 94.12,90.04 94.16,90.05 94.93,90.05 94.93,90.25 94.16,90.25 94.12,90.27 94.11,90.3 94.11,90.4 94.12,90.44 94.16,90.45 94.93,90.45 94.93,90.65 94.16,90.65 94.12,90.67 94.11,90.7 94.11,90.8 94.12,90.84 94.16,90.85 94.93,90.85 94.93,91.05 94.16,91.05 94.12,91.07 94.11,91.1 94.11,91.24 94.06,91.29 93.94,91.29 93.9,91.3 93.89,91.34 93.89,92.09 93.93,92.13 95.19,92.13 96.12,93.05 96.12,95.87 96.13,95.89 96.13,97.06 96.27,97.19 97.89,97.19
N82284456 on BOTTOM (solid shape): 210.21,45.94 210.21,44.92 209.38,44.08 209.38,42.03 209.43,41.97 209.44,41.95 209.44,41.9 209.48,41.72 209.61,41.56 209.62,41.54 209.62,41.35 209.56,41.29 208.89,41.29 208.61,41.57 208.61,41.63 208.62,41.64 208.66,41.74 208.68,41.85 208.65,41.99 208.57,42.11 208.57,42.38 208.49,42.47 208.49,44.59 209.07,45.17 209.07,45.99 209.25,46.17 209.98,46.17
