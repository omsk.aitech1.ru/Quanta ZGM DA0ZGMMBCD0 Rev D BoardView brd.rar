# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3V on TOP (solid shape): 265.98,186.36 265.98,185.58 265.69,185.29 265.65,185.29 265.55,185.25 265.51,185.15 265.51,184.37 265.48,184.34 264.7,184.34 264.67,184.37 264.67,185.66 265.48,186.48 265.86,186.48
+3V on TOP (solid shape): 289.28,75.6 290.2,75.6 290.81,75 290.81,74.69 290.76,74.65 287.54,74.65 285.57,72.68 285.22,72.68 285.09,72.81 285.09,73.27 286.98,75.16 286.99,75.16 288.1,76.27 288.61,76.27
+3V on TOP (solid shape): 144.86,78.83 145.02,78.83 145.11,78.73 145.11,76.83 144.91,76.63 143.88,76.63 143.21,75.96 139.37,75.96 139.12,76.21 139.12,78.68 139.26,78.82 139.69,78.82 139.7,78.83 144.86,78.83
+3V on TOP (solid shape): 252.15,114.26 252.15,113.4 252.05,113.3 251.64,113.3 251.54,113.4 251.54,113.55 251.56,113.6 251.57,113.63 251.57,113.83 251.55,113.91 251.49,113.96 251.49,113.96 251.39,114.06 251.03,114.06 251.01,114.09 251.01,114.33 251.14,114.47 251.95,114.47
+3V on TOP (solid shape): 260.65,217.87 260.69,217.85 260.7,217.82 260.7,217.44 260.96,217.17 260.96,216.73 260.96,216.73 260.96,216.58 260.93,216.55 260.28,216.55 260.27,216.54 260.14,216.67 260.14,216.98 259.98,217.14 259.61,217.14 259.51,217.24 259.51,217.33 259.51,217.34 259.51,217.82 259.56,217.87
+3V on TOP (solid shape): 24.06,49.95 24.06,47.72 23.92,47.58 23.63,47.58 23.42,47.79 22.58,47.79 22.52,47.85 22.52,48.15 22.53,48.2 22.53,48.23 22.5,48.38 22.41,48.51 22.41,48.52 22.41,48.54 22.1,48.85 22.1,50.08 22.13,50.1 23.91,50.1
+3V on TOP (solid shape): 268.47,199.6 268.47,199.29 268.45,199.23 268.45,199.15 268.31,199.01 267.86,199.01 267.64,199.23 267.57,199.23 267.57,199.24 267.21,199.24 267.05,199.4 265.7,199.4 265.7,199.4 265.7,199.7 265.72,199.7 267,199.7 267,199.71 267.25,199.71 267.32,199.78 268.29,199.78
+3V on TOP (solid shape): 188.17,61.34 188.17,61.07 187.73,60.63 187.39,60.63 187.3,60.59 187.25,60.5 187.25,60.45 187.08,60.28 186.54,60.28 186.45,60.37 186.45,60.7 186.54,60.79 186.98,60.79 187.12,60.92 187.18,60.96 187.22,60.99 187.66,61.43 188.08,61.43
+3V on TOP (solid shape): 171.18,76.86 171.22,76.85 171.26,76.84 171.32,76.84 171.39,76.81 171.45,76.81 171.72,76.81 171.81,76.72 171.81,76.19 171.54,75.92 171.49,75.86 171.47,75.79 171.47,75.77 171.35,75.65 171.35,75.53 171.15,75.32 170.54,75.32 170.52,75.34 170.52,75.66 170.96,76.1 170.98,76.12 171.05,76.19 171.05,76.8 171.12,76.87 171.17,76.87
+3V on TOP (solid shape): 298.3,61.89 298.3,61.6 297.79,61.09 297.79,60.2 297.81,60.18 297.82,60.16 297.88,60.05 297.99,59.99 298,59.98 298.17,59.82 298.42,59.82 298.49,59.74 298.49,59.33 298.41,59.24 296.72,59.24 296.66,59.3 296.66,61.49 296.72,61.55 296.74,61.56 296.76,61.57 297.55,61.57 297.59,61.61 297.59,61.81 297.82,62.03 297.84,62.04 297.89,62.03 297.97,62.04 298.05,62.07 298.12,62.07
+3V on TOP (solid shape): 97.54,77.86 97.54,76.09 98.07,75.55 98.07,74.04 98.06,74.03 98.04,73.99 98.03,73.94 98.03,73.56 98.04,73.51 98.06,73.47 98.07,73.46 98.07,72.84 98.06,72.8 98.06,72.76 98.06,72.46 98.06,72.42 98.07,72.37 98.07,72.08 97.95,71.96 97.2,71.96 97.13,71.89 97.13,70.67 97.02,70.56 94.59,70.56 94.34,70.3 94.34,69.76 94.14,69.56 93.75,69.56 93.58,69.74 93.58,76.9 94.72,78.04 97.36,78.04
+3V on TOP (solid shape): 220.22,75.27 220.22,74.87 219.97,74.61 219.61,74.61 219.48,74.7 219.33,74.73 219.19,74.7 219.07,74.63 219.05,74.61 218.98,74.61 218.9,74.69 218.9,75.2 218.93,75.23 218.95,75.27 218.98,75.31 219.39,75.31 219.5,75.25 219.62,75.23 219.81,75.28 219.97,75.45 220,75.45 220.04,75.45
+3V on TOP (solid shape): 33.53,66.24 33.53,65.45 33.5,65.42 33.5,62.29 33.1,61.89 30.18,61.89 29.82,62.24 29.82,65.12 29.97,65.27 30.03,65.28 30.1,65.28 30.17,65.31 30.56,65.31 30.64,65.28 30.71,65.28 30.78,65.28 30.86,65.31 32.06,65.31 32.26,65.25 32.46,65.31 32.7,65.31 32.75,65.36 32.75,66.21 32.84,66.3 33.47,66.3
+3V on TOP (solid shape): 264.06,217.66 264.06,215.33 263.95,215.22 263.18,215.22 263.17,215.23 263.17,215.99 263.17,216.27 263.19,216.31 263.2,216.32 263.29,216.4 263.35,216.5 263.35,216.51 263.5,216.66 263.5,216.93 263.33,217.11 262.58,217.11 262.2,216.73 261.96,216.73 261.96,217.23 262.17,217.43 262.17,217.82 262.18,217.85 262.22,217.87 263.85,217.87
+3V on TOP (solid shape): 188.14,102.86 188.14,102.38 188.06,102.3 187.71,102.3 187.57,102.44 187.57,102.46 187.43,102.7 187.18,102.79 186.92,102.7 186.79,102.47 186.78,102.45 186.76,102.43 186.31,102.43 186.19,102.3 186.19,100.57 186.8,99.96 186.8,99.62 186.84,99.52 186.94,99.48 187.07,99.48 187.18,99.38 187.18,98.49 187.07,98.39 186.85,98.39 186.67,98.57 186.67,98.74 186.68,98.75 186.72,98.85 186.73,98.95 186.69,99.13 186.57,99.27 185.78,100.06 185.78,102.83 186.29,103.34 187.66,103.34
+3V on TOP (solid shape): 153.67,209.44 153.67,207.81 153.29,207.43 153.29,207.22 153.29,207.19 153.29,206.63 153.29,206.6 153.29,206.19 153.48,206 156.58,206 156.61,206 157.13,206 157.3,206.16 157.32,206.17 157.34,206.18 159.33,206.18 159.93,205.58 160.05,205.54 160.14,205.53 160.36,205.6 160.51,205.78 160.51,205.78 160.82,206.09 160.83,206.09 160.9,206.13 160.94,206.2 160.94,206.21 160.99,206.26 160.99,206.57 161.06,206.64 161.39,206.64 161.42,206.62 161.42,206.03 161.32,205.93 161.32,205.68 161.14,205.5 161.09,205.5 160.77,205.18 160.77,204.84 160.67,204.75 160.6,204.7 160.54,204.65 160.52,204.63 160.5,204.63 159.53,204.63 159.27,204.88 159.27,205.28 158.98,205.58 158.04,205.58 157.74,205.27 154.69,205.27 154.13,204.71 153.47,204.71 153.45,204.72 153.43,204.73 153.29,204.86 152.66,204.86 152.61,204.92 152.61,209.44 152.89,209.72 153.39,209.72
+3V on TOP (solid shape): outline of 173 points within 310.82,83.42 313.36,89.75
+3V on TOP (solid shape): outline of 604 points within 214.56,81.84 223.92,86.91
+3V on TOP (solid shape): outline of 1007 points within 274.95,171.27 286.87,206.34
+3V on TOP (solid shape): outline of 2002 points within 183.4,48.25 206.83,84.54
+3V on BOTTOM (solid shape): 255.34,213.44 255.34,212.49 254.94,212.1 254.53,212.1 254.48,212.15 254.48,213.21 254.93,213.66 255.12,213.66
+3V on BOTTOM (solid shape): 268.1,199.66 268.11,199.66 268.35,199.42 268.35,198.99 268.31,198.96 267.95,198.96 267.64,199.27 267.31,199.27 267.17,199.41 267.17,199.81 267.23,199.87 267.89,199.87
+3V on BOTTOM (solid shape): 207.26,49.23 207.26,48.99 207.24,48.97 206.65,48.97 206.34,48.66 206.34,48.61 206.34,48.61 206.34,48.28 206.26,48.2 205.67,48.2 205.53,48.35 205.53,48.81 205.35,48.99 205.35,49.2 205.4,49.25 207.24,49.25
+3V on BOTTOM (solid shape): 275.49,203.8 275.49,203.34 275.85,202.99 276.61,202.99 276.86,202.73 276.86,201.31 276.79,201.23 276.56,201.23 276.3,201.49 276.3,201.93 275.44,202.79 274.67,202.79 274.5,202.63 274.5,201.41 274.32,201.23 273.92,201.23 273.74,201.41 273.74,203.04 274.63,203.92 275.36,203.92
+3V on BOTTOM (solid shape): 267.07,116.01 267.07,114.87 267.34,114.61 267.92,114.61 267.93,114.61 268.34,114.61 268.73,114.61 268.99,114.86 268.99,115.23 269.01,115.26 269.4,115.26 269.44,115.24 269.45,115.2 269.45,114.67 269.21,114.43 266.69,114.43 266.48,114.63 266.48,116.07 266.55,116.15 266.94,116.15
+3V on BOTTOM (solid shape): 186.9,90.43 186.9,88.67 186.97,88.67 187.01,88.66 187.02,88.62 187.02,87.49 186.87,87.34 186.49,87.34 186.29,87.54 186.29,88.35 186.52,88.58 186.52,88.62 186.53,88.66 186.57,88.67 186.65,88.67 186.65,90.44 186.66,90.47 186.7,90.49 186.87,90.49
+3V on BOTTOM (solid shape): 231.56,118.68 231.56,118.25 231.54,118.21 231.51,118.2 231.17,118.2 231.08,118.11 229.38,118.11 229.07,117.8 229.07,117.78 228.88,117.59 228.88,115.05 228.35,114.52 226.19,114.52 226.06,114.64 226.06,115.58 226.22,115.74 227.92,115.74 228.4,116.22 228.4,116.63 228.45,116.68 228.45,118.07 229.01,118.63 229.77,118.63 229.9,118.76 231.47,118.76
+3V on BOTTOM (solid shape): 198.36,50.93 198.39,50.93 198.77,50.93 198.81,50.93 198.83,50.92 198.91,50.84 198.91,50.39 198.84,50.28 198.82,50.15 198.81,50.1 198.65,49.94 198.63,49.93 198.54,49.91 198.47,49.86 198.23,49.86 197.94,50.15 197.94,50.82 198.07,50.95 198.32,50.95
+3V on BOTTOM (solid shape): 186.9,105.28 186.94,105.27 186.95,105.23 186.95,103.47 187.06,103.47 187.06,103.46 187.43,103.1 187.43,102.26 187.3,102.13 186.96,102.13 186.63,102.46 186.63,103.01 186.62,103.02 186.62,103.42 186.64,103.46 186.67,103.47 186.7,103.47 186.7,105.23 186.71,105.27 186.75,105.28
+3V on BOTTOM (solid shape): 286.72,204.29 286.72,203.35 286.64,203.27 286.36,203.27 286.29,203.34 285.92,203.34 285.68,203.1 285.68,202.73 286.22,202.19 286.66,202.19 286.72,202.12 286.72,201.54 286.46,201.28 286.44,201.27 286.33,201.24 286.22,201.16 286.2,201.16 284.56,201.16 284.44,201.28 284.44,202.14 284.42,202.15 284.42,203.97 284.76,204.3 285.71,204.3 285.89,204.49 286.53,204.49
+3V on BOTTOM (solid shape): 200.36,50.83 200.36,50.66 200.63,50.39 200.63,49.41 200.08,48.86 200.08,48.54 200.16,48.45 200.69,48.45 200.74,48.51 200.74,48.73 201,48.99 201.02,49 201.04,49 201.52,49 201.63,49.11 201.63,49.22 201.67,49.27 202.41,49.27 202.41,49.27 204.84,49.27 204.92,49.19 204.92,48.82 205.11,48.63 205.11,48.22 205.03,48.14 204.55,48.14 203.95,48.75 202.49,48.75 201.62,47.88 199.57,47.88 199.06,48.39 199.06,49.16 199.14,49.23 199.68,49.23 199.92,49.47 199.92,50.82 199.95,50.86 200.32,50.86
+3V on BOTTOM (solid shape): 113.95,115.08 113.95,113.86 113.74,113.65 112.17,113.65 110.52,112 110.52,110.73 109.55,109.77 109.55,108.8 109.58,108.78 109.58,108.07 109.45,107.94 108.49,107.94 108.45,107.95 108.44,107.99 108.44,108.19 108.4,108.28 108.3,108.33 108.22,108.33 108.16,108.35 108.11,108.35 107.8,108.35 107.76,108.37 107.75,108.4 107.75,108.5 108.21,108.95 108.21,110.3 108.89,110.99 108.89,111.77 109.25,112.13 109.25,113.22 111.6,115.57 113.45,115.57
+3V on BOTTOM (solid shape): 111.75,49.75 111.75,49.61 112.36,49 113,49 113.03,48.97 113.04,48.95 113.04,48.88 113.01,48.84 113.01,48.61 112.8,48.4 112.51,48.4 112.48,48.42 112.41,48.48 112.39,48.5 112.12,48.61 111.81,48.48 111.27,48.48 111.04,48.72 111.04,48.75 111.08,48.84 111.09,48.95 111.08,49.05 111.04,49.14 111.04,49.15 111.04,49.27 111.17,49.41 111.17,49.79 111.22,49.83 111.67,49.83
+3V on BOTTOM (solid shape): 160.32,168.44 160.32,168.07 160.36,167.97 160.46,167.93 161.17,167.93 161.27,167.97 161.31,168.07 161.31,168.21 161.42,168.32 162.05,168.32 162.14,168.41 163.93,168.41 164.12,168.22 164.12,167.89 163.82,167.59 163.38,167.59 163.33,167.66 163.25,167.69 162.54,167.69 162.45,167.66 162.4,167.59 162.22,167.59 162,167.37 159.8,167.37 159.29,167.88 159.19,167.98 158.37,167.98 158.06,168.3 158.01,168.31 157.96,168.35 157.91,168.36 157.5,168.36 157.42,168.44 157.42,168.66 157.51,168.75 160.02,168.75
+3V on BOTTOM (solid shape): outline of 82 points within 168.97,161.04 175.17,164.38
+3V on BOTTOM (solid shape): outline of 182 points within 24.83,61.65 33.52,68.17
+3V on BOTTOM (solid shape): outline of 584 points within 91.72,72.99 100.79,99.61
+3V on IN1 (solid shape): 260.76,217.68 260.76,217.53 260.76,217.29 260.88,217.16 261.85,217.16 262.18,216.83 262.18,216.14 261.88,215.84 259.67,215.84 259.31,216.19 259.31,217.68 259.33,217.72 259.36,217.74 260.7,217.74
+3V on IN2 (solid shape): outline of 83 points within 227.84,61.22 230.33,63.74
+3V on IN2 (solid shape): outline of 2369 points within 133.68,49.67 201.55,69.4
+3V on SVCC (solid shape): outline of 1781 points within 94.75,65.6 303.05,204.56
+3V on SVCC1 (solid shape): 27.13,63.38 27.29,63.27 27.49,63.23 33.09,63.23 33.56,62.77 33.56,55.97 30.74,55.97 30.55,55.93 30.38,55.82 29.06,54.5 28.95,54.34 28.91,54.14 28.91,44.91 28.65,44.56 28.91,44.22 28.91,38.98 26.72,38.98 25.53,37.78 17.1,37.78 16.79,38.1 16.77,38.13 16.74,38.16 16.74,41.15 21.7,46.11 21.81,46.28 21.85,46.47 21.85,53.53 21.9,53.53 22.15,53.64 22.25,53.89 22.25,53.94 22.24,53.99 22.46,54.21 22.57,54.38 22.61,54.57 22.61,56.84 22.88,57.18 22.61,57.53 22.61,58.51 22.57,58.7 22.46,58.87 22.1,59.23 22.1,61.15 22.29,61.28 22.36,61.5 22.31,61.68 22.18,61.81 24.6,64.22 26.28,64.22
+3V on IN3 (solid shape): outline of 1062 points within 185.91,78.3 190.68,103.47
+3V on IN3 (solid shape): outline of 2802 points within 216.21,36.06 287.16,51.34
+3V on IN3 (solid shape): outline of 2913 points within 31.42,59.3 98.07,75.76
+3V on IN3 (solid shape): outline of 5283 points within 12.69,2.1 27.35,41.26
+3V on IN4 (solid shape): 260.75,217.69 260.75,216.48 260.44,216.17 258.78,216.17 258.73,216.15 258.68,216.13 258.64,216.1 258.6,216.06 258.56,216.02 258.53,215.98 258.51,215.93 258.5,215.89 258.08,215.47 258.08,215.42 255.42,212.76 254.69,212.76 254.48,212.96 254.48,213.52 254.6,213.63 255.34,213.63 255.68,213.97 255.68,214.06 256.06,214.44 256.06,214.62 256.04,214.64 256.04,215.82 257.07,215.82 257.07,215.76 257.08,215.71 257.09,215.66 257.12,215.61 257.15,215.57 257.18,215.53 257.22,215.49 257.27,215.47 257.32,215.45 257.37,215.44 257.42,215.43 257.48,215.44 257.53,215.45 257.58,215.47 257.62,215.49 257.67,215.53 257.7,215.57 257.73,215.61 257.76,215.66 257.77,215.71 257.78,215.76 257.78,215.82 257.77,215.87 257.76,215.92 257.73,215.97 257.7,216.01 257.67,216.05 257.62,216.08 257.58,216.11 257.53,216.13 257.48,216.14 257.42,216.15 257.37,216.14 257.32,216.13 257.27,216.11 257.22,216.08 257.18,216.05 257.15,216.01 257.12,215.97 257.09,215.92 257.08,215.87 257.07,215.82 256.04,215.82 256.04,216.62 257.23,217.82 260.61,217.82
+3V on IN4 (solid shape): outline of 502 points within 198.99,41.39 218.16,48.85
+3V3PD on TOP (solid shape): 63.68,91.89 63.68,91.48 62.97,90.77 61.92,90.77 61.42,90.27 61.42,89.52 61.37,89.47 61.24,89.47 61.17,89.55 61.17,90.19 61.18,90.28 61.18,90.32 61.18,90.45 61.8,91.07 61.99,91.07 62.22,91.07 62.23,91.07 62.43,91.07 62.51,91.07 62.59,91.15 62.59,91.26 63.05,91.73 63.05,91.89 63.1,91.93 63.63,91.93
+3V3PD on IN3 (solid shape): outline of 707 points within 62.61,83.18 72.97,93.49
+3V_5G on TOP (solid shape): 282.01,55.33 284.89,55.33 285.35,54.87 285.35,54.28 285.14,54.07 282.11,54.07 281.86,54.33 280.7,54.33 280.61,54.43 280.61,55.13 280.85,55.37 281.97,55.37
+3V_5G on TOP (solid shape): 297.42,108.21 297.42,105.49 297.25,105.32 296.94,105.32 296.37,105.89 296.37,106.36 295.99,106.74 295.99,108.34 296.09,108.45 297.18,108.45
+3V_5G on TOP (solid shape): 305.64,80.48 305.64,77.18 305.92,76.9 306.84,76.9 307.04,76.7 307.04,75.29 306.98,75.23 305.73,75.23 305.73,75.23 305.66,75.23 305.22,74.79 304.5,74.79 304.4,74.89 304.4,76.14 304.27,76.26 304.18,76.26 303.98,76.46 303.98,80.24 304.27,80.54 305.59,80.54
+3V_5G on TOP (solid shape): 274.3,56.75 274.3,55.84 274.36,55.78 274.51,55.78 274.57,55.74 274.65,55.66 274.65,54.96 274.65,54.96 274.65,54.77 274.57,54.69 274,54.69 273.92,54.61 273.25,54.61 273.2,54.66 273.2,55.21 273.26,55.27 273.5,55.27 273.74,55.52 273.74,55.52 273.94,55.71 273.94,56.75 273.96,56.77 274.27,56.77
+3V_5G on TOP (solid shape): 273.49,58.79 274.23,58.79 274.33,58.69 274.33,57.42 274.3,57.4 273.91,57.4 273.88,57.42 273.88,58.26 273.7,58.45 273.25,58.45 273.18,58.38 272.21,58.38 272.01,58.18 272.01,58.18 271.93,58.1 271.93,57.03 271.84,56.95 270.58,56.95 270.5,57.03 270.5,58.67 270.64,58.81 273.46,58.81
+3V_5G on TOP (solid shape): outline of 87 points within 301.2,82.28 310.47,90.8
+3V_5G on TOP (solid shape): outline of 235 points within 295.28,88.86 307.55,94.16
+3V_5G on BOTTOM (solid shape): 277.76,58.9 277.76,58.15 277.76,58.15 276.6,58.15 276.53,58.21 276.53,59.06 276.62,59.14 277.52,59.14
+3V_5G on BOTTOM (solid shape): 298.85,93.78 298.85,93.33 298.7,93.18 298.7,92.75 298.25,92.29 297.19,92.29 296.58,91.68 296.5,91.68 296.31,91.87 296.31,93.23 296.53,93.45 298.03,93.45 298.44,93.86 298.77,93.86
+3V_5G on BOTTOM (solid shape): 297.48,77.19 297.5,77.19 297.52,77.18 297.56,77.13 297.61,77.1 298.15,76.56 298.15,74.87 298.09,74.81 297.98,74.81 297.9,74.88 297.9,75.98 296.9,76.99 296.9,77.35 297.01,77.46 297.22,77.46
+3V_5G on BOTTOM (solid shape): 275.29,56.48 275.29,56.09 275.41,55.97 275.57,55.97 275.73,55.82 275.76,55.78 275.76,55.55 275.56,55.35 275.19,55.35 274.41,56.13 274.24,56.13 274.21,56.16 274.21,56.44 274.26,56.49 274.98,56.49 275.01,56.52 275.25,56.52
+3V_5G on BOTTOM (solid shape): 309.22,93.14 309.25,93.12 309.27,93.09 309.27,92.92 309.25,92.88 309.22,92.87 307.7,92.87 307.7,92.64 309.22,92.64 309.25,92.63 309.27,92.59 309.27,92.42 309.25,92.38 309.22,92.37 307.7,92.37 307.7,92.29 307.69,92.28 307.6,92.24 307.56,92.14 307.56,91.18 307.35,90.97 305.99,90.97 305.84,91.12 305.84,92.77 306.1,93.02 307.03,93.02 307.14,93.14
+3V_5G on BOTTOM (solid shape): 282.24,58.21 282.24,57.91 282.17,57.84 281.58,57.84 281.31,57.58 281.31,56.08 281.5,55.88 281.67,55.88 281.76,55.8 281.76,54.91 281.32,54.47 280.29,54.47 280.16,54.6 280.16,55.36 280.22,55.42 280.33,55.37 280.45,55.35 280.73,55.47 280.84,55.74 280.82,55.86 280.77,55.97 280.79,56 280.79,57.11 280.81,57.15 280.81,57.19 280.82,57.29 280.82,57.34 280.82,57.79 281.41,58.38 282.06,58.38
+3V_5G on BOTTOM (solid shape): 307.52,76.87 307.52,76.29 307.67,76.15 307.7,76.14 309.29,76.14 309.35,76.09 309.35,75.92 309.33,75.88 309.3,75.87 307.7,75.87 307.7,75.64 309.3,75.64 309.33,75.63 309.35,75.59 309.35,75.42 309.33,75.38 309.3,75.37 307.7,75.37 307.7,75.14 309.3,75.14 309.33,75.13 309.35,75.09 309.35,74.87 309.28,74.8 307.73,74.8 307.73,74.8 307.32,75.2 306.48,75.2 306.47,75.2 306.2,75.23 305.93,75.2 305.92,75.2 304.97,75.2 304.8,75.37 304.8,76.8 305.08,77.08 307.32,77.08
+3V_5G on IN1 (solid shape): outline of 577 points within 295.43,91.15 307.52,105.98
+3V_5G on IN3 (solid shape): outline of 701 points within 303.65,74.94 310.52,92.84
+3V_DEEP_SUS on TOP (solid shape): 219.07,69.38 219.07,68.81 219.3,68.58 219.62,68.58 219.75,68.7 219.86,68.82 219.86,69.1 219.83,69.13 219.82,69.15 219.82,69.37 219.89,69.43 220.19,69.43 220.3,69.33 220.3,68.34 220.07,68.11 218.44,68.11 218.27,68.29 218.27,69.36 218.37,69.46 218.99,69.46
+3V_DEEP_SUS on TOP (solid shape): outline of 161 points within 216.92,58.23 219.89,62.78
+3V_DEEP_SUS on TOP (solid shape): outline of 301 points within 214.92,69.97 219.56,80.36
+3V_DEEP_SUS on TOP (solid shape): outline of 610 points within 224.11,58.21 231.96,73.32
+3V_DEEP_SUS on BOTTOM (solid shape): 231.85,59.74 231.85,59.19 231.16,58.49 230.88,58.49 230.88,59.28 231.46,59.87 231.73,59.87
+3V_DEEP_SUS on BOTTOM (solid shape): 232.76,55.4 232.76,54.55 232.56,54.36 232.26,54.36 232.18,54.28 232.18,53.79 232.1,53.71 231.24,53.71 231.02,53.94 231.02,55.31 231.6,55.89 232.26,55.89
+3V_DEEP_SUS on BOTTOM (solid shape): 114.92,144.15 115.13,144.15 115.19,144.1 115.27,144.07 115.29,144.05 115.3,144.02 115.3,142.36 115.18,142.24 114.92,142.24 114.91,142.23 114.56,142.23 114.31,142.48 114.31,143.8 114.2,143.91 114.2,144.19 114.22,144.21 114.24,144.21 114.85,144.21
+3V_DEEP_SUS on IN1 (solid shape): outline of 6349 points within 209.8,58.84 232.59,73.5
+3V_DEEP_SUS on IN3 (solid shape): 229.78,78.55 229.81,78.54 229.82,78.53 229.83,78.5 229.83,77.89 230.39,77.33 230.39,73.09 230.41,73.08 230.41,72.89 230.18,72.66 229.14,72.66 228.58,73.22 228.58,73.7 229.16,73.7 229.16,73.65 229.17,73.59 229.19,73.54 229.21,73.5 229.24,73.45 229.27,73.41 229.32,73.38 229.36,73.35 229.41,73.33 229.46,73.32 229.52,73.32 229.57,73.32 229.62,73.33 229.67,73.35 229.72,73.38 229.76,73.41 229.8,73.45 229.83,73.5 229.85,73.54 229.87,73.59 229.87,73.65 229.87,73.7 229.87,73.75 229.85,73.8 229.83,73.85 229.8,73.9 229.76,73.94 229.72,73.97 229.67,74 229.62,74.01 229.57,74.03 229.52,74.03 229.46,74.03 229.41,74.01 229.36,74 229.32,73.97 229.27,73.94 229.24,73.9 229.21,73.85 229.19,73.8 229.17,73.75 229.16,73.7 228.58,73.7 228.58,74.99 228.93,75.35 228.93,75.85 228.94,75.89 228.93,75.93 228.93,76.44 229.29,76.8 229.29,78.37 229.47,78.55
+3V_DP on TOP (solid shape): 17.86,21.04 17.86,20.6 17.56,20.3 15.67,20.3 15.58,20.39 15.58,20.72 15.64,20.78 16.15,20.78 16.52,21.14 17.76,21.14
+3V_DP on TOP (solid shape): 23.32,27.98 23.32,27.67 22.99,27.34 20.2,27.34 20.12,27.42 20.12,27.83 20.25,27.95 22.53,27.95 22.76,28.18 23.12,28.18
+3V_DP on TOP (solid shape): 24.21,26.1 24.21,26.06 24.38,25.89 24.38,25.89 24.43,25.85 24.72,25.85 24.86,25.7 24.86,25.34 24.86,25.34 24.83,25.19 24.86,25.04 24.86,25.03 24.86,24.51 24.83,24.47 24.31,24.47 24.31,24.47 23.69,24.47 23.6,24.56 23.6,26.03 23.72,26.14 24.17,26.14
+3V_DP on TOP (solid shape): 25.33,19.47 25.68,19.47 25.69,19.46 25.9,19.46 26.08,19.28 26.08,18.8 25.96,18.68 24.09,18.68 23.98,18.79 23.98,19.26 24.02,19.3 24.05,19.31 24.08,19.31 24.12,19.3 24.5,19.3 24.54,19.31 24.58,19.32 24.79,19.32 24.94,19.48 25.32,19.48
+3V_DP on TOP (solid shape): 19.89,43.14 19.89,42.41 19.69,42.2 19.31,42.2 19.15,42.04 19.07,42 19.05,41.99 18.66,41.59 17.53,41.59 17.43,41.7 17.43,42.13 17.54,42.24 18.55,42.24 18.56,42.24 18.81,42.24 18.83,42.26 18.86,42.26 18.96,42.3 19,42.4 19,42.73 19.1,42.84 19.1,43.21 19.13,43.24 19.79,43.24
+3V_DP on TOP (solid shape): 25.24,22.24 25.5,22.13 25.76,22.24 26.07,22.24 26.49,21.82 26.49,20.91 26.36,20.78 24.43,20.78 24.29,20.92 24.24,20.95 24.2,20.97 24.17,20.99 24.16,21.03 24.17,21.07 24.17,22.16 24.17,22.2 24.21,22.24
+3V_DP on BOTTOM (solid shape): 27.33,26.76 27.33,25.03 27.08,24.78 26.62,24.78 26.5,24.91 26.5,26.43 26.24,26.68 25.94,26.68 25.83,26.79 25.83,27.27 25.99,27.42 26.67,27.42
+3V_DP on BOTTOM (solid shape): 26.82,22.6 26.82,21.38 26.45,21.01 26.21,21.01 25.93,21.29 25.93,21.6 25.93,21.63 25.92,21.67 25.92,21.79 26.28,22.15 26.28,22.53 26.41,22.66 26.76,22.66
+3V_DP on BOTTOM (solid shape): 18.83,21.75 18.83,21.69 18.82,21.67 18.81,21.66 18.7,21.54 18.62,21.38 18.62,21.37 18.5,21.26 18.5,20.57 18.35,20.42 16.69,20.42 16.52,20.59 16.52,21.62 16.68,21.78 18.81,21.78
+3V_DP on BOTTOM (solid shape): 25.17,21.46 25.17,20.97 25.16,20.95 25.15,20.93 25.09,20.88 25.05,20.83 25.03,20.81 25,20.8 24.02,20.8 23.96,20.87 23.96,21.7 24.03,21.78 24.62,21.78 24.62,21.79 24.84,21.79
+3V_DP on BOTTOM (solid shape): 16.33,19.64 16.33,18.4 16.25,18.32 16.25,17.71 16.2,17.65 14.43,17.65 14.24,17.84 14.24,18.65 14.35,19.06 14.24,19.47 14.24,19.6 14.39,19.74 16.23,19.74
+3V_DP on BOTTOM (solid shape): 16.26,24.31 16.65,24.31 17.03,24.31 17.41,24.31 17.61,24.31 17.85,24.08 17.85,23.93 17.99,23.79 18.21,23.79 18.21,23.78 18.81,23.78 18.84,23.76 18.86,23.73 18.86,23.63 18.84,23.59 18.81,23.58 18.21,23.58 18.02,23.58 17.84,23.4 17.84,23.19 17.77,23.12 17.37,23.12 17.31,23.18 17.31,23.65 17.22,23.74 16.57,23.74 16.51,23.68 16.51,23.58 16.5,23.53 16.5,23.15 16.51,23.11 16.51,22.98 16.37,22.84 14.36,22.84 14.2,23 14.2,23.84 14.68,24.31 16.25,24.31
+3V_DP on IN1 (solid shape): outline of 584 points within 14.43,22.82 22.05,42.84
+3V_DP on IN2 (solid shape): outline of 531 points within 13.97,22.82 18.8,42.38
+3V_DP on IN4 (solid shape): outline of 3366 points within 14.15,7.99 27.05,28.13
+3V_DVDD on TOP (solid shape): 305.95,71.46 305.95,70.98 306.12,70.8 306.38,70.8 306.43,70.75 306.43,70.35 306.96,69.81 306.96,69.37 308.13,68.2 308.15,68.2 308.19,68.17 308.19,68.01 308.11,67.94 307.06,67.94 306.98,67.86 306.37,67.86 306.21,68.02 305.66,68.02 305.55,68.14 305.55,68.56 305.86,68.87 305.86,69.8 305.7,69.96 305.7,69.97 304.96,70.71 304.96,71.92 305.06,72.02 305.39,72.02
+3V_DVDD_IO on BOTTOM (solid shape): 312.56,63.05 312.56,62.21 312.47,62.12 312.08,62.12 311.64,62.55 311.15,62.55 311.06,62.64 311,62.64 310.99,62.65 310.89,62.69 310.78,62.71 310.51,62.59 310.39,62.31 310.41,62.18 310.48,62.06 310.49,62.05 310.49,62.03 310.67,61.85 310.82,61.85 310.87,61.8 310.87,60.99 310.81,60.94 310.55,60.94 309.72,60.94 309.62,61.04 309.62,62.96 309.75,63.09 312.53,63.09
+3V_EDPMUX on TOP (solid shape): 277.48,211.27 277.48,209.08 277.4,208.99 276.86,208.99 276.82,209.03 276.82,209.32 276.37,209.77 275.02,209.77 275.02,209.77 274.94,209.77 274.79,209.92 274.74,209.99 274.69,210.05 274.68,210.07 274.67,210.09 274.67,211.36 274.7,211.39 277.36,211.39
+3V_EDPMUX on TOP (solid shape): 265.63,216.32 265.63,216.02 265.81,215.84 265.82,215.84 265.89,215.77 266.51,215.77 266.6,215.68 266.6,215.39 266.81,215.18 267.27,215.18 267.35,215.11 267.35,214.76 267.22,214.64 264.63,214.64 264.57,214.7 264.57,215.07 264.57,215.07 264.57,216.26 264.67,216.36 265.59,216.36
+3V_EDPMUX on TOP (solid shape): 276.63,215.49 276.63,215.18 276.63,215.17 276.67,215.09 276.74,215.06 276.76,215.05 277.03,215.05 277.09,214.99 277.09,214.25 277.03,214.19 275.91,214.19 275.86,214.23 275.86,214.64 275.82,214.68 275.82,214.68 275.39,215.11 275.39,215.55 275.42,215.59 276.2,215.59 276.21,215.6 276.52,215.6
+3V_EDPMUX on TOP (solid shape): 271.41,213.78 271.41,213.55 271.57,213.39 271.57,211.45 271.5,211.38 271.5,210.98 271.57,210.91 271.57,210.9 271.77,210.71 272.34,210.71 272.57,210.48 272.57,210.17 272.53,210.13 272.51,210.11 272.51,209.51 272.45,209.45 272.09,209.45 272.01,209.53 272.01,209.7 270.85,210.86 270.85,211.83 270.9,211.88 270.9,212.83 270.8,212.93 270.8,213.78 270.87,213.86 271.33,213.86
+3V_EDPMUX on BOTTOM (solid shape): 279.55,206.72 279.55,205.69 278.63,204.77 277.67,204.77 277.36,205.08 277.36,206.04 277.6,206.27 278.25,206.27 278.93,206.94 279.33,206.94
+3V_EDPMUX on IN1 (solid shape): outline of 98 points within 265.47,206.46 279.54,215.84
+3V_HDD_REDRIVER on TOP (solid shape): outline of 262 points within 266.3,42.48 279.38,47.56
+3V_HDD_REDRIVER on BOTTOM (solid shape): 267.24,48.71 267.24,45.66 267.01,45.43 267.01,44.57 266.88,44.44 266.53,44.44 266.4,44.57 266.4,45.93 266.4,47.06 266.4,48.78 266.45,48.83 267.11,48.83
+3V_HDD_REDRIVER on BOTTOM (solid shape): 270.4,45.72 271.31,45.72 271.43,45.61 271.43,44.9 271.37,44.78 271.35,44.65 271.35,43.76 271.43,43.67 271.43,43.53 271.21,43.31 271.17,43.26 271.14,43.22 269.29,43.22 269.1,43.42 269.1,44.14 269.04,44.14 269.04,44.72 269.09,44.77 269.09,45.28 269.55,45.73 270.4,45.73
+3V_HDD_REDRIVER on BOTTOM (solid shape): 278.31,49.98 278.31,49.29 279.37,48.23 279.37,48.11 279.45,48.03 279.45,45.63 279.17,45.35 278.11,45.35 278.01,45.45 278.01,48.3 277.04,49.26 277.04,49.47 276.93,49.58 276.52,49.58 276.41,49.47 276.41,48.2 276.23,48.02 276.15,48.02 275.59,47.46 274.27,47.46 274.22,47.51 274.22,48.34 274.24,48.42 274.25,48.5 274.25,49.04 274.26,49.05 274.25,49.06 274.25,49.47 275.29,50.51 277.78,50.51
+3V_HDMI on TOP (solid shape): 36.1,59.81 36.1,57.95 35.27,57.12 34.52,57.12 34.36,56.96 33.82,56.96 33.73,57.04 33.73,57.42 33.84,57.52 34.09,57.52 34.26,57.7 34.51,57.7 34.9,58.09 34.9,60.06 35.06,60.22 35.69,60.22
+3V_HDMI on TOP (solid shape): 33.98,55.91 36.09,55.91 36.87,55.14 36.95,55.14 36.99,55.11 37.02,55.1 37.4,55.1 37.45,55.11 37.48,55.11 37.6,54.99 37.6,54.78 37.59,54.75 37.35,54.61 37.27,54.38 37.27,54.35 37.27,54.32 37.25,54.23 37.17,54.2 36.52,54.2 36.41,54.3 36.41,54.89 36.28,55.02 36.26,55.04 36.21,55.09 34.35,55.09 34.34,55.08 34.26,55.08 33.7,55.08 33.66,55.09 33.64,55.1 33.05,55.68 32.41,55.68 32.2,55.89 32.2,56.42 32.25,56.46 33.43,56.46
+3V_HDMI on BOTTOM (solid shape): outline of 162 points within 34.88,53.51 47.68,61.66
+3V_LDO_EC on TOP (solid shape): 259.69,53.06 259.69,51.26 259.59,51.15 259.03,51.15 258.99,51.19 258.99,51.75 259,51.76 259,52.28 258.5,52.78 258.41,52.78 258.34,52.85 258.34,53.32 258.37,53.35 259.4,53.35
+3V_LDO_EC on TOP (solid shape): 175.49,78.7 176.03,78.7 176.27,78.46 176.27,77.45 176.2,77.38 175.77,77.38 175.31,77.84 175.09,77.84 174.96,77.97 174.96,78.25 175.02,78.36 175.03,78.47 175.02,78.57 174.99,78.65 174.98,78.68 175,78.71 175.09,78.8 175.39,78.8
+3V_LDO_EC on BOTTOM (solid shape): 228.25,203.9 228.43,203.9 228.53,203.8 228.53,203.42 228.5,203.39 228.25,203.39 228.1,203.54 227.79,203.54 227.26,204.08 227.26,204.41 227.33,204.48 227.66,204.48
+3V_RTC on TOP (solid shape): 256.15,54.61 256.15,53.21 256.36,53.01 257.38,53.01 257.42,53.01 258.21,52.22 258.21,51.44 258.19,51.42 257.68,51.42 257.51,51.6 257.51,52.09 257.25,52.34 256.92,52.34 256.89,52.37 256.23,52.37 254.86,51.01 254.86,50.58 254.86,50.55 254.72,50.39 254.67,50.21 254.78,49.94 255.05,49.82 255.07,49.82 255.18,49.7 256.68,49.7 256.72,49.66 256.72,49.22 256.53,49.03 254.96,49.03 254.16,49.83 254.16,51.04 254.18,51.07 254.21,51.09 254.26,51.09 254.99,51.81 254.99,51.98 255.39,52.38 255.39,53.37 254.24,54.53 253.22,54.53 253.21,54.54 252.34,54.54 252.05,54.83 252.05,55.23 252.2,55.38 255.39,55.38
+3V_RTC on BOTTOM (solid shape): 234.4,51.72 234.4,51.28 234.24,51.12 234.24,51.09 234.22,51.07 234.22,46.75 234.11,46.65 233.66,46.65 233.58,46.72 233.58,48.03 233.6,48.05 233.6,49.34 233.58,49.35 233.58,49.39 233.63,49.44 233.63,51.68 233.78,51.83 234.29,51.83
+3V_RTC on BOTTOM (solid shape): 224.64,56.92 226.37,56.92 226.83,56.46 228.72,56.46 228.73,56.45 228.83,56.55 228.83,56.55 228.98,56.71 229.5,56.71 229.64,56.57 229.64,56.53 229.75,56.42 229.75,56.09 229.67,56.01 224.86,56.01 224.51,56.35 224.06,56.35 223.85,56.55 223.67,56.55 223.51,56.71 223.51,56.86 223.52,56.88 223.53,56.9 223.6,56.97 223.64,57.06 223.64,57.07 223.81,57.24 224.31,57.24
+3V_S5 on TOP (solid shape): 50.4,96.2 50.4,95.14 50.27,95.01 48.34,95.01 48.24,95.11 48.24,96.13 48.42,96.31 50.3,96.31
+3V_S5 on TOP (solid shape): 77.89,85.57 77.89,84.15 77.68,83.95 76.01,83.95 75.87,84.09 75.87,85.56 75.95,85.63 77.83,85.63
+3V_S5 on TOP (solid shape): 160.21,76.08 160.21,74.86 159.94,74.6 159.36,74.6 159.04,74.91 159.04,76.08 159.22,76.26 160.03,76.26
+3V_S5 on TOP (solid shape): 114.51,119.12 114.51,118.7 114.5,118.69 114.5,118.44 114.37,118.31 112.85,118.31 112.76,118.41 112.76,119.13 112.86,119.23 114.4,119.23
+3V_S5 on TOP (solid shape): 219.06,56.44 220.44,56.44 220.56,56.31 220.56,55.77 218.46,55.77 218.12,56.11 218.12,56.55 218.27,56.7 218.79,56.7
+3V_S5 on TOP (solid shape): 297.57,103.21 297.57,103.08 297.36,102.86 297.36,102.33 297.24,102.21 296.73,102.21 296.51,102.43 296.51,103.15 296.59,103.23 297.55,103.23
+3V_S5 on TOP (solid shape): 140.89,206.77 140.89,204.94 141.06,204.77 141.06,204.32 140.99,204.25 140.49,204.25 140.45,204.29 140.45,204.8 140.58,204.94 140.58,206.78 140.61,206.8 140.86,206.8
+3V_S5 on TOP (solid shape): 303.92,98.48 303.92,97.34 303.86,97.27 302.21,97.27 302.06,97.42 302.06,98.08 302.19,98.21 302.62,98.21 302.95,98.54 303.86,98.54
+3V_S5 on TOP (solid shape): 150.07,78.6 150.07,76.29 149.76,75.99 145.44,75.99 145.28,76.15 145.28,78.69 145.37,78.78 149.89,78.78
+3V_S5 on TOP (solid shape): 241.32,37.95 241.32,37.02 241.12,36.83 240.63,36.83 240.59,36.86 240.59,36.87 240.54,36.96 240.48,37.04 240.48,37.26 240.61,37.4 240.61,37.57 240.66,37.62 240.67,37.69 240.67,38.11 240.71,38.14 241.13,38.14
+3V_S5 on TOP (solid shape): 229.85,216.5 230.01,216.5 230.01,216.49 230.37,216.12 230.54,216.12 230.6,216.09 230.66,216.07 230.68,216.07 230.8,215.94 230.8,215.74 230.64,215.58 230.62,215.58 230.3,215.58 230,215.89 229.62,215.89 229.36,216.15 229.36,216.34 229.25,216.46 228.87,216.46 228.78,216.55 228.78,216.76 228.83,216.81 229.54,216.81
+3V_S5 on TOP (solid shape): 291.07,124.27 291.07,123.91 291.04,123.88 290.93,123.88 290.71,123.66 290.71,123.11 290.91,122.91 291.24,122.91 291.37,123.04 291.7,123.04 291.76,122.98 291.76,122.53 291.7,122.48 291.31,122.48 291.16,122.63 290.2,122.63 290.2,122.63 289.46,122.63 289.43,122.65 289.41,122.68 289.41,122.79 289.42,122.8 289.44,122.8 290.16,123.51 290.16,123.72 290.74,124.3 291.04,124.3
+3V_S5 on TOP (solid shape): 226.74,212.67 227.86,212.67 227.86,212.67 227.86,212.52 227.81,212.48 226.56,212.48 226.04,211.96 225.15,211.96 225.12,212 225.1,212.03 225.02,212.1 225.02,212.31 225.09,212.38 225.52,212.38 225.61,212.41 225.66,212.5 225.66,212.51 225.72,212.56 225.72,212.56 225.88,212.72 226.69,212.72
+3V_S5 on TOP (solid shape): 223.42,212.33 224.06,212.33 224.16,212.23 224.16,212 223.75,211.6 223.75,211.34 223.65,211.24 223.27,211.24 222.91,210.88 222.91,209.74 223.24,209.41 224.64,209.41 224.79,209.56 224.79,209.74 224.87,209.82 224.95,209.82 225.02,209.74 225.02,209.34 224.69,209 222.66,209 222.2,209.46 222.2,210.45 221.82,210.83 221.82,212.28 222.02,212.48 223.27,212.48
+3V_S5 on TOP (solid shape): 259.71,62.27 260.13,62.27 260.17,62.23 260.17,62.11 260.12,62.05 259.71,62.05 259.34,61.69 259.34,61.42 259.45,61.31 260.67,61.31 260.83,61.14 260.83,60.17 260.67,60.01 260.28,60.01 260.24,60.05 260.24,60.09 260.24,60.47 260.2,60.57 260.1,60.61 260.04,60.61 259.85,60.81 259.13,60.81 258.84,61.1 258.84,61.93 259.04,62.14 259.04,62.24 259.17,62.37 259.61,62.37
+3V_S5 on TOP (solid shape): 227.69,68.11 227.69,67.22 227.55,67.08 227.53,67.07 227.5,67.08 227.12,67.08 227.08,67.07 226.43,67.07 226.4,67.08 226.38,67.12 226.38,67.62 226.37,67.62 226.34,67.65 226.34,67.69 226.37,67.72 226.38,67.72 226.62,67.86 226.71,68.11 226.71,68.16 226.72,68.18 226.85,68.31 227.49,68.31
+3V_S5 on TOP (solid shape): 270.6,73.84 270.6,73.83 270.71,73.6 270.94,73.48 270.96,73.48 271,73.45 271,71.39 270.41,70.8 270.01,70.8 269.73,70.52 268.81,70.52 268.61,70.73 268.61,71.21 268.74,71.34 269.14,71.34 269.37,71.56 269.37,72.18 269.43,72.28 269.46,72.4 269.46,72.42 269.55,72.51 269.55,72.86 269.42,72.99 268.94,72.99 268.84,72.89 268.84,72.76 268.71,72.63 268.58,72.63 268.51,72.71 268.51,73.6 269.07,74.16 270.28,74.16
+3V_S5 on TOP (solid shape): 235.36,211.22 235.36,210.07 235,209.7 234.31,209.7 234.27,209.71 234.07,209.71 234.03,209.7 233.95,209.7 233.55,210.1 233.55,210.5 233.71,210.5 233.76,210.47 233.82,210.44 233.94,210.32 234.3,210.32 234.64,210.65 234.64,211.31 234.32,211.63 234.24,211.63 234.13,211.74 233.98,211.84 233.81,211.87 233.67,211.87 233.6,211.9 233.57,211.97 233.57,212.35 233.59,212.39 233.62,212.4 234.18,212.4
+3V_S5 on TOP (solid shape): 161.63,214.18 161.73,214.09 161.78,213.95 161.78,212.85 161.28,212.36 161.28,212.21 161.19,212.12 161.19,211.47 159.73,210 159.73,208.56 159.79,208.5 159.79,208.13 159.55,207.89 159.23,207.89 159.19,207.92 159.14,207.96 159.04,207.99 158.96,208 158.87,207.99 158.79,207.96 158.7,207.96 158.58,207.84 158.58,207.71 158.56,207.61 158.58,207.51 158.58,207.4 158.73,207.25 158.79,207.25 158.87,207.22 158.96,207.21 159.04,207.22 159.13,207.25 159.44,207.25 159.58,207.4 159.65,207.4 159.96,207.71 160.94,207.71 160.97,207.7 161,207.7 161.28,207.7 161.31,207.7 161.35,207.71 161.67,207.71 161.85,207.53 161.85,207.05 161.78,206.97 161.67,206.97 161.51,207.13 160.42,207.13 160.39,207.1 160.15,207.1 159.98,206.93 159.89,206.86 159.82,206.77 159.65,206.6 158.21,206.6 157.66,207.15 157.66,208.14 158.25,208.73 159.22,208.73 159.22,210.21 160.68,211.68 160.68,212.33 160.77,212.42 160.77,212.57 161.27,213.07 161.27,213.95 161.31,214.09 161.42,214.18
+3V_S5 on TOP (solid shape): 91.23,88.22 91.27,88.21 91.29,88.17 91.29,87.4 90.19,86.31 90.14,86.23 90.12,86.14 90.12,86.05 90.04,85.96 90.04,85.49 90.04,85.47 90.03,85.45 89.9,85.33 88.79,85.33 88.75,85.29 88.69,85.29 88.68,85.28 88.62,85.28 88.57,85.33 88.55,85.35 88.5,85.39 88.43,85.41 88.05,85.41 87.98,85.39 87.93,85.33 87.92,85.32 87.65,85.05 87.17,85.05 87.17,85.04 87.14,85.04 86.98,84.88 85.93,84.88 85.85,84.95 85.85,85.93 85.94,86.02 87.16,86.02 87.26,85.93 87.32,85.91 87.39,85.91 87.51,85.93 87.63,85.98 88.41,85.98 88.52,85.93 88.63,85.92 88.77,85.94 88.89,86.01 88.91,86.01 89.15,86.1 89.29,86.33 89.29,86.34 89.5,86.55 89.53,86.59 89.56,86.64 89.63,86.7 89.66,86.76 89.66,86.78 90.25,87.37 90.25,87.51 90.25,87.53 90.26,87.55 90.83,88.11 90.99,88.11 91.11,88.22
+3V_S5 on TOP (solid shape): outline of 152 points within 228.09,56.27 248.92,77.43
+3V_S5 on TOP (solid shape): outline of 516 points within 187.15,38.79 207.47,51.04
+3V_S5 on BOTTOM (solid shape): 303.93,97.58 303.93,97.28 303.82,97.17 303.16,97.17 302.26,97.17 302.21,97.22 302.21,97.75 302.26,97.8 303.7,97.8
+3V_S5 on BOTTOM (solid shape): 290.7,123.72 290.7,123.53 289.93,122.76 289.93,122.6 289.95,122.59 289.95,122.28 289.94,122.27 289.54,122.27 289.52,122.29 289.52,123.21 290.19,123.88 290.53,123.88
+3V_S5 on BOTTOM (solid shape): 203.18,87.92 203.18,86.02 202.82,85.66 201.31,85.66 200.7,86.27 200.66,86.3 200.64,86.34 200.64,86.75 201,87.12 201.65,87.12 201.73,87.2 201.73,88.15 201.83,88.25 202.85,88.25
+3V_S5 on BOTTOM (solid shape): 121.4,145.98 121.41,145.97 121.46,145.93 121.52,145.92 121.86,145.92 122.01,145.76 122.01,145.5 121.77,145.26 121.38,145.26 121.06,145.57 120.68,145.57 120.64,145.58 120.63,145.62 120.63,145.95 120.66,145.99 121.38,145.99
+3V_S5 on BOTTOM (solid shape): 295.45,104.81 295.45,104.5 295.47,104.48 295.47,104.42 295.51,104.32 295.61,104.28 295.66,104.28 296.03,103.91 296.19,103.91 297.26,102.84 297.26,102.4 297.21,102.35 296.45,102.35 295.31,103.49 295.31,104.01 295.07,104.25 295.07,104.81 295.13,104.86 295.4,104.86
+3V_S5 on BOTTOM (solid shape): 203.92,48.14 203.93,48.12 204.04,48.01 204.04,47.71 204.02,47.69 203.66,47.69 203.54,47.81 203.46,47.81 203.44,47.82 203.26,47.86 203.07,47.82 202.94,47.69 202.47,47.69 202.44,47.71 202.44,47.92 202.47,47.94 202.89,47.94 203.12,48.17 203.12,48.48 203.22,48.59 203.47,48.59
+3V_S5 on BOTTOM (solid shape): 215.07,51.78 215.09,51.77 215.16,51.72 215.22,51.71 215.62,51.71 215.65,51.68 215.65,51.19 215.22,50.76 215.2,50.76 215.12,50.72 215.08,50.64 215.08,50.63 214.91,50.46 214.63,50.46 214.58,50.51 214.58,51.09 214.58,51.13 214.56,51.17 214.56,51.32 214.53,51.35 214.53,51.43 214.37,51.59 214.37,51.75 214.4,51.78
+3V_S5 on BOTTOM (solid shape): 246.98,37.33 247,37.31 246.99,37.27 246.95,37.18 246.94,37.07 246.96,36.93 247.04,36.8 247.04,36.46 246.89,36.31 245.82,36.31 245.72,36.41 245.72,36.79 245.77,36.84 246.21,36.84 246.31,36.95 246.31,36.96 246.35,37.01 246.37,37.08 246.37,37.28 246.37,37.33 246.38,37.35 246.46,37.43 246.89,37.43
+3V_S5 on BOTTOM (solid shape): outline of 125 points within 84.15,61.8 88.52,86.88
+3V_S5 on BOTTOM (solid shape): 223.49,56.09 223.53,56.02 223.53,55.63 223.69,55.46 223.72,55.46 224.23,54.95 226.72,54.95 227.26,54.42 228.96,54.42 229.19,54.65 229.19,55.06 229.34,55.21 230.25,55.21 230.36,55.11 230.36,53.54 230.35,53.54 230.35,52.99 230.02,52.66 229.88,52.66 229.43,52.21 229.43,52.07 229.26,51.91 228.93,51.91 228.85,51.99 228.85,52.38 228.85,52.4 228.86,52.45 228.91,52.46 228.97,52.44 229.04,52.44 229.31,53.11 228.64,52.83 228.66,52.71 228.72,52.6 228.73,52.58 228.73,52.57 228.71,52.53 228.68,52.52 228.64,52.52 228.63,52.53 228.41,52.53 228.39,52.54 228.37,52.55 228.34,52.59 228.3,52.63 228.26,52.7 228.28,52.77 228.34,52.88 228.36,53.01 228.25,53.28 227.97,53.4 227.78,53.35 227.62,53.21 227.6,53.2 225.48,53.2 224.51,54.17 223.73,54.17 222.59,55.31 222.59,55.63 222.59,55.75 222.59,56.16 222.74,56.3 223.28,56.3
+3V_S5 on BOTTOM (solid shape): outline of 194 points within 48.14,83.51 77.47,97.24
+3V_S5 on IN1 (solid shape): 226.65,212.59 226.65,212.1 226.42,211.88 225.66,211.88 225.33,212.21 223.57,212.21 222.68,211.32 221.85,211.32 221.69,211.47 221.69,212.43 221.87,212.61 222.71,212.61 223.09,212.99 226.24,212.99
+3V_S5 on IN2 (solid shape): outline of 156 points within 221.6,209.59 235.37,216.07
+3V_S5 on IN2 (solid shape): outline of 147 points within 145.18,77.25 202.8,88.1
+3V_S5 on SVCC1 (solid shape): outline of 171 points within 144.78,50.38 271.27,80.9
+3V_S5 on IN3 (solid shape): 226.27,212.79 226.27,211.93 226.24,211.9 225.38,211.9 225.1,212.18 224.77,212.18 224.54,212.41 223.9,212.41 223.22,211.72 223.22,211.32 223.07,211.16 221.85,211.16 221.59,211.42 221.59,212.33 221.87,212.61 222.48,212.61 222.76,212.89 226.16,212.89
+3V_S5 on IN3 (solid shape): outline of 2970 points within 75.9,76.21 149.05,86.93
+3V_S5 on IN4 (solid shape): outline of 967 points within 268.66,72.07 303.96,98.24
+3V_SSD1 on TOP (solid shape): 100.99,93.03 102.03,93.03 102.03,93.02 104.3,93.02 104.65,92.66 104.65,90.42 104.28,90.05 99.85,90.05 99.67,90.23 99.67,92.27 100.47,93.07 100.95,93.07
+3V_SSD1 on TOP (solid shape): 103.02,81.29 103.02,81.14 103.03,81.13 103.03,76.54 102.53,76.03 98.36,76.03 97.93,76.46 97.93,77.86 97.92,77.9 98.04,78.01 98.79,78.01 98.98,78.2 98.98,80.94 99.02,81.02 99.11,81.04 99.16,81.03 99.44,81.1 99.59,81.29 99.59,81.3 99.64,81.34 102.97,81.34
+3V_SSD1 on BOTTOM (solid shape): outline of 444 points within 98.3,75.27 107.74,93.75
+3V_SSD2 on TOP (solid shape): 101.28,69.99 101.28,67.06 101.14,66.92 95.18,66.92 94.86,67.23 94.86,69.92 94.87,69.92 94.87,70.17 94.89,70.19 95.32,70.19 95.37,70.17 95.4,70.17 96.77,70.17 96.81,70.17 96.85,70.19 96.96,70.19 97.15,70.38 100.89,70.38
+3V_SSD2 on BOTTOM (solid shape): outline of 189 points within 96.09,50.2 105.74,69.18
+3V_SUS on TOP (solid shape): 59.01,58.05 59.01,56.68 57.81,55.49 57.81,54.4 57.46,54.04 56.49,54.04 56.19,54.34 56.19,55.16 56.54,55.51 56.54,57.14 56.34,57.34 56.34,57.35 56.28,57.41 56.21,57.43 55.67,57.43 55.5,57.6 55.5,58.1 55.52,58.13 55.55,58.15 58.91,58.15
+3V_SUS on BOTTOM (solid shape): 25.95,68.56 25.95,68.28 25.96,68.26 25.96,67.73 25.56,67.32 24.97,67.32 24.62,66.97 23.8,66.97 23.74,67.03 23.74,67.09 23.73,67.1 23.73,67.63 23.85,67.76 24.51,67.76 24.84,68.09 24.84,68.59 25.07,68.82 25.68,68.82
+3V_SUS on BOTTOM (solid shape): 314.63,97.12 314.58,97.07 312.61,97.07 312.51,96.97 311.2,96.97 310.82,96.58 309.02,96.58 309.02,96.59 308.98,96.59 308.58,96.99 308.54,96.99 308.01,96.99 307.75,97.09 307.49,96.99 307.13,96.99 306.89,97.07 306.66,96.99 306.46,96.99 306.36,97.04 306.25,97.05 305.97,96.94 305.85,96.66 305.86,96.56 305.9,96.47 305.92,96.43 305.86,96.37 305.8,96.38 305.75,96.39 305.47,96.27 305.36,95.98 305.33,95.9 305.26,95.87 305.03,95.87 304.86,96.04 304.86,96.59 305.82,97.55 307.32,97.55 307.44,97.67 308.6,97.67 309.13,97.14 310.72,97.14 311.32,97.74 312.36,97.74 312.39,97.74 314.63,97.74
+3V_SUS on IN3 (solid shape): outline of 557 points within 24.56,55.86 57,69.13
+3V_TCSS on TOP (solid shape): 205.7,185.29 205.7,185.29 205.68,185.21 205.67,185.13 205.68,185.06 205.7,184.98 205.7,184.59 206.13,184.16 207.13,184.16 207.55,184.58 208.01,184.58 208.13,184.46 208.13,184.17 207.77,183.82 206.78,183.82 206.56,183.59 206.56,183.01 206.5,182.95 205.62,182.95 205.48,183.09 205.48,183.75 205.23,184 205.23,185.32 205.02,185.53 203.55,185.53 203.1,185.08 203.1,184.3 203,184.2 202.36,184.2 202.23,184.06 201.69,184.06 201.66,184.08 201.64,184.11 201.64,185.68 201.75,185.78 205.21,185.78
+3V_TCSS on BOTTOM (solid shape): 208.54,186.2 208.54,185.27 208.51,185.27 208.51,184.48 208.54,184.48 208.54,184.36 208.21,184.03 207.73,184.03 207.59,184.17 207.59,184.42 207.98,184.81 207.98,186.24 208.02,186.28 208.46,186.28
+3V_THM on TOP (solid shape): 262.03,217.8 262.03,217.49 261.85,217.31 261.68,217.31 261.68,216.74 261.63,216.69 261.2,216.69 261.1,216.79 261.1,217.23 260.84,217.49 260.84,217.76 260.93,217.84 261.98,217.84
+3V_THM on BOTTOM (solid shape): 256.29,214.01 257.18,214.01 257.55,213.63 257.55,212.64 257.76,212.43 257.76,212.1 257.64,211.98 257.35,211.98 257.25,212.09 257.25,213.15 257.12,213.27 256.54,213.27 256.44,213.37 255.86,213.37 255.8,213.43 255.8,213.92 255.89,214.01 256.28,214.01
+3V_THM on BOTTOM (solid shape): 262.52,217.7 262.52,217.68 262.52,216.78 262.51,216.74 262.47,216.73 262.02,216.73 262,216.7 261.76,216.7 261.7,216.76 260.15,216.76 260.1,216.81 260.1,217.16 260.14,217.2 260.34,217.2 260.4,217.18 260.45,217.18 260.5,217.18 260.56,217.2 260.67,217.2 260.78,217.31 260.78,217.37 260.79,217.38 260.83,217.47 260.84,217.58 260.83,217.66 260.8,217.75 260.79,217.76 260.8,217.79 260.86,217.86 262.36,217.86
+3V_THM on IN4 (solid shape): 262.17,217.7 262.17,215.3 261.04,214.17 260.83,214.17 260.8,214.18 260.65,214.35 260.46,214.4 260.22,214.31 260.11,214.06 260.11,214.05 259.98,213.92 259.98,212.41 259.84,212.27 258.73,212.27 258.62,212.38 258.62,212.55 258.47,212.71 258.05,212.71 257.74,212.39 257.74,212.11 257.47,211.84 257.17,211.84 256.94,212.07 256.94,212.9 258.26,214.22 258.26,214.38 259.3,215.41 260.21,215.41 260.85,216.06 260.85,217.76 260.95,217.85 262.02,217.85
+3V_THM2 on BOTTOM (solid shape): 212.39,106.43 212.39,106.14 212.08,105.82 211.89,105.82 211.74,105.67 211.74,103.96 211.98,103.72 213.47,103.72 214.86,102.32 214.86,101 214.56,100.69 214.56,98.22 214.4,98.06 210.74,98.06 210.68,98 210.27,98 210.24,98.04 210.24,98.22 210.33,98.32 210.98,98.32 211.02,98.32 211.06,98.36 212.9,98.36 212.94,98.32 213.81,98.32 214.04,98.55 214.04,101.77 212.72,103.08 212.72,103.08 212.62,103.19 210.9,103.19 210.79,103.07 210.22,103.07 210.16,103.12 210.16,105.17 210.36,105.37 210.36,106.38 210.49,106.51 212.32,106.51
+3V_U3 on TOP (solid shape): 24.39,67.48 25.08,66.78 25.08,66.44 24.5,65.86 24.5,65.41 24.26,65.16 23.83,65.16 23.73,65.27 23.73,65.7 23.37,66.05 23.37,66.17 23.39,66.19 23.41,66.23 23.41,66.27 23.41,66.65 23.41,66.69 23.39,66.73 23.37,66.75 23.37,66.92 23.28,67.01 23.28,67.44 23.32,67.48 23.93,67.48
+3V_U3 on BOTTOM (solid shape): 23.6,67.04 23.6,66.97 23.8,66.76 24.64,66.76 24.79,66.92 25.09,66.92 25.25,66.76 25.25,65.32 24.67,64.74 24.67,63.7 25.07,63.3 25.07,62.8 24.96,62.68 24.42,62.68 23.05,64.05 23.05,64.96 23.09,65.04 23.18,65.06 23.25,65.04 23.31,65.04 23.7,65.43 23.31,65.82 23.22,65.81 23.13,65.78 23.1,65.78 23.07,65.79 23.02,65.85 23.02,65.99 22.7,66.31 21.5,66.31 21.34,66.47 20.65,66.47 20.62,66.49 20.6,66.52 20.6,67.04 21.29,67.72 22.91,67.72
+3V_U3 on BOTTOM (solid shape): outline of 151 points within 12.33,62.76 17.9,67.12
+3V_U3 on IN3 (solid shape): 25.15,63.43 25.15,62.95 24.86,62.66 23.72,62.66 23.6,62.73 23.47,62.75 23.26,62.68 23.13,62.5 23.13,62.49 22.47,61.82 22.16,61.82 22.15,61.83 22.01,61.85 21.87,61.83 21.86,61.82 17.99,61.82 17.73,62.08 16.67,62.08 16.57,62.19 16.57,62.48 16.34,62.71 15.81,62.71 15.62,62.9 15.62,63.41 15.67,63.46 16.93,63.46 17.62,62.77 20.63,62.77 21.12,63.26 22.17,63.26 22.19,63.28 22.2,63.28 22.32,63.36 22.4,63.48 22.4,63.49 22.57,63.66 24.91,63.66
+3VPCU on TOP (solid shape): 50.4,97.85 50.4,96.71 50.27,96.58 48.34,96.58 48.26,96.66 48.26,97.78 48.42,97.93 50.32,97.93
+3VPCU on TOP (solid shape): 80.24,50.81 80.24,49.72 80.11,49.58 77.92,49.58 77.78,49.72 77.78,50.75 77.93,50.9 80.16,50.9
+3VPCU on TOP (solid shape): 142.12,210.05 142.12,209.64 141.89,209.41 140.95,209.41 140.77,209.59 140.77,210 141.07,210.3 141.86,210.3
+3VPCU on TOP (solid shape): 267.74,68.92 267.74,67.62 267.67,67.55 265.84,67.55 265.64,67.75 265.64,69.33 265.72,69.42 267.25,69.42
+3VPCU on TOP (solid shape): 72.76,45.27 72.76,43.34 72.73,43.31 72.26,43.31 72.16,43.41 72.16,44.13 72.17,44.14 72.17,44.27 71.61,44.84 71.61,45.51 71.85,45.75 72.27,45.75
+3VPCU on TOP (solid shape): 259.49,60.47 259.49,59.95 259.71,59.73 259.93,59.73 259.96,59.7 259.96,59.34 259.94,59.33 259.63,59.33 259.6,59.35 259.6,59.36 258.83,60.13 258.83,60.52 258.94,60.63 259.34,60.63
+3VPCU on TOP (solid shape): 77.63,87.43 77.63,86.72 77.63,86.71 77.6,86.62 77.59,86.53 77.6,86.44 77.63,86.35 77.63,86.34 77.63,86.15 77.43,85.95 75.95,85.95 75.85,86.04 75.85,86.93 76.52,87.59 77.47,87.59
+3VPCU on TOP (solid shape): 167.22,77.12 167.22,76.68 167.21,76.63 167.15,76.57 166.86,76.57 166.85,76.56 166.82,76.56 166.72,76.52 166.68,76.42 166.68,76.39 166.53,76.24 165.38,76.24 165.23,76.39 165.23,76.95 165.46,77.18 167.16,77.18
+3VPCU on TOP (solid shape): 223.05,188 223.05,187.61 223.08,187.52 223.17,187.48 223.22,187.47 223.22,187.1 222.74,186.62 221.39,186.62 221.13,186.37 219.65,186.37 219.62,186.4 219.62,186.66 219.96,187.01 220.54,187.01 220.95,187.42 222.14,187.42 222.79,188.07 223.05,188.07
+3VPCU on TOP (solid shape): 20.36,94.5 21.47,94.5 21.78,94.19 21.78,93.47 21.63,93.32 19.43,93.32 19.33,93.43 19.33,93.65 19.34,93.71 19.34,94.36 19.35,94.4 19.38,94.42 19.43,94.42 19.43,94.79 19.44,94.83 19.48,94.84 19.59,94.84 20.02,94.84
+3VPCU on TOP (solid shape): 150.07,60.69 150.13,60.66 150.19,60.65 150.58,60.65 150.69,60.55 150.69,59.87 150.66,59.83 150.08,59.83 150.02,59.77 149.83,59.77 149.78,59.79 149.74,59.79 149.46,59.79 149.42,59.79 149.37,59.77 148.96,59.77 148.8,59.93 148.8,60.57 148.92,60.69 149.97,60.69 149.97,60.7 150.05,60.7
+3VPCU on TOP (solid shape): 17.08,93.66 17.07,93.61 17.07,93.41 17.08,93.32 17.12,93.27 17.21,93.27 17.59,93.27 17.65,93.21 17.65,93 17.59,92.95 17.32,92.95 17.11,92.94 16.91,92.93 16.5,92.93 16.39,93.04 16.39,93.72 16.47,93.8 16.94,93.8
+3VPCU on TOP (solid shape): 267.2,200.49 267.66,200.49 267.68,200.51 268.31,200.51 268.55,200.27 269.06,200.27 269.19,200.13 269.19,199.73 269.17,199.7 268.69,199.7 268.44,199.95 267.59,199.95 267.51,199.97 267.44,199.98 267.37,199.97 267.29,199.95 267.09,199.95 267.04,199.9 265.72,199.9 265.69,199.93 265.69,200.15 265.7,200.19 265.74,200.2 267,200.2 267,200.4 265.74,200.4 265.7,200.41 265.69,200.45 265.69,200.65 265.7,200.69 265.74,200.7 267,200.7
+3VPCU on TOP (solid shape): 18.49,78.18 18.6,78.07 18.6,78.07 18.68,77.96 18.79,77.89 18.8,77.89 18.83,77.86 19.49,77.86 19.55,77.84 19.6,77.84 19.66,77.84 19.71,77.86 19.73,77.86 19.77,77.82 19.77,77.23 19.7,77.16 19.7,76.76 19.6,76.66 17.74,76.66 17.68,76.72 17.68,76.98 17.69,77.02 17.69,77.67 17.7,77.71 17.73,77.73 17.78,77.73 17.78,78.1 17.79,78.14 17.83,78.15 18.3,78.15 18.38,78.16 18.44,78.18 18.46,78.19
+3VPCU on TOP (solid shape): outline of 516 points within 136.55,45.65 151.49,68.87
+3VPCU on BOTTOM (solid shape): 269.27,200.45 269.27,200.03 269.04,199.8 268.16,199.8 267.87,200.1 267.87,200.52 267.95,200.61 268.13,200.61 268.19,200.61 269.1,200.61
+3VPCU on BOTTOM (solid shape): 140.96,50.13 143.85,50.13 144.15,49.82 144.15,47.68 144.02,47.55 140.2,47.55 140.06,47.41 140.06,45.95 139.77,45.66 138.6,45.66 138.26,46 138.26,46.93 137.8,47.39 137.8,49.98 138.05,50.23 140.86,50.23
+3VPCU on BOTTOM (solid shape): outline of 285 points within 47.12,50 81.33,101.05
+3VPCU on IN3 (solid shape): outline of 3624 points within 77.72,42.2 144.4,57.67
+3VPCU on IN3 (solid shape): outline of 5755 points within 144.86,47.34 269.34,69.8
+3VPCU_EC on TOP (solid shape): 188.87,69.79 188.87,68.98 188.81,68.91 188.01,68.91 187.94,68.94 187.77,69.32 187.45,69.45 187.38,69.44 187.31,69.42 187.28,69.42 187.26,69.44 187.24,69.45 185.8,69.45 185.73,69.52 185.71,69.54 185.68,69.56 185.66,69.59 185.64,69.62 185.64,69.9 185.68,69.94 188.72,69.94
+3VPCU_EC on IN2 (solid shape): outline of 190 points within 164.15,55.21 176.43,60.23
+3VSPI on BOTTOM (solid shape): 246.98,57.05 247.02,57.03 247.03,56.99 247.03,55.17 246.73,54.87 245.23,54.87 244.99,55.11 244.99,56.1 245.23,56.34 245.94,56.34 246.45,56.85 246.45,56.96 246.54,57.05
