# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TCP0_TXRX_P0: length 155.3
  TOP w0.14: C246.1 45.15,90.48 arc(45.2,90.51) 45.25,90.52 45.4,90.52 arc(45.48,90.5) 45.55,90.46 v1(45.78,90.23)
  IN4 w0.086: v1(45.78,90.23) 45.78,90.32 arc(45.79,90.36) 45.81,90.4 45.96,90.54 arc(45.99,90.56) 46.04,90.57 46.6,90.57 47.26,90.45 48.54,90.68 49.79,90.46 51.33,90.73 52.25,91.3 52.5,91.66 53.72,92.52 54.43,93.52 54.86,93.82 55.08,94.35 55.08,95.13 55.23,95.55 55.84,96.16 56.23,96.28 56.73,96.19 57.94,96.4 58.36,96.33 59.97,96.33 60.14,96.5 61.17,97.23 61.7,97.42 61.91,97.42 62.89,97.25 64.27,97.49 65.52,97.27 66.77,97.49 68.02,97.27 69.27,97.49 70.53,97.27 71.78,97.49 73.03,97.27 74.28,97.49 75.53,97.27 76.78,97.49 78.03,97.27 79.28,97.49 80.53,97.27 81.78,97.49 83.03,97.27 84.28,97.49 85.53,97.27 86.78,97.49 88.04,97.27 88.98,97.44 89.82,97.65 90.22,97.78 90.62,97.91 92.21,98.55 93.03,99.19 93.04,99.21 94.08,99.94 94.54,100.59 95.43,101.21 97.93,101.65 99.18,101.43 99.21,101.44 100.43,101.65 101.32,101.5 102.57,101.72 103.35,102.13 106.26,105.04 106.94,107.59 106.83,108.22 107,109.21 106.78,110.46 107.05,111.98 106.84,113.12 106.83,113.23 107.05,114.48 106.83,115.73 107.05,116.98 106.83,118.23 107.05,119.48 106.83,120.73 107.05,121.99 106.86,123.05 107.01,123.88 107.01,124.4 107.41,126.73 108.08,128.5 109.06,129.9 109.76,132.11 109.76,133.74 109.96,134.91 109.84,135.61 110,136.52 110,138.33 110.61,139.47 110.82,139.68 111.03,140.82 114.5,145.77 115.77,146.66 115.97,146.95 116.1,147.03 116.89,147.83 116.89,148.79 117.02,149.49 116.7,151.3 117.49,155.8 119.43,157.74 120.54,158.52 126.83,159.63 127.04,159.6 128.29,159.82 129.54,159.6 130.79,159.82 132.04,159.6 132.87,159.74 133.79,159.74 134.44,159.86 134.84,159.86 134.84,159.86 135.57,159.99 140.37,159.14 140.75,158.61 arc(141.01,158.3) 141.32,158.03 141.68,157.78 arc(141.7,157.76) 141.72,157.75 142.07,157.4 arc(142.09,157.36) 142.1,157.32 142.1,155.59 arc(142.2,155.35) 142.44,155.25 arc(142.5,155.24) 142.54,155.21 v2(142.74,155.01)
  BOTTOM w0.079: v2(142.74,155.01) 142.74,155.16 arc(142.74,155.2) 142.77,155.23 142.8,155.26 arc(142.83,155.28) 142.86,155.29 143.36,155.29 144.09,154.55 arc(144.13,154.5) 144.14,154.44 144.14,153.69 arc(144.11,153.6) 144.03,153.56 arc(144.01,153.56) 144,153.56 arc(144,153.56) 144,153.56 143.95,153.56 arc(143.86,153.6) 143.82,153.69 143.82,153.94 U42.BL41
TCP0_TXRX_P0_C: length 3.8
  TOP w0.079: 42.43,90.49 42.41,90.49 42.36,90.54 41.9,90.54 arc(41.86,90.54) 41.82,90.53 arc(41.78,90.51) 41.73,90.49 arc(41.7,90.47) 41.67,90.45 arc(41.59,90.4) 41.51,90.39 41.31,90.39 arc(41.21,90.44) 41.2,90.55 arc(41.23,90.6) 41.29,90.62 U9.G1
  TOP w0.14: 42.43,90.49 44.19,90.49 arc(44.25,90.48) 44.29,90.45 C246.2
TCP0_TXRX_P1: length 164.3
  TOP w0.14: C260.1 45.06,88.74 arc(45.16,88.81) 45.28,88.83 45.43,88.83 arc(45.52,88.81) 45.59,88.76 v1(45.82,88.54)
  IN4 w0.086: v2(144.83,155.81) 144.7,155.69 arc(144.63,155.64) 144.54,155.62 144.47,155.62 arc(144.43,155.63) 144.39,155.65 144.28,155.76 arc(144.25,155.81) 144.24,155.87 144.24,157.03 arc(144.19,157.32) 144.06,157.58 143.34,158.61 arc(143.09,158.91) 142.8,159.15 142.11,159.63 141.38,160.68 140.12,161.56 140.01,161.56 138.2,161.88 136.58,161.6 135.71,161.75 134.67,161.56 134.42,161.56 133.64,161.43 133.33,161.43 133.02,161.48 132.04,161.31 130.79,161.53 130.76,161.52 129.54,161.31 128.29,161.53 127.95,161.47 125.85,161.84 122.8,161.3 122.77,161.32 119.67,160.77 118.23,159.76 117.5,158.72 116.39,157.94 114.93,155.86 112.92,154.45 112.19,153.41 111.15,152.68 110.56,151.84 110.18,151.57 109.86,151.25 109.57,149.61 110,147.17 109.86,146.38 109.96,145.8 109.77,144.7 109.9,143.98 109.59,142.27 109.3,141.85 109.08,140.57 108.3,138.65 108.3,136.58 108.13,135.61 108.25,134.91 108.07,133.92 108.07,132.61 108,132.14 107.61,130.9 107.26,130.66 106.79,129.98 105.65,127.32 105.49,127.17 105.26,125.83 105.32,125.47 105.32,125.22 105.38,124.88 105.32,124.54 105.32,124.13 105.23,123.59 105.14,123.1 105.34,121.99 105.11,120.73 105.33,119.48 105.11,118.23 105.33,116.98 105.11,115.73 105.33,114.48 105.11,113.23 105.13,113.12 105.33,111.98 105.07,110.46 105.29,109.2 105.09,108.06 105.17,107.61 104.7,105.98 102.51,103.79 101.81,103.38 101.06,103.25 100.43,103.36 99.18,103.14 97.89,103.37 97.34,103.27 96.84,103.18 96.36,103.27 95.52,103.27 94.61,102.92 94.35,102.65 93.49,102.04 92.84,101.13 91.26,100.02 89.38,99.3 87.8,99.03 86.78,99.2 85.53,98.98 84.28,99.2 83.03,98.98 81.78,99.2 80.53,98.98 79.28,99.2 78.03,98.98 76.78,99.2 75.53,98.98 74.28,99.2 73.03,98.98 71.78,99.2 70.53,98.98 69.27,99.2 68.02,98.98 66.77,99.2 65.52,98.98 64.27,99.2 63.02,98.98 61.97,99.17 61.62,99.11 60.26,99.11 59.93,98.78 59.57,98.27 59.22,98.02 58.5,98.02 57.94,98.11 56.75,97.91 56.12,98.02 55.31,98.02 54.9,97.84 54.36,97.3 54.17,97.03 53.14,96.31 52.73,95.73 52.5,95.49 52.01,95.32 51.57,95.32 51.19,95.2 50.98,94.99 50.86,94.82 50.74,94.65 49.93,94.08 49.6,93.62 49.52,93.54 49.02,93.23 48.33,93.11 47.79,93.21 47.1,93.46 46.79,93.46 46.03,93.59 45.33,93.47 45.16,93.39 44.94,93.17 44.88,93.02 44.88,92.84 44.94,92.52 44.77,91.56 44.98,90.36 arc(44.99,90.31) 44.98,90.27 44.94,90.01 arc(44.92,89.89) 44.92,89.76 44.92,89.37 arc(45.09,88.96) 45.49,88.79 45.59,88.79 arc(45.75,88.73) 45.82,88.57 v1(45.82,88.54)
  BOTTOM w0.079: U42.BK40 144.61,153.29 arc(144.67,153.35) 144.74,153.39 arc(144.79,153.42) 144.84,153.44 arc(144.84,153.44) 144.85,153.45 144.85,153.45 arc(145.04,153.6) 145.11,153.83 145.11,153.99 arc(145.14,154.12) 145.21,154.22 arc(145.36,154.45) 145.41,154.71 145.41,155.33 arc(145.33,155.54) 145.12,155.62 145.05,155.62 arc(145.01,155.63) 144.98,155.66 v2(144.83,155.81)
TCP0_TXRX_P1_C: length 4
  TOP w0.079: 42.43,89.56 42.41,89.56 42.36,89.61 41.91,89.61 arc(41.83,89.59) 41.76,89.55 41.75,89.53 arc(41.68,89.49) 41.59,89.47 41.3,89.47 arc(41.2,89.54) 41.22,89.67 arc(41.26,89.69) 41.3,89.7 U9.E1
  TOP w0.14: 42.43,89.56 42.89,89.56 arc(43.06,89.53) 43.2,89.43 43.58,89.05 arc(43.79,88.91) 44.04,88.86 44.12,88.86 arc(44.22,88.84) 44.3,88.79 C260.2
TCP1_AN_RBIAS: length 1.2
  TOP w0.079: U16.L4 35.44,74.89 v2(35.31,74.75)
  BOTTOM w0.14: R942.1 35.41,74.85 v2(35.31,74.75)
TCP1_AN_RSENSE: length 1.3
  TOP w0.079: U16.L5 34.98,75.08 v2(34.67,74.77)
  BOTTOM w0.14: v2(34.67,74.77) 34.96,75.05 R942.2
TCP1_FLASH_BUSY#: length 28.9
  TOP w0.079: U16.A9 33.14,70.22 32.95,70.02 32.95,69.85 32.25,69.15
  TOP w0.14: 32.25,69.15 31.58,68.48 31.58,66.94 31.25,66.61 R468.1 30.1,66.61 29.92,66.43 29.92,65.77 v1(30.03,65.67) ; R261.1 35.37,82.41 35.51,82.55 v1(35.51,82.92)
  IN2 w0.089: v1(30.03,65.67) 30.03,66.18 29.74,66.47 29.74,68.05 29.98,68.29 30.99,68.29 31.12,68.42 31.12,70.21 31.68,70.77 31.68,74.96 32.57,75.86 33.29,75.86 35.75,78.32 35.75,82.68 v1(35.51,82.92)
TCP01_FLASH_BUSY#: length 0.6
  TOP w0.14: R243.2 R261.2
TCP1_FLASH_CLK: length 50.4
  TOP w0.079: U16.C7 33.64,71.78 v2(33.96,71.47)
  TOP w0.14: v1(51.48,93.44) 51,93.44 50.71,93.15 R165.1
  IN2 w0.089: v1(51.48,93.44) 51.48,93.67 51.79,93.98 53.16,93.98 53.44,93.7 53.44,92.71 49.31,88.58 49.31,86.94 48.76,86.4 48.76,84.18 48.16,83.58 45.68,83.58 44.74,82.64 44.74,78.6 43.96,77.83 43.96,76.28 43.79,76.1 43.79,75.17 42.87,74.25 42.87,69.13 42.29,68.55 37.76,68.55 37.18,69.14 35.9,69.14 35.46,68.71 34.87,68.71 34.07,67.91 32.66,67.91 32.14,68.43 32.14,69.99 33.19,71.03 33.52,71.03 v2(33.96,71.47)
TCP1_FLASH_CS#: length 27
  TOP w0.079: v1(34.93,69.58) 34.74,69.77 34.74,70.83 U16.B6
  TOP w0.14: R232.1 47.52,83.68 v1(46.68,84.53)
  IN2 w0.089: v1(46.68,84.53) 45.3,84.53 43.8,83.03 43.8,78.99 43.24,78.43 41.64,78.43 40.01,76.8 40.01,71.84 39.63,71.46 36.81,71.46 v1(34.93,69.58)
TCP1_FLASH_DI: length 46.7
  TOP w0.079: U16.C6 34.29,71.74 v2(34.56,71.48)
  TOP w0.14: R166.1 52.68,93.25 v1(52.94,93.51)
  IN2 w0.089: v1(52.94,93.51) 52.94,92.87 48.84,88.78 48.84,87.13 48.3,86.59 48.3,84.38 47.98,84.06 45.49,84.06 44.27,82.83 44.27,78.8 43.49,78.03 43.49,76.47 43.32,76.29 43.32,75.36 42.4,74.45 42.4,69.33 42.1,69.02 39.91,69.02 38.87,70.07 38.36,70.07 38.2,69.91 38.2,69.53 37.98,69.3 37.7,69.3 37.32,69.69 35.78,69.69 35.27,69.18 34.67,69.18 33.87,68.38 32.86,68.38 32.61,68.62 32.61,69.8 33.38,70.56 33.74,70.56 34.56,71.38 v2(34.56,71.48)
TCP1_FLASH_DO: length 31.5
  TOP w0.079: 36.52,69.15 36.33,69.34 36.33,69.71 35.66,70.37 35.66,70.82 U16.B4
  TOP w0.14: 36.52,69.15 36.6,69.06 v1(36.6,68.67) ; v1(47.98,83.11) 48.57,82.51 v1(49.36,82.51) 50.33,82.51 50.8,82.99 R235.1
  IN2 w0.089: v1(47.98,83.11) 45.87,83.11 45.21,82.44 45.21,78.41 44.43,77.64 44.43,76.08 44.26,75.9 44.26,74.97 43.34,74.06 43.34,68.94 42.48,68.08 37.55,68.08 36.96,68.67 v1(36.6,68.67)
TCP1_FLASH_MSTR_SLV: length 5.5
  TOP w0.079: U16.A5 34.98,70.11 35.33,69.76 35.33,69.43 35.06,69.15
  TOP w0.14: 35.06,69.15 34.93,69.03 R448.2 35.08,68.13 35.37,67.85 35.37,66.98 R473.1 34.93,66.61 R470.1
TCP1_FLASH_SHARE_EN: length 5
  TOP w0.079: 35.95,69.15 35.95,69.76 35.44,70.26 U16.A4
  TOP w0.14: 35.95,69.15 35.95,68.67 36.48,68.13 R450.2 36.84,68.13 37.11,67.87 37.11,67.49 37.34,67.25 R471.1
TCP1_GPIO_5: length 3.9
  TOP w0.079: 31.59,69.19 31.66,69.25 31.94,69.25 32.91,70.22 32.91,70.81 U16.B9
  TOP w0.14: R444.1 31.12,68.71 v1(31.44,69.03) 31.59,69.19
TCP1_GPIO_6: length 5.9
  TOP w0.079: 32.65,69.15 33.18,69.68 33.18,70 33.6,70.43 U16.A8
  TOP w0.14: R475.2 32.76,66.57 32.72,66.61 R469.1 32.04,66.61 31.86,66.78 31.86,68.37 32.65,69.15
TCP1_GPIO_7: length 6.7
  TOP w0.079: v1(33.65,69.85) 33.84,70.04 33.84,70.8 U16.B8
  BOTTOM w0.14: R973.1 R1227.1 34.39,68.03 ; v1(33.65,69.85) 34.34,69.17 v1(34.34,68.83) 34.34,68.65 34.39,68.6 34.39,68.03 ; 34.39,68.03 R972.1
TCP1_GPIO_12: length 4.8
  TOP w0.079: U16.A6 34.52,70.17 34.52,69.15
  TOP w0.14: 34.52,69.15 34.17,68.8 34.17,68.44 34.04,68.31 R447.2 34.3,68.13 34.44,67.99 34.44,66.73 34.28,66.57 R476.1
TCP1_JTAG_TCK: length 5.4
  TOP w0.079: U16.B5 35.21,70.82 35.21,70.19 35.68,69.72 35.68,69.43 35.44,69.18 35.44,69.15
  TOP w0.14: 35.44,69.15 TP56.1 35.44,68.67 35.82,68.29 R449.2 36.07,68.13 36.22,67.98 36.22,67.44 36.31,67.35 36.31,66.91 36.55,66.66 R466.2
TCP1_JTAG_TDI: length 3.5
  TOP w0.079: 37.14,69.15 37,69.29 35.9,70.39 U16.A3
  TOP w0.14: 37.14,69.15 37.34,68.95 TP57.1 37.34,68.42 37.62,68.13 R451.2
TCP1_JTAG_TDO: length 3.6
  TOP w0.079: U16.C5 34.97,71.81 v2(35.3,72.15)
  BOTTOM w0.14: v2(35.3,72.15) 35.49,71.95 35.49,71.28 35.98,70.8 TP149.1 36.8,70.04 R963.2
TCP1_JTAG_TMS: length 6.4
  TOP w0.079: U16.C3 35.91,71.5 v2(35.93,71.5)
  TOP w0.14: R453.2 39.5,68.57 TP58.1 39.24,69 v1(38.61,69.64)
  IN3 w0.089: v2(35.93,71.5) 36.04,71.5 36.07,71.46 37.85,71.46 38.61,70.7 v1(38.61,69.64)
TCP1_RESET#: length 11.2
  TOP w0.079: 30.84,76.65 31.7,76.65 32.46,75.89 32.46,75.42 U16.L11
  TOP w0.14: R323.1 R314.1 26.01,79.31 26.42,79.72 R299.2 R313.1 R324.1 26.96,77.86 27.2,77.61 27.59,77.61 v1(27.92,77.28) 28.3,76.9 29.59,76.9 29.84,76.65 30.84,76.65
TCP1_TEST_PWRGD: length 4.5
  TOP w0.079: 36.83,69.95 36.6,69.95 36.12,70.42 36.12,70.82 U16.B3
  TOP w0.14: 36.83,69.95 37.85,68.92 37.85,68.68 37.99,68.54 38.47,68.54 38.74,68.28 R452.1
TCP1_THERMDA: length 2.3
  TOP w0.14: TP49.1 30.64,76.24 30.74,76.34 31.65,76.34 32.22,75.77 U16.M11
TCP2_AUX_DN: length 185
  TOP w0.14: R303.1 34.08,79.94 arc(34.15,80.03) 34.19,80.14 arc(34.2,80.18) 34.2,80.23 34.2,80.46 arc(34.17,80.63) 34.07,80.78 v1(33.94,80.91)
  IN4 w0.086: v2(139.5,151.65) 139.35,151.65 arc(139.28,151.63) 139.24,151.57 arc(139.24,151.57) 139.24,151.56 arc(139.2,151.43) 139.12,151.32 138.99,151.19 arc(138.9,151.13) 138.79,151.11 138.54,151.11 arc(138.43,151.13) 138.34,151.19 137.92,151.62 arc(137.88,151.64) 137.84,151.65 137.37,151.65 136.6,151.52 135.84,151.65 135.25,151.55 134.86,151.62 134.66,151.76 134.39,152.14 134.32,152.54 134.48,153.42 134.83,153.93 134.9,154.33 134.87,154.52 134.66,154.82 134.29,154.97 133.15,154.97 132.39,154.84 130.7,155.13 129.62,154.94 128.26,155.18 127.13,154.98 126.81,154.53 122.84,153.83 122.39,153.52 121.82,152.7 121.45,150.61 121.68,149.31 121.45,148.03 121.45,145.94 119.44,143.92 118.25,142.23 118.07,141.23 116,138.27 114.99,137.26 114.78,136.71 114.69,136.19 114.69,134.42 114.83,133.65 114.83,132.31 114.56,130.75 114.56,129.23 112.63,126.48 112.6,126.4 111.71,124.16 111.52,123.07 111.7,122 111.62,121.52 111.47,120.66 111.68,119.48 111.45,118.23 111.73,116.65 111.56,115.65 111.75,114.54 111.55,113.41 111.6,113.12 111.8,112.03 111.51,110.41 111.6,109.88 111.7,109.32 111.56,108.49 111.86,106.78 111.69,105.81 111.56,104.35 111.48,104.05 111.39,103.73 110.24,102.11 109.21,101.38 108.48,100.34 107.44,99.61 106.71,98.57 105.67,97.84 105.42,97.49 104.94,96.8 103.88,96.06 103.15,95.02 102.14,94.31 101.94,94.02 101.69,93.77 101.41,93.2 101.41,92.79 101.41,92.78 101.57,91.87 101.35,90.62 101.57,89.37 101.35,88.12 101.57,86.86 101.41,85.97 101.41,84.91 101.28,84.35 100.51,83.59 100.27,83.24 99.64,82.8 98.91,81.76 97.87,81.03 97.68,80.75 96.74,79.82 95.69,79.35 94.59,79.15 93.48,79.35 92.23,79.13 90.98,79.35 89.73,79.13 88.48,79.35 87.23,79.13 87.2,79.13 85.97,79.35 84.59,79.1 83.48,79.3 82.55,79.14 82.07,78.8 81.4,77.84 80.3,77.07 78.72,76.79 77.48,77.01 76.22,76.79 74.97,77.01 73.72,76.79 72.47,77.01 72.18,76.96 71.6,76.96 70.67,77.29 70.36,77.29 69.55,77.15 68.41,77.35 67.16,77.13 65.91,77.35 64.66,77.13 63.41,77.35 62.16,77.13 60.91,77.35 59.66,77.13 58.41,77.35 57.16,77.13 55.9,77.35 54.65,77.13 53.4,77.35 52.15,77.13 51.28,77.28 50.92,77.17 50.89,77.13 50.65,76.8 50.01,76.35 49.28,75.31 48.24,74.58 47.51,73.54 46.98,73.17 46.48,72.46 45.48,71.76 44.75,70.72 43.66,69.96 43.23,69.35 42.75,69.01 42.58,68.84 42.34,68.84 42.23,68.85 41.49,68.73 41.11,68.79 40.26,69.64 39.32,74.97 39.55,76.26 39.44,76.85 39.6,77.72 39.56,77.95 39.56,78.33 39.15,78.61 38.43,79.64 37.86,80.04 36.91,80.2 35.8,80.01 35.22,80.11 34.99,80.11 arc(34.73,80.16) 34.52,80.31 34.41,80.42 arc(34.35,80.49) 34.31,80.56 arc(34.29,80.64) 34.28,80.72 34.28,80.79 arc(34.24,80.88) 34.16,80.91 v1(33.94,80.91)
  BOTTOM w0.14: v2(139.5,151.65) 139.53,151.65 arc(139.65,151.63) 139.74,151.56 139.82,151.49 arc(139.87,151.42) U42.BU37
TCP2_AUX_DN_R: length 4.4
  TOP w0.079: 34.12,77.56 34.12,77.54 34.16,77.49 34.16,77.18 33.67,76.68 33.67,76.33 33.53,76.19 33.53,76.09 33.67,75.95 33.67,75.81 arc(33.65,75.72) U16.M8
  TOP w0.14: R303.2 34.19,79.24 arc(34.2,79.24) 34.21,79.23 34.25,79.2 arc(34.26,79.19) 34.26,79.18 34.26,78.73 arc(34.26,78.69) 34.24,78.65 arc(34.15,78.47) 34.12,78.26 34.12,77.56
TCP2_AUX_DP: length 185
  TOP w0.14: v1(34.79,80.91) 34.57,80.69 arc(34.5,80.58) 34.47,80.46 34.47,80.07 arc(34.5,79.91) 34.6,79.76 R304.1
  IN4 w0.086: v2(139.5,152.31) 139.5,152.23 arc(139.49,152.18) 139.47,152.15 139.22,151.9 arc(139.19,151.87) 139.17,151.83 arc(139.14,151.76) 139.11,151.7 arc(139.09,151.66) 139.08,151.61 arc(139.05,151.51) 138.98,151.42 138.87,151.31 arc(138.84,151.28) 138.79,151.28 138.54,151.28 arc(138.5,151.28) 138.46,151.31 138.03,151.74 arc(137.94,151.8) 137.84,151.82 137.35,151.82 136.6,151.69 135.84,151.82 135.25,151.72 134.92,151.77 134.78,151.88 134.55,152.2 134.49,152.54 134.63,153.35 134.99,153.86 135.07,154.33 135.02,154.59 134.77,154.95 134.33,155.14 133.13,155.14 132.39,155.01 130.7,155.3 129.62,155.11 128.26,155.35 127.04,155.13 126.72,154.68 122.77,153.98 122.28,153.64 121.66,152.76 121.29,150.61 121.51,149.31 121.29,148.04 121.29,146.01 119.31,144.03 118.09,142.29 117.92,141.3 115.87,138.38 114.85,137.35 114.62,136.76 114.53,136.2 114.53,134.41 114.66,133.63 114.66,132.32 114.39,130.77 114.39,129.28 112.49,126.56 112.48,126.53 111.55,124.21 111.38,123.27 111.35,123.07 111.54,122 111.48,121.66 111.3,120.66 111.51,119.48 111.29,118.23 111.57,116.65 111.39,115.65 111.59,114.54 111.39,113.41 111.44,113.12 111.63,112.03 111.34,110.41 111.53,109.32 111.39,108.49 111.69,106.78 111.52,105.83 111.46,105.11 111.4,104.38 111.24,103.8 110.12,102.22 109.09,101.5 108.36,100.46 107.32,99.73 106.59,98.69 105.55,97.96 105.42,97.77 104.83,96.92 103.76,96.17 103.03,95.13 102.02,94.43 101.81,94.13 101.55,93.87 101.25,93.24 101.25,92.81 101.24,92.78 101.4,91.87 101.18,90.62 101.41,89.37 101.18,88.12 101.41,86.86 101.25,85.98 101.25,84.93 101.13,84.44 100.39,83.7 100.15,83.36 99.52,82.92 98.79,81.88 98.48,81.66 97.75,81.15 97.55,80.86 96.64,79.95 95.64,79.51 94.59,79.32 93.48,79.52 92.23,79.29 90.98,79.51 89.73,79.29 88.48,79.51 87.23,79.29 85.97,79.51 84.59,79.27 83.48,79.47 82.49,79.3 81.95,78.92 81.28,77.95 80.24,77.23 78.72,76.96 77.48,77.18 76.22,76.96 74.97,77.18 73.72,76.96 72.47,77.18 72.16,77.13 71.63,77.13 70.7,77.46 70.35,77.46 69.55,77.32 68.41,77.52 67.16,77.29 65.91,77.52 64.66,77.29 63.41,77.52 62.16,77.29 60.91,77.52 59.66,77.29 58.41,77.52 57.16,77.29 55.9,77.52 54.65,77.29 53.4,77.52 52.15,77.29 51.26,77.45 50.83,77.31 50.76,77.24 50.53,76.92 49.89,76.47 49.16,75.43 48.12,74.7 47.39,73.66 46.86,73.29 46.37,72.58 45.36,71.88 44.63,70.84 43.54,70.07 43.11,69.47 42.64,69.13 42.51,69 42.35,69 42.23,69.02 41.49,68.89 41.19,68.95 40.41,69.72 39.49,74.97 39.72,76.26 39.61,76.85 39.76,77.72 39.72,77.96 39.72,78.41 39.27,78.73 38.55,79.75 37.93,80.19 36.91,80.37 35.8,80.18 35.23,80.28 34.99,80.28 arc(34.8,80.31) 34.64,80.42 34.52,80.54 arc(34.49,80.58) 34.46,80.62 arc(34.45,80.67) 34.45,80.72 34.45,80.81 arc(34.47,80.88) 34.55,80.91 v1(34.79,80.91)
  BOTTOM w0.14: U42.BU38 139.6,152.27 arc(139.55,152.3) v2(139.5,152.31)
TCP2_AUX_DP_R: length 4.4
  TOP w0.079: U16.L8 33.64,75.23 arc(33.79,75.44) 33.84,75.7 33.84,76.61 34.33,77.11 34.33,77.49 34.38,77.54 34.38,77.56
  TOP w0.14: 34.38,77.56 34.38,78.26 arc(34.4,78.39) 34.46,78.5 arc(34.51,78.61) 34.53,78.73 34.53,78.91 arc(34.57,79.08) 34.67,79.23 R304.2
TCP2_TX_N0: length 167.2
  TOP w0.14: v1(41.18,75.45) 40.96,75.23 arc(40.88,75.17) 40.78,75.15 40.69,75.15 arc(40.61,75.17) 40.55,75.21 C371.1
  IN4 w0.086: v1(41.18,75.45) 41.27,75.36 arc(41.3,75.33) 41.33,75.3 41.47,75.19 arc(41.51,75.17) 41.55,75.16 41.64,75.16 arc(41.77,75.16) 41.89,75.14 42.3,75.07 arc(42.42,75.06) 42.55,75.07 43.35,75.21 arc(43.47,75.22) 43.6,75.21 43.96,75.15 43.96,75.15 44.44,75.06 45.29,75.21 46.08,75.76 46.49,76.34 47.53,77.07 48.25,78.11 48.9,78.56 49.03,78.74 50.18,79.89 50.56,80.03 51.46,80.03 52.15,79.91 53.4,80.13 54.65,79.91 55.9,80.13 57.16,79.91 58.41,80.13 59.66,79.91 60.91,80.13 61.88,79.96 63.13,80.18 64.66,79.91 65.88,80.12 65.91,80.13 67.16,79.91 68.41,80.13 69.55,79.93 70.12,80.03 71.91,80.03 72.47,80.13 73.72,79.91 74.97,80.13 76.22,79.91 77.56,80.14 78.81,79.91 79.53,80.04 80.16,80.43 80.52,80.95 81.64,81.73 82.91,81.73 83.47,81.83 84.72,81.61 85.97,81.83 87.23,81.61 88.48,81.83 89.73,81.61 90.98,81.83 92.23,81.61 93.48,81.83 94.25,81.7 95.08,81.84 95.61,82.14 95.79,82.32 96.11,82.79 97.15,83.52 97.88,84.56 98.48,84.97 98.51,85 98.59,85.11 98.63,85.16 98.84,85.37 98.92,85.82 98.92,86.19 99.04,86.86 98.89,87.76 98.89,88.47 99.04,89.37 98.82,90.62 99.04,91.87 98.88,92.77 98.92,93 98.92,94.07 99.24,94.79 100.05,95.6 100.38,96.06 101.36,96.75 102.09,97.79 103.19,98.56 103.92,99.6 104.96,100.33 105.69,101.37 106.73,102.1 107.45,103.14 108.39,103.79 108.92,104.55 109.15,105.43 109.27,106.8 109.01,108.24 109.18,109.18 108.94,110.5 109.23,112.1 109,113.39 109.19,114.48 108.98,115.7 108.97,115.73 109.19,116.98 108.97,118.23 109.19,119.48 109.09,120.09 108.97,120.73 109.19,121.98 109.01,123.05 109.12,123.7 109.12,123.99 109.4,125.6 110.04,127.15 112.1,130.09 112.1,131.99 111.89,133.2 112.09,134.31 112.15,135.08 112.05,135.66 112.11,136.02 112.11,137.16 112.63,138.37 113.55,139.28 115.68,142.38 115.79,142.99 117,144.71 117,144.71 117.55,145.5 119.01,146.95 119.01,148.44 119.18,149.41 118.93,150.81 119.52,154.15 120.42,155.43 122.17,156.66 126.83,157.48 127.04,157.45 128.29,157.67 129.54,157.45 130.69,157.65 132.17,157.39 132.7,157.48 133.95,157.48 135.12,157.69 135.99,157.69 136.72,157.56 138.65,156.21 139.29,155.76 139.32,155.72 139.42,155.16 140.48,153.65 140.54,153.28 140.72,153.1 arc(140.89,152.85) 140.95,152.56 140.95,152.21 arc(140.93,152.1) 140.87,152.01 140.81,151.95 arc(140.72,151.89) 140.61,151.87 arc(140.53,151.85) 140.46,151.81 v2(140.31,151.66)
  BOTTOM w0.14: U42.BT37 140.38,151.63 arc(140.35,151.65) v2(140.31,151.66)
TCP2_TX_N0_C: length 4
  TOP w0.079: U16.J2 36.48,74.38 arc(36.59,74.46) 36.73,74.48 37.03,74.48 arc(37.1,74.47) 37.17,74.43 37.18,74.42 arc(37.24,74.37) 37.31,74.36 37.79,74.36 37.84,74.41 37.86,74.41
  TOP w0.14: 37.86,74.41 38.38,74.41 arc(38.55,74.44) 38.69,74.54 39.15,75 arc(39.32,75.11) 39.52,75.15 39.56,75.15 arc(39.65,75.17) 39.73,75.22 C371.2
TCP2_TX_N1: length 164.9
  TOP w0.14: v1(41.24,70.49) 41.02,70.27 arc(40.94,70.22) 40.85,70.2 40.71,70.2 arc(40.62,70.22) 40.54,70.27 C410.1
  IN4 w0.086: v1(41.24,70.49) 41.24,70.27 arc(41.29,70.15) 41.42,70.1 42.53,70.1 42.66,70.23 42.95,70.64 44.13,71.46 44.86,72.5 45.87,73.22 46.3,73.82 46.85,74.21 47.58,75.25 48.62,75.98 49.34,77.02 49.99,77.47 50.09,77.61 50.2,77.76 50.5,78.06 50.83,78.22 51.3,78.22 52.15,78.07 53.4,78.29 54.65,78.07 55.9,78.29 57.16,78.07 58.41,78.29 59.66,78.07 60.91,78.29 62.16,78.07 63.41,78.29 64.66,78.07 65.91,78.29 67.16,78.07 68.41,78.29 69.55,78.09 70.28,78.22 71.01,78.22 71.84,77.89 72.1,77.89 72.47,77.95 73.72,77.73 74.97,77.95 76.22,77.73 77.47,77.95 78.72,77.73 79.94,77.95 80.73,78.5 81.48,79.56 82.14,80.03 83.42,80.25 84.6,80.04 85.97,80.29 87.23,80.07 88.48,80.29 89.73,80.07 90.98,80.29 92.23,80.07 93.48,80.29 94.46,80.12 95.5,80.3 96.27,80.66 96.96,81.35 97.2,81.7 98.24,82.42 98.97,83.46 99.6,83.9 99.8,84.19 99.8,84.19 100.36,84.75 100.44,85.05 100.44,86.05 100.59,86.86 100.41,87.85 100.41,88.38 100.59,89.37 100.37,90.62 100.59,91.87 100.43,92.78 100.44,92.87 100.44,93.41 100.78,94.17 101.22,94.62 101.47,94.97 102.47,95.67 103.2,96.71 104.28,97.47 105.01,98.51 106.05,99.24 106.78,100.28 107.82,101 108.55,102.05 109.56,102.75 110.42,103.99 110.66,104.73 110.66,105.33 110.92,106.78 110.62,108.5 110.76,109.33 110.56,110.48 110.83,111.99 110.63,113.12 110.56,113.49 110.77,114.65 110.6,115.61 110.79,116.69 110.52,118.23 110.74,119.48 110.52,120.73 110.74,121.98 110.55,123.02 110.83,124.61 111.38,125.97 111.75,126.88 113.63,129.56 113.63,130.83 113.9,132.39 113.9,133.57 113.74,134.49 113.74,135.88 113.74,136.89 114.1,137.69 115.23,138.81 117.07,141.44 117.24,142.39 118.73,144.52 120.52,146.32 120.52,148.11 120.74,149.31 120.5,150.64 120.94,153.16 121.64,154.16 123.31,155.32 124.99,155.62 125.19,155.58 128.26,156.12 129.52,155.9 130.68,156.1 132.37,155.81 133.04,155.92 134.45,155.92 135.18,155.8 135.62,155.49 135.82,155.2 136.24,154.91 136.55,154.85 137.38,154.27 137.68,153.84 138.02,153.6 138.26,153.36 138.29,153.31 arc(138.36,153.16) 138.4,152.99 arc(138.41,152.94) 138.41,152.88 138.41,152.39 arc(138.42,152.35) 138.45,152.32 138.47,152.29 arc(138.5,152.27) 138.53,152.27 138.59,152.27 arc(138.63,152.28) 138.67,152.3 v2(138.71,152.34)
  BOTTOM w0.14: U42.BW38 138.76,152.32 arc(138.74,152.34) v2(138.71,152.34)
TCP2_TX_N1_C: length 4.4
  TOP w0.079: U16.C2 36.49,71.63 arc(36.61,71.71) 36.76,71.74 36.99,71.74 arc(37.08,71.72) 37.16,71.67 37.17,71.66 arc(37.25,71.61) 37.34,71.59 37.79,71.59 37.84,71.64 37.86,71.64
  TOP w0.14: C410.2 39.7,70.24 arc(39.66,70.21) 39.6,70.2 39.54,70.2 arc(39.49,70.21) 39.44,70.24 38.09,71.59 arc(38.03,71.63) 37.97,71.64 37.86,71.64
TCP2_TX_P0: length 167.2
  TOP w0.14: C382.1 40.55,74.83 arc(40.61,74.87) 40.69,74.89 40.78,74.89 arc(40.88,74.87) 40.96,74.81 v1(41.18,74.59)
  IN4 w0.086: v2(140.29,152.34) 140.29,152.21 arc(140.34,152.09) 140.46,152.04 140.61,152.04 arc(140.65,152.04) 140.69,152.07 140.75,152.13 arc(140.77,152.17) 140.78,152.21 140.78,152.56 arc(140.74,152.79) 140.61,152.98 140.39,153.2 140.38,153.25 140.32,153.58 139.26,155.09 139.16,155.65 138.5,156.11 136.65,157.4 135.98,157.52 135.13,157.52 133.97,157.32 132.71,157.32 132.17,157.23 130.69,157.48 129.54,157.28 128.29,157.5 127.04,157.28 126.83,157.32 122.24,156.51 120.53,155.32 119.67,154.08 119.1,150.81 119.35,149.41 119.34,149.38 119.17,148.43 119.17,146.88 117.68,145.39 117.14,144.62 117.13,144.61 115.95,142.92 115.84,142.32 113.67,139.17 112.77,138.27 112.28,137.13 112.28,136 112.22,135.66 112.32,135.09 112.25,134.29 112.06,133.2 112.27,132 112.27,130.04 110.19,127.07 109.56,125.55 109.28,123.97 109.28,123.68 109.17,123.05 109.36,121.98 109.14,120.73 109.29,119.88 109.36,119.48 109.14,118.23 109.36,116.98 109.14,115.73 109.36,114.48 109.17,113.39 109.39,112.1 109.11,110.5 109.35,109.18 109.18,108.24 109.43,106.81 109.31,105.4 109.08,104.48 108.51,103.68 107.57,103.02 106.84,101.98 105.8,101.25 105.08,100.21 104.04,99.48 103.31,98.44 102.21,97.67 101.48,96.63 100.5,95.94 100.18,95.49 99.38,94.69 99.09,94.04 99.09,92.99 99.05,92.77 99.21,91.87 98.99,90.62 99.21,89.37 99.05,88.46 99.05,87.78 99.21,86.86 99.09,86.17 99.09,85.8 98.99,85.29 98.75,85.06 98.63,84.88 98.59,84.85 98.48,84.77 98,84.44 97.27,83.4 96.23,82.67 95.92,82.22 95.71,82.01 95.13,81.68 94.25,81.53 93.48,81.66 92.23,81.44 90.98,81.66 89.73,81.44 88.48,81.66 87.23,81.44 85.97,81.66 84.72,81.44 83.47,81.66 82.93,81.57 81.69,81.57 80.64,80.83 80.27,80.31 79.59,79.88 78.81,79.74 77.56,79.97 76.22,79.74 74.97,79.96 73.72,79.74 72.47,79.96 71.93,79.86 70.14,79.86 69.55,79.76 68.41,79.96 67.16,79.74 65.91,79.96 64.66,79.74 63.13,80.01 61.88,79.79 60.91,79.96 59.66,79.74 58.41,79.96 57.16,79.74 55.9,79.96 54.65,79.74 53.4,79.96 52.15,79.74 51.45,79.86 50.59,79.86 50.27,79.75 49.16,78.64 49.02,78.44 48.37,77.99 47.64,76.95 46.6,76.22 46.2,75.64 45.36,75.05 44.44,74.89 43.57,75.05 arc(43.47,75.06) 43.37,75.05 42.58,74.91 arc(42.42,74.89) 42.27,74.91 41.86,74.98 arc(41.75,74.99) 41.64,75 41.35,75 arc(41.29,74.99) 41.24,74.95 41.23,74.94 arc(41.19,74.89) 41.18,74.83 v1(41.18,74.59)
  BOTTOM w0.14: U42.BT38 140.67,152.09 arc(140.66,152.14) 140.63,152.19 140.52,152.3 arc(140.47,152.33) 140.42,152.34 v2(140.29,152.34)
TCP2_TX_P0_C: length 4
  TOP w0.079: 37.86,74.14 37.84,74.14 37.79,74.19 37.35,74.19 arc(37.26,74.17) 37.18,74.12 37.17,74.11 arc(37.09,74.06) 37,74.04 36.74,74.04 arc(36.62,74.15) 36.74,74.27 U16.J1
  TOP w0.14: 37.86,74.14 38.38,74.14 arc(38.65,74.2) 38.88,74.35 39.34,74.81 arc(39.42,74.87) 39.52,74.89 39.56,74.89 arc(39.65,74.87) 39.73,74.82 C382.2
TCP2_TX_P1: length 165
  TOP w0.14: v1(41.24,69.64) 41.02,69.86 arc(40.94,69.91) 40.85,69.93 40.71,69.93 arc(40.61,69.92) 40.54,69.86 C416.1
  IN4 w0.086: v1(41.24,69.64) 41.47,69.86 arc(41.54,69.91) 41.63,69.93 42.6,69.93 42.79,70.12 43.07,70.52 44.25,71.34 44.98,72.38 45.99,73.1 46.42,73.7 46.97,74.09 47.69,75.13 48.73,75.86 49.46,76.9 50.11,77.35 50.32,77.65 50.6,77.93 50.87,78.06 51.29,78.06 52.15,77.9 53.4,78.12 54.65,77.9 55.9,78.12 57.16,77.9 58.41,78.12 59.66,77.9 60.91,78.12 62.16,77.9 63.41,78.12 64.66,77.9 65.91,78.12 67.16,77.9 68.41,78.12 69.55,77.92 70.3,78.06 70.97,78.06 71.8,77.73 72.11,77.73 72.47,77.79 73.72,77.57 74.97,77.79 76.22,77.57 77.47,77.79 78.72,77.57 80.01,77.79 80.04,77.81 80.85,78.38 81.59,79.44 82.21,79.87 83.42,80.08 84.6,79.88 85.97,80.12 87.23,79.9 88.48,80.12 89.73,79.9 90.98,80.12 92.23,79.9 93.48,80.12 94.46,79.95 95.55,80.14 96.37,80.52 97.09,81.24 97.32,81.58 98.36,82.31 98.59,82.63 99.09,83.35 99.72,83.79 99.93,84.08 100.51,84.66 100.61,85.03 100.61,86.04 100.76,86.86 100.58,87.86 100.58,88.37 100.76,89.37 100.53,90.62 100.75,91.87 100.59,92.78 100.61,92.86 100.61,93.37 100.92,94.07 101.35,94.51 101.59,94.85 102.59,95.55 103.32,96.59 104.4,97.35 105.13,98.39 106.17,99.12 106.9,100.16 107.94,100.89 108.67,101.93 109.67,102.64 110.57,103.91 110.83,104.71 110.83,105.31 111.09,106.78 110.78,108.5 110.93,109.33 110.73,110.48 110.99,111.99 110.8,113.12 110.73,113.49 110.93,114.65 110.77,115.61 110.96,116.69 110.68,118.23 110.9,119.48 110.68,120.73 110.9,121.98 110.72,123.02 110.99,124.56 111.9,126.8 113.8,129.51 113.8,130.82 114.07,132.38 114.07,133.59 113.91,134.51 113.91,135.88 113.91,136.85 114.24,137.59 115.36,138.7 117.22,141.37 117.39,142.33 118.86,144.41 120.69,146.25 120.69,148.09 120.91,149.31 120.67,150.64 121.1,153.09 121.76,154.04 123.37,155.16 124.99,155.45 125.19,155.41 128.26,155.95 129.52,155.73 130.68,155.94 132.37,155.64 133.05,155.76 134.43,155.76 135.12,155.64 135.5,155.37 135.71,155.08 136.14,154.77 136.17,154.75 136.48,154.7 137.26,154.15 137.56,153.72 137.92,153.47 138.06,153.33 138.13,153.26 138.15,153.23 arc(138.21,153.1) 138.24,152.97 arc(138.25,152.92) 138.25,152.88 138.25,152.39 arc(138.27,152.29) 138.33,152.2 138.68,151.85 arc(138.7,151.81) 138.71,151.77 v2(138.71,151.68)
  BOTTOM w0.14: U42.BW37 138.79,151.65 arc(138.75,151.67) v2(138.71,151.68)
TCP2_TX_P1_C: length 4.4
  TOP w0.079: 37.86,71.37 37.84,71.37 37.79,71.42 37.36,71.42 arc(37.26,71.4) 37.17,71.35 37.16,71.34 arc(37.08,71.28) 36.98,71.26 36.69,71.26 36.63,71.33 36.63,71.44 36.7,71.5 U16.C1
  TOP w0.14: 37.86,71.37 37.93,71.37 39.25,70.05 arc(39.38,69.96) 39.54,69.93 39.56,69.93 arc(39.65,69.91) 39.74,69.86 C416.2
TCP2_TXRX_N0: length 172.1
  TOP w0.14: C387.1 40.53,73.58 arc(40.6,73.53) 40.68,73.52 40.83,73.52 arc(40.91,73.53) 40.98,73.58 v1(41.21,73.81)
  IN4 w0.086: v1(41.21,73.81) 41.37,73.65 arc(41.4,73.56) 41.37,73.47 arc(41.24,73.38) 41.09,73.35 40.88,73.35 arc(40.87,73.35) 40.86,73.35 arc(40.79,73.37) 40.72,73.41 40.59,73.52 arc(40.57,73.56) 40.56,73.61 40.56,74.2 40.47,74.7 40.54,75.13 40.49,75.45 40.55,75.8 40.69,76.01 40.87,76.13 41.31,76.21 41.96,76.09 42.74,76.23 43.82,76.04 45.43,76.33 47.1,77.49 47.83,78.53 48.48,78.99 48.57,79.13 49.89,80.45 50.32,80.62 51.51,80.62 52.15,80.51 53.4,80.73 54.65,80.51 55.9,80.73 57.16,80.51 58.41,80.73 59.66,80.51 60.91,80.73 61.86,80.56 63.11,80.78 64.66,80.51 65.91,80.73 67.16,80.51 68.41,80.73 69.55,80.53 70.07,80.62 71.86,80.62 72.47,80.73 73.72,80.51 74.97,80.73 76.22,80.51 76.25,80.51 77.56,80.75 78.81,80.52 79.08,80.57 79.77,80.96 80.11,81.44 80.74,81.88 81.37,82.33 82.86,82.33 83.47,82.43 84.72,82.21 85.97,82.43 87.23,82.21 88.48,82.43 89.73,82.21 90.98,82.43 92.23,82.21 92.26,82.22 93.48,82.43 94.22,82.3 94.76,82.4 95.27,82.66 95.62,83.17 96.73,83.94 97.45,84.98 97.9,85.3 98.2,85.6 98.33,85.98 98.33,86.24 98.44,86.86 98.27,87.84 98.27,88.39 98.44,89.37 98.2,90.75 98.41,91.98 98.28,92.75 98.33,93.05 98.33,94.31 98.48,94.66 98.62,95 99.6,95.98 99.95,96.49 100.92,97.17 101.65,98.21 102.76,98.99 103.49,100.03 104.53,100.75 105.26,101.79 106.3,102.52 107.06,103.6 107.92,104.21 108.12,104.5 108.59,107.19 108.4,108.26 108.55,109.13 108.32,110.46 108.59,111.98 108.39,113.12 108.37,113.23 108.59,114.48 108.37,115.73 108.59,116.98 108.37,118.23 108.59,119.48 108.37,120.73 108.38,120.79 108.59,121.98 108.4,123.05 108.52,123.75 108.52,124.08 108.84,125.9 109.42,127.29 111.05,129.63 111.49,131.01 111.49,131.87 111.38,132.49 111.28,133.08 111.28,133.39 111.54,134.87 111.4,135.63 111.52,136.3 111.52,137.33 112.14,138.72 114.86,142.6 115.24,143.25 115.89,144.17 115.89,144.17 115.97,144.28 115.96,144.28 117.07,145.85 117.07,145.85 118.41,147.2 118.41,148.65 118.56,149.49 118.3,150.94 118.94,154.58 119.71,155.68 121.92,157.22 126.83,158.09 127.04,158.05 128.29,158.27 129.54,158.05 130.73,158.26 132.16,158.01 132.63,158.09 133.87,158.09 135.5,158.38 137.01,158.11 137.06,158.1 138.92,157.78 139.4,157.3 arc(139.54,157.2) 139.7,157.17 arc(139.92,157.13) 140.1,157.01 140.25,156.86 arc(140.4,156.63) 140.45,156.37 140.45,156.36 arc(140.42,156.23) 140.33,156.13 arc(140.21,156.08) 140.09,156.06 139.93,156.06 arc(139.79,156.15) 139.82,156.32 v2(139.94,156.44)
  BOTTOM w0.102: v2(139.94,156.44) 139.94,156.26 arc(139.9,156.17) 139.8,156.13 139.8,156.12 139.61,156.12 arc(139.56,156.11) 139.5,156.1 arc(139.46,156.07) 139.41,156.04 139.36,155.98 arc(139.29,155.88) 139.27,155.76 139.27,155.28 arc(139.29,155.15) 139.36,155.05 140.16,154.26 arc(140.18,154.21) 140.19,154.16 140.19,153.84 arc(140.18,153.78) 140.15,153.74 arc(140.11,153.72) 140.07,153.72 140.07,153.72 arc(140.05,153.72) 140.04,153.72 arc(139.93,153.76) 139.88,153.87 U42.BU41
TCP2_TXRX_N0_C: length 3.8
  TOP w0.079: 37.86,73.48 37.84,73.48 37.79,73.43 37.28,73.43 arc(37.21,73.45) 37.14,73.49 37.13,73.5 arc(37.07,73.55) 36.99,73.56 36.73,73.56 arc(36.59,73.54) 36.48,73.46 U16.G2
  TOP w0.14: 37.86,73.48 39.52,73.48 arc(39.63,73.51) 39.73,73.57 C387.2
TCP2_TXRX_N1: length 165.5
  TOP w0.14: C398.1 40.58,71.88 arc(40.64,71.84) 40.71,71.83 40.86,71.83 arc(40.94,71.84) 41.02,71.89 v1(41.24,72.12)
  IN4 w0.086: v1(41.24,72.12) 41.5,71.86 arc(41.6,71.8) 41.71,71.78 41.84,71.78 42.39,71.68 43.12,71.81 43.66,72.18 44.39,73.22 45.44,73.96 45.7,74.33 46.3,74.75 47.03,75.79 48.07,76.52 48.8,77.56 49.45,78.01 49.61,78.25 50.49,79.13 50.95,79.27 51.39,79.27 52.15,79.13 53.4,79.36 54.65,79.13 55.9,79.36 57.16,79.13 58.41,79.36 59.66,79.13 60.87,79.35 61.95,79.16 63.24,79.39 64.66,79.13 65.91,79.36 67.16,79.13 68.41,79.36 69.55,79.16 70.19,79.27 71.98,79.27 72.47,79.36 73.72,79.13 74.97,79.36 76.34,79.11 77.59,79.33 78.79,79.12 79.92,79.32 80.67,79.79 81.09,80.4 81.91,80.97 82.98,80.97 83.47,81.06 84.72,80.84 85.97,81.06 87.23,80.84 88.48,81.06 89.73,80.84 90.98,81.06 92.23,80.84 93.48,81.06 94.41,80.9 95.2,81.03 95.88,81.34 96.37,81.84 96.66,82.24 97.7,82.97 98.43,84.01 98.48,84.05 99.06,84.45 99.21,84.67 99.64,85.1 99.68,85.41 99.68,86.12 99.82,86.86 99.65,87.81 99.65,88.42 99.82,89.37 99.6,90.62 99.82,91.87 99.66,92.78 99.68,92.94 99.68,93.76 99.94,94.41 100.64,95.11 100.93,95.52 101.44,95.88 101.44,95.88 101.91,96.21 102.06,96.42 102.64,97.25 103.73,98.01 104.46,99.05 105.5,99.78 106.23,100.82 107.27,101.55 108,102.59 108.99,103.29 109.66,104.24 109.88,104.78 109.88,105.06 109.91,105.43 110.07,106.34 110.07,107.24 109.84,108.52 109.98,109.32 109.76,110.59 110.01,112.04 109.82,113.12 109.77,113.4 109.96,114.48 109.76,115.67 109.98,116.9 109.74,118.23 109.96,119.48 109.74,120.73 109.96,121.98 109.78,123.05 109.88,123.63 109.88,123.88 110.12,125.28 110.87,127.01 112.87,129.86 112.87,130.88 112.87,132.06 112.67,133.21 112.93,134.7 112.93,137.13 113.35,138.01 114.16,138.82 116.33,141.71 116.51,142.69 118.14,145.01 119.76,146.64 119.76,148.31 119.96,149.38 119.71,150.74 120.25,153.79 120.88,154.69 122.73,155.99 124.99,156.39 125.19,156.35 128.29,156.9 129.55,156.68 130.69,156.88 132.18,156.62 132.7,156.71 134.05,156.71 135.23,156.91 136.03,156.77 136.1,156.7 136.63,156.33 137.23,155.48 137.54,155.26 137.68,155.12 arc(137.74,155.08) 137.81,155.07 138.31,155.07 arc(138.37,155.08) 138.42,155.11 138.48,155.18 arc(138.54,155.25) v2(138.55,155.35)
  BOTTOM w0.102: U42.BW40 139.23,153.42 arc(139.26,153.44) 139.29,153.46 arc(139.5,153.57) 139.59,153.79 139.59,154.3 arc(139.57,154.42) 139.5,154.52 139.15,154.87 arc(138.97,155) 138.75,155.07 arc(138.61,155.14) 138.55,155.29 v2(138.55,155.35)
TCP2_TXRX_N1_C: length 4
  TOP w0.079: U16.E2 36.48,72.54 arc(36.59,72.62) 36.73,72.64 36.99,72.64 arc(37.07,72.63) 37.14,72.58 37.15,72.57 arc(37.22,72.52) 37.3,72.51 37.79,72.51 37.84,72.55 37.86,72.55
  TOP w0.14: C398.2 39.73,71.92 arc(39.66,71.87) 39.59,71.86 39.46,71.86 arc(39.32,71.89) 39.19,71.97 38.81,72.35 arc(38.59,72.5) 38.32,72.55 37.86,72.55
TCP2_TXRX_P0: length 172.1
  TOP w0.14: C390.1 40.58,73.21 arc(40.63,73.24) 40.68,73.25 40.83,73.25 arc(40.91,73.23) 40.98,73.19 v1(41.21,72.96)
  IN4 w0.086: v2(139.94,155.67) 140.1,155.83 arc(140.12,155.84) 140.14,155.85 140.29,155.92 arc(140.33,155.94) 140.37,155.96 140.44,156.01 arc(140.51,156.06) 140.56,156.14 arc(140.6,156.24) 140.62,156.36 140.62,156.37 arc(140.55,156.7) 140.37,156.97 140.22,157.12 arc(139.98,157.28) 139.7,157.34 arc(139.64,157.34) 139.58,157.37 arc(139.55,157.39) 139.52,157.41 139.47,157.46 139,157.93 137.09,158.27 137.04,158.28 135.5,158.55 133.86,158.26 132.62,158.26 132.16,158.18 130.73,158.43 129.54,158.22 128.29,158.44 127.04,158.22 126.83,158.26 121.85,157.38 119.59,155.8 118.79,154.64 118.14,150.94 118.39,149.49 118.25,148.67 118.25,147.27 116.96,145.98 116.95,145.97 115.79,144.32 115.79,144.32 115.76,144.26 115.1,143.34 114.72,142.69 112,138.8 111.35,137.36 111.35,136.32 111.24,135.63 111.37,134.87 111.11,133.41 111.11,133.07 111.33,131.85 111.33,131.04 110.91,129.7 109.27,127.37 108.68,125.94 108.36,124.09 108.36,123.76 108.24,123.05 108.42,121.98 108.24,120.94 108.2,120.73 108.42,119.48 108.2,118.23 108.42,116.98 108.2,115.73 108.42,114.48 108.2,113.23 108.22,113.12 108.42,111.98 108.15,110.46 108.39,109.13 108.23,108.26 108.42,107.19 107.97,104.56 107.8,104.33 106.94,103.72 106.18,102.64 105.14,101.91 104.41,100.87 103.37,100.14 102.64,99.1 101.53,98.32 100.8,97.28 99.83,96.61 99.47,96.09 98.48,95.1 98.48,95.09 98.17,94.34 98.17,93.07 98.11,92.75 98.24,91.98 98.03,90.75 98.27,89.37 98.1,88.41 98.1,87.82 98.27,86.86 98.17,86.25 98.17,86.01 98.06,85.69 97.79,85.42 97.34,85.1 96.61,84.06 95.51,83.29 95.15,82.79 94.71,82.56 94.22,82.47 93.48,82.6 92.23,82.38 90.98,82.6 89.73,82.38 88.48,82.6 87.23,82.38 85.97,82.6 84.72,82.38 83.47,82.6 82.85,82.49 81.32,82.49 79.99,81.56 79.66,81.09 79.02,80.73 78.81,80.69 77.56,80.91 76.22,80.68 74.97,80.9 73.72,80.68 72.47,80.9 71.85,80.79 70.06,80.79 69.55,80.7 68.41,80.9 67.16,80.68 65.91,80.9 64.66,80.68 63.11,80.95 61.86,80.73 60.91,80.9 59.66,80.68 58.41,80.9 57.16,80.68 55.9,80.9 54.65,80.68 53.4,80.9 52.15,80.68 51.53,80.79 50.29,80.79 49.8,80.59 48.45,79.24 48.36,79.11 48.36,79.11 47.71,78.65 46.98,77.61 45.37,76.48 43.82,76.21 42.74,76.4 41.96,76.26 41.31,76.38 40.81,76.29 40.58,76.13 40.39,75.86 40.32,75.45 40.38,75.13 40.3,74.7 40.39,74.18 40.39,73.61 arc(40.41,73.49) 40.48,73.4 40.62,73.28 arc(40.73,73.22) 40.85,73.19 arc(40.85,73.19) 40.86,73.19 arc(40.98,73.16) 41.08,73.08 v1(41.21,72.96)
  BOTTOM w0.102: U42.BU40 139.88,153.39 arc(139.89,153.43) 139.91,153.46 139.95,153.51 arc(139.99,153.53) 140.03,153.54 140.07,153.54 arc(140.17,153.55) 140.26,153.6 arc(140.34,153.7) 140.37,153.84 140.37,154.17 arc(140.35,154.28) 140.29,154.38 139.49,155.18 arc(139.46,155.22) 139.45,155.28 139.45,155.76 arc(139.46,155.81) 139.49,155.85 139.54,155.91 arc(139.57,155.93) 139.61,155.94 139.7,155.94 arc(139.87,155.87) 139.94,155.69 v2(139.94,155.67)
TCP2_TXRX_P0_C: length 3.8
  TOP w0.079: 37.86,73.22 37.84,73.22 37.79,73.27 37.33,73.27 arc(37.29,73.26) 37.25,73.26 arc(37.2,73.24) 37.16,73.22 arc(37.13,73.2) 37.09,73.18 arc(37.02,73.13) 36.93,73.11 36.74,73.11 arc(36.64,73.17) 36.62,73.28 arc(36.66,73.33) 36.71,73.35 U16.G1
  TOP w0.14: C390.2 39.72,73.18 arc(39.68,73.21) 39.62,73.22 37.86,73.22
TCP2_TXRX_P1: length 165.5
  TOP w0.14: C404.1 40.49,71.47 arc(40.59,71.54) 40.71,71.56 40.86,71.56 arc(40.94,71.54) 41.02,71.49 v1(41.24,71.27)
  IN4 w0.086: v1(41.24,71.27) 41.24,71.44 arc(41.26,71.5) 41.29,71.56 arc(41.35,71.6) 41.42,71.61 41.83,71.61 42.39,71.51 43.19,71.65 43.78,72.07 44.51,73.11 45.56,73.84 45.82,74.21 46.42,74.63 47.15,75.67 48.19,76.4 48.92,77.44 49.56,77.9 49.74,78.15 50.57,78.98 50.98,79.1 51.38,79.1 52.15,78.97 53.4,79.19 54.65,78.97 55.9,79.19 57.16,78.97 58.41,79.19 59.66,78.97 60.87,79.18 61.95,78.99 63.24,79.22 64.63,78.97 64.66,78.97 65.91,79.19 67.13,78.97 67.16,78.97 68.41,79.19 69.55,78.99 70.2,79.1 71.99,79.1 72.47,79.19 73.72,78.97 74.97,79.19 76.34,78.95 77.59,79.17 78.79,78.96 79.98,79.17 80.78,79.67 81.21,80.28 81.96,80.81 83,80.81 83.47,80.89 84.72,80.67 85.97,80.89 87.23,80.67 88.48,80.89 89.73,80.67 90.98,80.89 92.23,80.67 92.26,80.67 93.48,80.89 94.41,80.73 95.25,80.88 95.98,81.21 96.5,81.73 96.78,82.12 97.82,82.85 98.48,83.8 98.55,83.89 98.59,83.92 99.18,84.33 99.34,84.57 99.79,85.02 99.85,85.4 99.85,86.11 99.98,86.86 99.81,87.83 99.81,88.4 99.98,89.37 99.76,90.62 99.98,91.87 99.82,92.78 99.85,92.92 99.85,93.73 100.08,94.32 100.77,95 101.04,95.4 102.03,96.09 102.2,96.33 102.76,97.13 103.85,97.89 104.58,98.93 105.62,99.66 106.35,100.7 107.39,101.43 108.12,102.47 109.11,103.17 109.81,104.16 110.04,104.75 110.04,105.05 110.07,105.41 110.23,106.32 110.23,107.25 110.01,108.52 110.15,109.32 109.93,110.59 110.18,112.04 109.99,113.12 109.94,113.4 110.13,114.48 109.93,115.67 110.15,116.9 109.91,118.23 110.13,119.48 109.91,120.73 110.13,121.98 109.95,123.05 110.04,123.62 110.04,123.87 110.28,125.23 111.02,126.93 111.38,127.45 113.04,129.81 113.04,130.88 113.04,132.08 112.84,133.21 113.1,134.69 113.1,137.09 113.49,137.91 114.29,138.71 116.48,141.64 116.67,142.62 118.26,144.9 119.93,146.57 119.93,148.3 120.12,149.38 119.88,150.74 120.41,153.73 121,154.57 122.79,155.83 124.99,156.22 125.19,156.18 128.29,156.73 129.55,156.51 130.69,156.71 132.18,156.45 132.72,156.54 134.06,156.54 135.23,156.74 135.95,156.62 136,156.57 136.52,156.21 137.11,155.36 137.43,155.14 137.57,155 arc(137.68,154.93) 137.81,154.9 138.41,154.9 arc(138.48,154.89) 138.55,154.84 138.55,154.84 arc(138.62,154.69) v2(138.55,154.54)
  BOTTOM w0.102: U42.BW41 139.1,153.79 arc(139.25,153.64) 139.41,153.79 139.41,154.3 arc(139.4,154.35) 139.37,154.39 139.02,154.75 arc(138.89,154.84) 138.73,154.89 arc(138.61,154.85) 138.55,154.73 v2(138.55,154.54)
TCP2_TXRX_P1_C: length 4
  TOP w0.079: 37.86,72.29 37.84,72.29 37.79,72.34 37.34,72.34 arc(37.26,72.32) 37.19,72.27 37.17,72.26 arc(37.1,72.22) 37.02,72.2 36.73,72.2 arc(36.63,72.27) 36.65,72.39 arc(36.69,72.42) 36.73,72.42 U16.E1
  TOP w0.14: C404.2 39.73,71.52 arc(39.65,71.57) 39.55,71.59 39.46,71.59 arc(39.22,71.64) 39.01,71.78 38.62,72.16 arc(38.48,72.26) 38.32,72.29 37.86,72.29
TCP_RCOMP: length 4
  BOTTOM w0.14: U42.BP41 142.07,154.12 142.07,156.07 143.04,157.04 R784.2
TCP_RETIMER_PERST#: length 300.7
  TOP w0.14: v1(227.08,58.66) 226.72,58.3 226.72,57.65 226.16,57.08 U28.4 225.04,57.08 224.75,57.37 224.75,58.55 224.39,58.92 224.39,59.48 224.69,59.78 224.87,59.78 225.08,59.99 R537.2 R536.1 224.38,60.57 224.25,60.71 223.65,60.71 223.12,60.18 R550.1 ; v1(34.85,65.62) 35.44,65.03 37.62,65.03 38.55,65.96 39.9,65.96 41.47,67.53 46.36,67.53 47.46,66.42 47.46,65.88 53.68,59.66 59.71,59.66 60.1,59.27 73.31,59.27 75.08,61.04 88.23,61.04 v1(92.15,57.11)
  IN4 w0.086: v1(227.08,58.66) 227.66,58.66 228.45,57.87 228.78,57.87 229.16,57.49 229.16,56.91 229.09,56.83 229.09,56.12 229.32,55.89 230.85,55.89 231,55.73 231.98,55.73 233.43,54.27 233.43,51.13 234.23,50.33 234.23,47.38 232.04,45.19 230.72,45.19 230.27,44.74 230.27,43.06 228.6,41.39 220.64,41.39 219.27,40.02 210.21,40.02 209.3,40.93 199.83,40.93 194.87,45.89 191.93,45.89 185.22,52.6 182.57,52.6 180.89,54.28 178.57,54.28 177.68,55.17 177.68,58.63 176.79,59.52 175.81,59.52 174.65,60.68 173.35,60.68 172.77,61.26 171.39,61.26 171.11,61.54 170.25,61.54 169.85,61.94 169.12,61.94 166.29,64.76 161.78,64.76 161.55,64.54 153.96,64.54 153.62,64.2 152.36,64.2 148.99,60.83 145.06,60.83 144.79,61.1 142.42,61.1 140.32,58.99 136.73,58.99 134.91,57.17 131.65,57.17 130.67,56.19 126.2,56.19 124.3,54.28 122.05,54.28 118.96,51.2 114.22,51.2 113.56,50.53 111.78,50.53 111.26,50.01 109.29,50.01 109.07,49.78 106.78,49.78 101.55,55.01 96.31,55.01 94.21,57.11 v1(92.15,57.11)
  BOTTOM w0.14: R973.2 35.41,66.17 v1(34.85,65.62) 35.28,65.18 37.61,65.18 41.5,69.07 42.18,69.07 47.17,74.06 50.17,74.06 51.48,75.38 51.48,76.91 48.09,80.3 48.09,81.01 46.28,82.81 44.53,82.81 44.13,82.42 39.87,82.42 39.5,82.79 39.5,83.66 38.92,84.24 38.92,84.88 38.87,84.93 R875.2
TCRCOMP_DN: length 3.9
  BOTTOM w0.14: R782.1 141.06,156.53 141.06,154.08 141.23,153.68 U42.BR40
TCRCOMP_DP: length 3.9
  BOTTOM w0.14: U42.BR41 141.62,154.1 141.62,154.31 141.48,154.45 141.42,154.45 141.28,154.59 141.28,156.07 141.3,156.1 141.3,156.45 141.44,156.59 141.7,156.59 141.85,156.74 141.85,156.94 R782.2
TEMP_MBAT#: length 182.8
  TOP w0.14: v1(181.97,61.91) 182.49,61.91 182.68,62.1 U23.73 ; PR332.2 72.34,42.35 72,42.7 v2(72,42.71) 72,42.71 72.31,43.02 PR326.1 ; PR340.1 36.29,39.24 35.75,38.71 v1(35.66,38.71)
  IN1 w0.086: v2(72,42.71) 71.92,42.71 70.97,43.66 70.97,45.1 67.28,48.79 64.43,48.79 62.51,50.71 60.89,50.71 58.74,52.85 52.92,52.85 51.42,51.34 48.51,51.34 47.32,50.15 44.31,50.15 42.42,48.26 42.42,47.24 40.35,45.16 37.12,45.16 35.72,43.76 35.72,42.36 34.75,41.39 34.75,39.62 v1(35.66,38.71)
  IN3 w0.089: v2(72,42.71) 72.11,42.6 76.12,42.6 76.52,43 76.52,49.85 78.54,51.87 98.86,51.87 103.32,56.34 107.07,56.34 107.64,55.76 107.64,55.32 107.89,55.07 108.89,55.07 109.4,55.58 112.08,55.58 113,56.5 117.26,56.5 119.36,58.6 123.1,58.6 124.04,59.53 140.16,59.53 144,63.38 147.25,63.38 148.78,64.9 153.23,64.9 153.44,64.69 157.03,64.69 157.39,64.33 158.6,64.33 158.76,64.17 160.73,64.17 161.5,63.39 163.8,63.39 164.64,64.23 165.39,64.23 166.41,65.25 169.52,65.25 170.07,64.7 175.66,64.7 178.12,62.24 181.75,62.24 181.97,62.02 v1(181.97,61.91)
TEMP_MBAT#_CONN: length 6.3
  TOP w0.14: PR332.1 72.73,41.9 73.14,42.31 73.14,43.26 73.18,43.3 v1(73.18,44.87)
  BOTTOM w0.14: v1(73.18,44.87) 72.25,44.87 71.55,45.57 PJ19.6
THER_ALERT#: length 11.3
  TOP w0.102: 258.97,130.47 258.79,130.47 258.53,130.2 256.17,130.2 256.04,130.06 255.35,130.06 255.2,130.21 254.89,130.21 254.71,130.39 254.71,130.76 v2(253.6,131.87)
  TOP w0.14: 258.97,130.47 260.76,130.47 v1(260.94,130.65)
  BOTTOM w0.102: UG6.BK5 v2(253.6,131.87)
  BOTTOM w0.14: v1(260.94,130.65) 261.07,130.51 QG18.1 262.03,130.55 RG128.1
THERMDN: length 5.5
  BOTTOM w0.102: TPG55.1 252.93,123.5 251.51,124.91 251.51,127.53 251.7,127.72 251.75,127.77 251.85,127.87 UG6.BR8
THERMDP: length 8
  BOTTOM w0.102: UG6.BP8 252.2,128.37 252.2,125.89 254.01,124.08 254.01,122.41 254.45,121.97
  BOTTOM w0.14: TPG57.1 254.45,121.97
TP_CLK: length 44
  TOP w0.14: v1(190.99,53.89) 192.48,53.89 193.61,55.02 193.61,55.59 191.99,57.2 191.99,61.05 191.99,62.81 193.44,64.25 193.44,65.82 191.44,67.81 190.3,67.81 189.65,68.46 187.26,68.46 187.25,68.46 184.55,68.46 184.51,68.5 U23.89
  IN2 w0.089: v1(203.25,47.41) 202.84,47.83 201.35,47.83 201.19,47.99 195.86,47.99 193.77,50.08 193.77,50.29 193.36,50.7 193.33,50.7 190.99,53.05 v1(190.99,53.89)
  BOTTOM w0.14: CN17.2 204.25,46.54 203.84,46.95 R1140.1 203.3,47.36 v1(203.25,47.41)
TP_DAT: length 40.1
  TOP w0.14: v1(187.45,69) 187.19,68.74 184.75,68.74 184.59,68.9 U23.90
  BOTTOM w0.14: v1(187.45,69) 188.58,67.87 191.52,67.87 192.1,67.28 192.1,66.54 191.38,65.82 191.38,64.69 191.77,64.3 191.77,62.34 189.82,60.39 189.82,56.61 193.47,52.96 194.04,52.96 197.05,49.96 197.05,49.41 197.86,48.6 198.1,48.6 199.33,47.36 R1139.1 202.67,47.05 203.25,46.47 CN17.3
TP_EN: length 53.9
  TOP w0.14: R406.1 166.13,71.31 v1(165.78,70.96)
  IN2 w0.089: v1(191.11,64.27) 190.68,64.71 188.39,64.71 186.83,66.26 186.83,66.52 185.65,67.71 184.59,67.71 184.31,67.99 181.62,67.99 181.17,68.43 178.83,68.43 178.03,69.24 175.75,69.24 174.61,70.38 173.19,70.38 172.66,69.84 170.07,69.84 169.95,69.97 166.27,69.97 165.78,70.46 v1(165.78,70.96)
  BOTTOM w0.14: CN17.8 198.25,47.47 196.53,49.19 196.53,49.74 193.83,52.44 191.78,52.44 190.02,54.2 190.02,55.19 189.3,55.91 189.3,60.6 191.22,62.53 191.22,64.09 191.11,64.2 v1(191.11,64.27)
TP_I2C_SCL: length 73.7
  TOP w0.14: v1(203.23,42.09) 202.43,42.89 R639.1 202.03,42.05 Q62.3
  IN4 w0.086: v1(225.28,69.97) 225.78,69.46 225.78,68.8 225.42,68.44 225.42,67.57 224.62,66.78 224.07,66.78 223.34,66.04 223.34,63.9 223.97,63.27 223.97,62.11 223.91,62.05 223.91,61.1 226.1,58.91 226.1,58.32 228.15,56.27 228.15,55.73 228.99,54.89 230.52,54.89 230.85,54.56 231.26,54.56 232.5,53.33 232.5,50.74 233.3,49.94 233.3,47.77 231.65,46.12 230.33,46.12 229.33,45.12 229.33,43.52 228.14,42.33 223.53,42.33 222.35,43.5 220.12,43.5 219.51,42.89 219.51,41.59 218.88,40.96 214.35,40.96 212.96,42.36 211.75,42.36 211.23,42.87 204.01,42.87 v1(203.23,42.09)
  BOTTOM w0.102: R958.1 227.07,70.42 225.73,70.42 v1(225.28,69.97) 225.12,69.81 223.45,69.81 223.27,69.64 223.03,69.64 U49.BD21
TP_I2C_SDA: length 81.4
  TOP w0.14: Q62.6 199.6,40.59 199.46,40.45 199.46,40.23 199.69,40 200.06,40 200.31,39.74 R647.1 200.31,39 200.99,38.32 203.63,38.32 204.17,38.85 204.47,38.85 204.78,39.16 204.78,39.36 v1(205.44,40.02) 205.44,41.36 v1(204.85,41.95)
  IN4 w0.086: v1(226.25,69.13) 226.25,68.6 225.89,68.24 225.89,67.37 224.82,66.31 224.26,66.31 223.8,65.85 223.8,64.1 224.44,63.46 224.44,61.91 224.38,61.85 224.38,61.3 226.57,59.1 226.57,58.51 228.62,56.46 228.62,55.93 229.12,55.42 230.65,55.42 231.05,55.03 231.45,55.03 232.97,53.52 232.97,50.93 233.76,50.13 233.76,47.57 231.85,45.65 230.52,45.65 229.8,44.93 229.8,43.33 228.33,41.86 223.33,41.86 222.16,43.03 220.31,43.03 219.98,42.7 219.98,41.39 219.07,40.49 214.16,40.49 212.76,41.89 211.56,41.89 211.04,42.41 205.3,42.41 v1(204.85,41.95)
  BOTTOM w0.079: 223.73,69.61 223.57,69.61 223.46,69.49 223.46,69.29 223.27,69.1 U49.BC22
  BOTTOM w0.102: 223.73,69.61 224.71,69.61 224.81,69.51 225.61,69.51 225.98,69.13 v1(226.25,69.13) 226.25,69.54 226.54,69.84 226.94,69.84 R964.1
TP_INT#_C: length 8
  TOP w0.14: R636.2 196.76,43.69 197.58,44.51 198.68,44.51 v1(199.03,44.16) 198.86,43.99 198.6,43.99 198.15,43.54 R637.1 198.15,42.02 Q63.1
  BOTTOM w0.14: v1(199.03,44.16) 199.25,44.38 CN17.7
TP_LED_ON: length 297.8
  TOP w0.14: v1(162.69,72.23) 162.69,72.86 163.14,73.31 167.19,73.31 167.9,72.61 R399.1 168.84,72.07 169.23,71.68 169.62,71.68 170.25,71.06 170.25,70.36 169.75,69.86 169.75,68.54 171.95,66.35 171.95,64.98 172.94,63.98 172.94,63.12 172.7,62.87 v1(172.7,62.84) ; v1(105.49,83.27) 105.49,83.27 106.49,84.27 106.49,107.72 107.89,109.12 107.89,115.3 107.11,116.07 107.11,124.41 108.72,126.02 108.72,140.62 109.53,141.42 109.53,166.78 108.72,167.58 108.72,197.08 109.76,198.11 109.76,203.37 112.04,205.65 112.04,209.25 114.67,211.89 114.67,215.84 116.33,217.49 144.31,217.49 150.04,211.76 150.04,208.22 149.8,207.98 148.86,207.98 148.6,207.71 U1.1
  IN1 w0.086: v1(105.49,83.27) 105.24,83.02 105.24,77.3 107.27,75.27 108.21,75.27 108.47,75.54 114.24,75.54 118.13,71.65 135.82,71.65 136.99,72.82 159.64,72.82 159.99,72.46 162.46,72.46 v1(162.69,72.23)
  IN4 w0.086: v1(172.7,62.84) 172.89,63.03 174.44,63.03 175.68,61.79 180.79,61.79 181.07,61.5 183.48,61.5 184.69,60.3 184.69,57.98 185.6,57.06 186.57,57.06 188.41,55.23 188.41,54.44 190.26,52.59 192.02,52.59 v1(192.73,51.88)
  BOTTOM w0.14: Q115.2 194.05,50.72 R1101.1 193.71,50.74 192.73,51.72 v1(192.73,51.88)
TP_LED_ONOFF_C: length 4.6
  BOTTOM w0.14: CN17.10 196.25,46.47 196,46.72 195.27,46.72 195,46.99 Q115.3 197.01,47.36 v1(197.11,47.46)
