# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBB_CMD19: length 18.1
  IN2 w0.102: v2(218.09,174.64) 217.6,175.13 217.6,175.59 218.08,176.07 v2(220.51,176.07)
  BOTTOM w0.102: VRAM1.K11 220.88,176.44 v2(220.51,176.07)
  BOTTOM w0.129: UG6.A48 223.45,166.23 223.45,166.97 221.88,168.53 220.9,168.53
  BOTTOM w0.165: v2(218.09,174.64) 217.53,174.08 217.53,170.06 219.07,168.53 220.9,168.53
FBB_CMD20: length 12.4
  IN4 w0.102: v2(219.74,175.32) 220.13,174.93 220.13,168.37 222.27,166.24 v2(222.78,166.24)
  BOTTOM w0.102: VRAM1.L12 220.12,175.7 v2(219.74,175.32)
  BOTTOM w0.129: v2(222.78,166.24) 222.78,165.49 UG6.B49
FBB_CMD21: length 17.1
  BOTTOM w0.102: VRAM1.K12 219.79,176.11 218.01,176.11 217.71,175.81
  BOTTOM w0.129: 218.94,167.98 219.03,167.89 221.27,167.89 222.53,166.63 222.99,166.63 223.17,166.45 223.17,165.84 UG6.A49
  BOTTOM w0.165: 218.94,167.98 217.05,169.88 217.05,175.15 217.71,175.81
FBB_CMD22: length 20.4
  BOTTOM w0.129: VRAM1.J12 219.76,177.56 218.36,177.56 218.19,177.73 217.86,177.73 215.47,175.33 215.47,172.3 ; 217.6,167.98 218.46,167.12 220.91,167.12 222.13,165.89 222.13,165.44 UG6.B50
  BOTTOM w0.165: 217.6,167.98 215.47,170.12 215.47,172.3
FBB_CMD23: length 20.1
  IN2 w0.102: v2(220.51,177.57) 218.85,177.57 218.78,177.65 217.52,177.65 217.07,177.2 v2(217.07,175.97)
  BOTTOM w0.102: VRAM1.J11 220.88,177.21 v2(220.51,177.57)
  BOTTOM w0.129: UG6.A50 222.38,165.89 222.38,166.1 220.98,167.5
  BOTTOM w0.165: v2(217.07,175.97) 215.87,174.76 215.87,170.41 218.77,167.5 220.98,167.5
FBB_CMD24: length 16.9
  IN4 w0.102: v2(222.1,164.09) 221.41,164.09 220.98,164.52 220.98,166.39 219.36,168.01 219.36,177.95 219.72,178.3 v2(219.74,178.3)
  BOTTOM w0.102: v2(219.74,178.3) 220.1,177.95 VRAM1.H12
  BOTTOM w0.129: v2(222.1,164.09) 222.43,164.42 UG6.C50
FBB_CMD28: length 16.2
  IN4 w0.102: v2(217.9,152.86) 217.93,152.89 217.93,154.05 217.44,154.54 215.87,154.54 214.62,155.79 207.75,155.79 207.53,156.01 207.53,156.37 207.61,156.45 207.61,158.23 v2(207.26,158.57)
  BOTTOM w0.102: UG6.Y56 218.24,152.52 v2(217.9,152.86)
  BOTTOM w0.129: v2(207.26,158.57) 206.89,158.95 VRAM4.K4
FBB_CMD29: length 15.8
  IN4 w0.102: v2(205.75,157.81) 206.35,157.22 206.35,155.82 206.97,155.2 208.23,155.2 208.37,155.06 214.43,155.06 215.63,153.86 v2(216.22,153.86)
  BOTTOM w0.102: VRAM4.L3 206.13,158.18 v2(205.75,157.81)
  BOTTOM w0.129: UG6.W56 218.2,153.27 217.33,153.27 217.17,153.43 216.65,153.43 v2(216.22,153.86)
FBB_CMD30: length 16
  IN4 w0.102: v2(206.51,157.81) 206.51,157.38 206.62,157.27 206.62,155.88 207.03,155.47 208.55,155.47 208.64,155.38 214.6,155.38 215.71,154.26 217.02,154.26 v2(217.43,153.86)
  BOTTOM w0.102: v2(217.43,153.86) 217.74,153.54 218.44,153.54 218.76,153.22 UG6.W55 ; VRAM4.K3 206.88,158.17 206.52,157.81 v2(206.51,157.81)
FBB_CMD31: length 12.8
  TOP w0.165: v2(207.91,156.22) 208.18,155.95 RG25.1
  BOTTOM w0.102: v2(207.91,156.22) 207.63,156.51 VRAM4.J1
  BOTTOM w0.129: 215.99,154.78 216.25,154.52 216.65,154.52 216.88,154.29 217.56,154.29 217.93,153.92 UG6.V56
  BOTTOM w0.165: 215.99,154.78 215.03,155.74 208.43,155.74 207.95,156.22 v2(207.91,156.22)
FBB_CMD32: length 14.6
  IN4 w0.102: v2(207.99,157.81) 207.99,157.59 208.15,157.43 208.56,157.43 209.37,156.62 213.56,156.62 213.6,156.58 214.27,156.58 215.91,154.94 v2(216.62,154.94)
  BOTTOM w0.102: VRAM4.J3 207.63,158.17 v2(207.99,157.81) ; 218.62,154.28 219.95,154.28 220.29,154.62 UG6.U53
  BOTTOM w0.129: v2(216.62,154.94) 217.02,154.53 217.81,154.53 218.06,154.28 218.62,154.28
FBB_CMD33: length 11.6
  IN4 w0.102: v2(217.89,154.95) 217.52,155.32 215.87,155.32 214.83,156.36 214.83,156.82 214.22,157.43 209.27,157.43 208.89,157.81 v2(208.75,157.81)
  BOTTOM w0.102: VRAM4.H3 208.38,158.2 208.75,157.83 v2(208.75,157.81)
  BOTTOM w0.129: v2(217.89,154.95) 218.22,154.62 UG6.U56
FBB_CMD34: length 13.4
  IN4 w0.102: v2(216.1,156.01) 215.4,156.71 215.4,157.4 214.78,158.02 214.78,158.38 214.2,158.96 211.17,158.96 210.39,159.74 208.39,159.74 v2(208,159.34)
  BOTTOM w0.129: v2(216.1,156.01) 216.52,155.59 217.24,155.59 217.46,155.37 218.2,155.37 UG6.T56 ; v2(208,159.34) 208,159.34 207.63,158.97 VRAM4.J4
FBB_CMD35: length 12.1
  IN4 w0.102: v2(209.5,158.58) 209.89,158.19 214.15,158.19 214.43,157.91 214.43,157.7 215.13,157 215.13,156.43 215.93,155.63 216.92,155.63 v2(217.33,156.04)
  BOTTOM w0.129: UG6.T55 218.61,155.66 217.71,155.66 v2(217.33,156.04) ; VRAM4.G4 209.14,158.95 v2(209.5,158.58)
FBB_CMD36: length 14.5
  BOTTOM w0.129: UG6.R56 217.97,156.02 217.42,156.57 216.09,156.57
  BOTTOM w0.165: VRAM4.H5 208.6,159.92 208.6,160.46 208.97,160.83 214.07,160.83 214.46,160.45 214.46,157.37 215.26,156.57 216.09,156.57
FBB_CMD37: length 15.8
  IN4 w0.102: v2(217.11,157.09) 216.71,157.49 216.45,157.49 216.1,157.84 215.93,158.01 215.93,158.49 214.88,159.54 214.88,159.95 213.91,160.91 209.77,160.91 209.5,160.64 208.54,160.64 v2(208.08,160.18)
  BOTTOM w0.102: UG6.P53 220.05,156.42 218.48,156.42
  BOTTOM w0.129: v2(208.08,160.18) 207.63,159.73 VRAM4.J5 ; 218.48,156.42 218.44,156.38 217.98,156.38 217.27,157.09 v2(217.11,157.09)
FBB_CMD38: length 14.6
  IN4 w0.102: v2(207.23,160.23) 207.84,160.85 209.33,160.85 209.7,161.22 214.01,161.22 215.09,160.15 215.09,159.62 216.2,158.51 216.2,158.02 216.53,157.69 217.28,157.69 v2(217.9,157.07)
  BOTTOM w0.102: v2(207.23,160.23) 206.88,159.88 VRAM4.K5
  BOTTOM w0.129: UG6.P56 v2(217.9,157.07)
FBB_CMD39: length 16.3
  BOTTOM w0.129: 217.48,157.53 217.54,157.47 218.2,157.47 UG6.N56
  BOTTOM w0.165: 217.48,157.53 215.58,157.53 214.79,158.33 214.79,160.59 214.25,161.13 206.56,161.13 205.96,160.52 205.96,159.86 VRAM4.L5
FBB_CMD40: length 17.1
  IN4 w0.102: v2(217.32,158.11) 216.94,158.5 216.52,158.5 215.32,159.7 215.32,160.46 214.24,161.53 209.51,161.53 209.03,161.05 207.37,161.05 206.82,160.51 206.82,160.03 206.63,159.84 206.23,159.84 205.75,159.37 v2(205.75,159.34)
  BOTTOM w0.129: VRAM4.M4 205.72,159.29 205.72,159.31 205.75,159.34 v2(205.75,159.34) ; UG6.N55 218.6,157.77 217.75,157.77 217.41,158.11 v2(217.32,158.11)
FBB_CMD41: length 24
  TOP w0.165: v2(205.38,162.9) 204.62,162.14 RG20.2
  BOTTOM w0.129: 216.35,158.51 217.48,158.51 217.94,158.05 218.18,158.05 UG6.M56
  BOTTOM w0.165: VRAM4.M10 205.38,163.09 205.38,163.09 205.38,162.9 v2(205.38,162.9) 205.69,162.59 205.69,162.33 205.41,162.05 205.15,162.05 204.75,162.46 204.51,162.46 204.3,162.24 204.3,162.05 204.67,161.68 204.67,161.51 204.3,161.14 204.3,160.91 204.53,160.68 204.76,160.68 206.1,162.01 206.27,162.01 206.83,161.45 214.51,161.45 215.08,160.89 215.08,158.51 215.59,157.99 215.83,157.99 216.35,158.51
FBB_CMD42: length 18.1
  BOTTOM w0.102: UG6.L53 220.23,158.7 220.05,158.7 219.86,158.51 219.5,158.51 219.4,158.61 219.21,158.61 219.09,158.49
  BOTTOM w0.129: 215.96,158.84 217.72,158.84 218.07,158.49 219.09,158.49
  BOTTOM w0.165: 215.96,158.84 215.39,159.42 215.39,161.07 214.72,161.74 207.35,161.74 206.71,162.38 206.26,162.38 205.99,162.64 205.99,163.31 VRAM4.L10
FBB_CMD43: length 13.1
  BOTTOM w0.102: 217.9,159.17 UG6.L56
  BOTTOM w0.129: 214.26,162.09 214.26,162.08 ; 216.25,159.17 217.9,159.17
  BOTTOM w0.165: 216.25,159.17 215.77,159.66 215.77,161.2 214.88,162.08 214.26,162.08 ; VRAM4.H10 208.69,163.13 208.69,162.35 208.96,162.09 214.26,162.09
FBB_CMD44: length 27
  TOP w0.165: RG21.2 207.11,161.59 207.53,162 208.61,162 209.39,162.79 v2(209.39,162.95)
  BOTTOM w0.165: UG6.K56 218.16,159.43 216.48,159.43 216.16,159.75 216.16,160.44 216.36,160.64 216.72,160.64 216.9,160.83 216.9,161.06 216.65,161.32 216.23,161.32 216.03,161.52 216.03,161.89 215.84,162.08 215.47,162.08 215.28,162.27 215.28,166.63 215.12,166.8 214.67,166.8 214.48,166.61 214.48,162.58 214.35,162.45 213.58,162.45 213.45,162.58 213.45,162.96 213.32,163.09 212.96,163.09 212.8,162.93 212.8,162.62 212.63,162.45 210.24,162.45 210.08,162.61 209.85,162.61 209.58,162.35 209.36,162.35 209.2,162.52 209.2,162.75 v2(209.39,162.95) 209.39,163.28 209.23,163.45 VRAM4.G10
FBB_CMD45: length 13.1
  IN4 w0.102: v2(216.63,160.2) 216.63,160.85 214.86,162.62 214.86,163.55 214.22,164.18 210.59,164.18 210.59,164.18 209.87,164.18 v2(209.49,164.56)
  BOTTOM w0.102: v2(209.49,164.56) VRAM4.G11
  BOTTOM w0.129: v2(216.63,160.2) 217.04,159.78 217.89,159.78 217.99,159.88 218.59,159.88 UG6.K55
FBB_CMD46: length 13
  IN4 w0.102: v2(217.76,160.22) 217.33,160.66 217.18,160.66 215.15,162.68 215.15,164.07 214.28,164.95 209.13,164.95 v2(208.74,164.56)
  BOTTOM w0.102: UG6.J56 v2(217.76,160.22)
  BOTTOM w0.129: v2(208.74,164.56) 208.38,164.93 VRAM4.H12
FBB_CMD47: length 23.4
  IN2 w0.114: v2(208.67,166.97) 208.2,166.5 208.2,164.73 207.27,163.8 v2(207.25,163.8)
  BOTTOM w0.102: 219.38,160.6 219.39,160.61 220.04,160.61 UG6.H53 ; VRAM4.J11 207.63,164.15 207.27,163.8 v2(207.25,163.8)
  BOTTOM w0.129: 215.71,162.76 217.87,160.6 219.38,160.6
  BOTTOM w0.165: v2(208.67,166.97) 208.86,167.16 208.86,168.4 209.28,168.82 213.66,168.82 215.71,166.76 215.71,162.76
FBB_CMD48: length 20.2
  BOTTOM w0.102: UG6.H56 217.98,161.19 217.83,161.19
  BOTTOM w0.129: 208.01,167.08 208.01,165.31 207.65,164.95 VRAM4.J12 ; 216.1,162.92 217.83,161.19
  BOTTOM w0.165: 216.1,162.92 216.1,167.02 213.68,169.44 209.12,169.44 208.4,168.72 208.4,167.47 208.01,167.08
FBB_CMD49: length 22.9
  BOTTOM w0.129: VRAM4.K12 206.53,165.29 206.53,166.97 206.31,167.18 206.31,167.45 ; UG6.G56 217.84,161.62 216.45,163.01
  BOTTOM w0.165: 206.31,167.45 206.31,169.26 207.12,170.06 213.86,170.06 216.45,167.48 216.45,163.01
FBB_CMD50: length 21.4
  IN4 w0.102: v2(216.99,163.29) 216.77,163.52 216.77,164.76 216.14,165.38 216.14,167.4 215.05,168.49 206.78,168.49 206.07,167.78 206.07,166.38 206.23,166.23 206.23,165.8 v2(205.76,165.33)
  BOTTOM w0.102: VRAM4.L12 206.13,164.96 v2(205.76,165.33)
  BOTTOM w0.129: UG6.G55 218.6,161.97 217.9,161.97 216.99,162.88 v2(216.99,163.29)
FBB_CMD51: length 24.5
  IN2 w0.114: v2(205.75,167.99) 206.44,167.3 206.44,165.36 207.24,164.56 v2(207.25,164.56)
  BOTTOM w0.102: VRAM4.K11 206.89,164.2 v2(207.25,164.56)
  BOTTOM w0.129: 217.12,163.8 217.67,163.8 218.02,163.45 218.02,163.25 UG6.E56
  BOTTOM w0.165: 217.12,163.8 216.81,164.12 216.81,167.92 214.09,170.63 206.92,170.63 205.75,169.47 v2(205.75,167.99)
FBB_CMD52: length 21.4
  IN4 w0.102: v2(205.01,164.56) 204.62,164.95 204.62,166.44 204.54,166.52 204.54,167.36 206.17,168.99 215.8,168.99 217.75,167.04 217.75,166.8 v2(217.83,166.72)
  BOTTOM w0.102: VRAM4.M11 205.37,164.2 v2(205.01,164.56) ; v2(217.83,166.72) 218.6,166.72 219.32,166 219.32,165.46 UG6.B54
FBB_DBI0: length 13.8
  IN2 w0.102: 231.22,161.99 231.62,162.4 231.62,165.58 231.35,165.86 230.9,165.86 230.75,166.01 230.75,167.78 230.47,168.07 230.47,168.67 229.29,169.84 229.29,171.84 229.11,172.02 228.32,172.02 v2(228.03,172.32)
  IN2 w0.14: v2(231.2,161.97) 231.22,161.99
  BOTTOM w0.102: v2(228.03,172.32) 228,172.32 VRAM1.R2
  BOTTOM w0.161: v2(231.2,161.97) 231.17,161.97 230.85,162.29 UG6.F38
FBB_DBI1: length 25.2
  IN1 w0.102: v2(233.3,161.98) 232.89,162.39 232.89,163.29 232.43,163.74 232.12,163.74 231.8,164.06 231.8,168.32 231.28,168.84 230.79,168.84 229.22,170.42 227.13,170.42 226.88,170.67 226.88,178.36 227.62,179.1 227.62,180.71 227.27,181.06 227.27,181.17 v2(227.27,181.32)
  BOTTOM w0.161: v2(233.3,161.98) 232.96,162.32 UG6.F35 ; VRAM1.D2 227.63,180.96 v2(227.27,181.32)
FBB_DBI2: length 17.1
  IN2 w0.102: v2(225.67,161.34) 225.43,161.58 225.43,162.13 223.81,163.75 223.43,163.75 223.22,163.97 223.22,165 222.78,165.44 222.28,165.44 221.53,166.19 221.53,166.47 218.55,169.46 218.55,172.47 218.77,172.69 219.36,172.69 219.72,172.34 v2(219.74,172.34)
  BOTTOM w0.102: v2(219.74,172.34) 219.72,172.34 219.38,172.68 VRAM1.R13
  BOTTOM w0.161: UG6.G46 225.39,161.62 v2(225.67,161.34)
FBB_DBI3: length 31.7
  IN1 w0.102: v2(228.03,161.5) 227.38,160.86 226.77,160.86 226.71,160.91 225.23,160.91 225.15,160.83 224.47,160.83 223.97,161.33 223.97,163.49 223.71,163.75 223.43,163.75 223.19,163.99 223.19,164.93 222.91,165.21 222.39,165.21 220.37,167.24 219.89,167.24 217.21,169.92 217.21,174.76 216.69,175.28 216.69,176.34 217.19,176.84 217.19,180.17 218.01,180.98 218.56,180.98 218.59,180.95 219.36,180.95 v2(219.73,181.32)
  BOTTOM w0.102: v2(219.73,181.32) 219.38,180.96 VRAM1.D13
  BOTTOM w0.161: UG6.G43 227.47,161.5 v2(228.03,161.5)
FBB_DBI4: length 22.6
  IN1 w0.102: v2(202.76,157.82) 203.14,158.2 203.7,158.2 203.89,158.38 203.89,158.83 204.02,158.96 214.31,158.96 214.66,159.31 217.9,159.31 218.43,158.78 221.1,158.78 221.86,158.01 222.6,158.01 v2(222.66,158.07)
  BOTTOM w0.102: v2(202.76,157.82) VRAM4.R2
  BOTTOM w0.161: v2(222.66,158.07) 222.45,157.86 UG6.N50
FBB_DBI5: length 15.3
  IN2 w0.102: v2(222.15,155.74) 220.37,157.52 220.37,157.94 219.81,158.51 215.92,158.51 214.69,159.74 212.13,159.74 211.86,159.47 211.86,158.99 212.13,158.73 212.13,158.18 v2(211.75,157.81)
  BOTTOM w0.102: VRAM4.D2 211.39,157.45 v2(211.75,157.81)
  BOTTOM w0.161: v2(222.15,155.74) 222.15,155.62 UG6.T50
FBB_DBI6: length 26.4
  IN1 w0.102: v2(222.79,164.07) 222.43,163.71 221.63,163.71 220.59,164.75 219.71,164.75 218.74,165.71 218.74,166.35 217.23,167.87 206.71,167.87 206.18,168.4 204.26,168.4 203.09,167.23 203.09,166.81 203.12,166.79 203.12,165.85 202.75,165.49 v2(202.75,165.34)
  BOTTOM w0.102: v2(202.75,165.34) 202.75,165.34 203.11,165.7 VRAM4.R13
  BOTTOM w0.161: UG6.E49 222.79,163.38 v2(222.79,164.07)
FBB_DBI7: length 16.4
  IN2 w0.102: v2(222.74,159.97) 222.32,159.56 215.92,159.56 213.43,162.06 213.43,163.4 212.14,164.68 212.14,165.71 v2(211.75,166.1)
  BOTTOM w0.102: VRAM4.D13 211.38,165.72 v2(211.75,166.1) ; UG6.K50 222.45,159.69 v2(222.74,159.97)
FBB_EDC0: length 9.8
  IN2 w0.102: v2(231.19,164.76) 230.51,165.45 230.51,167.58 230.08,168.01 230.08,168.27 228.47,169.88 228.47,170.92 227.82,171.57 v2(227.26,171.57)
  BOTTOM w0.102: v2(231.19,164.76) 231.19,164.76 UG6.C38
  BOTTOM w0.161: v2(227.26,171.57) 227.63,171.93 VRAM1.T2
FBB_EDC1: length 21.4
  IN1 w0.102: v2(227.99,182.06) 228.63,182.06 229.33,181.35 229.33,175.33 229.69,174.98 229.69,171.69 232.5,168.88 232.78,168.88 233.7,167.96 233.7,165.18 v2(233.29,164.77)
  BOTTOM w0.102: UG6.C35 232.95,164.43 v2(233.29,164.77)
  BOTTOM w0.161: VRAM1.C2 227.99,182.06 v2(227.99,182.06)
FBB_EDC2: length 13.5
  IN2 w0.102: v2(218.98,171.56) 219.21,171.56 219.6,171.95 220.87,171.95 221.77,171.05 221.77,170.07 222.2,169.64 222.81,169.02 223.07,169.02 224.72,167.37 224.72,166.71 226.1,165.33 226.1,164.57 v2(225.69,164.16)
  BOTTOM w0.102: VRAM1.T13 219.37,171.95 v2(218.98,171.56)
  BOTTOM w0.161: v2(225.69,164.16) UG6.D46
FBB_EDC3: length 25.2
  IN1 w0.102: v2(227.01,164.07) 227.01,164.1 227.43,164.52 227.43,165.72 227.07,166.07 226.75,166.07 226.42,166.41 226.42,166.73 226.18,166.96 226.18,167.44 225.98,167.63 224.42,167.63 224.25,167.8 223.72,167.8 223.03,168.5 222.62,168.5 221.5,169.62 221.07,169.62 220.89,169.8 220.89,171.29 221.05,171.45 221.05,173.38 220.89,173.54 220.89,180.71 220.64,180.96 220.34,180.96 220.13,181.17 220.13,181.46 219.89,181.7 219.37,181.7 v2(219.01,182.06)
  BOTTOM w0.102: v2(227.01,164.07) 227.01,164.06 UG6.D43
  BOTTOM w0.161: v2(219.01,182.06) VRAM1.C13
FBB_EDC4: length 20.2
  IN1 w0.102: v2(219.93,157.84) 219.93,157.84 219.83,157.74 218.95,157.74 218.72,157.97 218.08,157.97 217.55,158.5 215.28,158.5 214.21,157.43 207.75,157.43 207.57,157.61 206.99,157.61 206.8,157.43 202.38,157.43 v2(202.01,157.05)
  BOTTOM w0.102: VRAM4.T2 202.38,157.42 v2(202.01,157.05)
  BOTTOM w0.161: v2(219.93,157.84) 220.35,157.43 UG6.N53
FBB_EDC5: length 9.6
  IN2 w0.102: v2(219.95,155.74) 219.83,155.61 215.96,155.61 214.52,157.05 214.52,157.16 214.27,157.4 213.82,157.4 213.47,157.04 v2(212.5,157.04)
  BOTTOM w0.102: VRAM4.C2 212.13,157.42 v2(212.5,157.04)
  BOTTOM w0.161: UG6.T53 220.35,155.36 219.97,155.74 v2(219.95,155.74)
FBB_EDC6: length 21.1
  IN1 w0.102: v2(220.69,163.37) 220.11,163.96 215.43,163.96 214.44,164.94 202.55,164.94 202.36,165.13 202.36,165.71 v2(202.01,166.06)
  BOTTOM w0.102: v2(220.69,163.37) 220.35,163.03 UG6.E53
  BOTTOM w0.161: v2(202.01,166.06) 202.03,166.04 202.03,166.04 VRAM4.T13
FBB_EDC7: length 12.8
  IN2 w0.102: v2(212.5,166.1) 212.5,164.76 213.12,164.14 214.21,164.14 214.82,163.53 214.82,162.21 216.4,160.63 217.92,160.63 218.32,160.23 v2(219.76,160.23)
  BOTTOM w0.102: UG6.K53 220.35,159.62 219.76,160.21 v2(219.76,160.23) ; VRAM4.C13 212.13,165.72 v2(212.5,166.1)
FBB_FB_TCK0: length 1.5
  TOP w0.14: v2(224.84,174.47) 224.8,174.43 TPG15.1
  BOTTOM w0.102: VRAM1.N5 225.12,174.2 v2(224.84,174.47)
FBB_FB_TDI0: length 1.5
  TOP w0.14: v2(222.24,179.15) 222.53,178.85 TPG3.1
  BOTTOM w0.102: v2(222.24,179.15) 222.23,179.14 221.93,179.14 VRAM1.F10
FBB_FB_TDO0: length 2
  TOP w0.14: v2(222.25,174.45) 223.06,173.64 TPG17.1
  BOTTOM w0.102: VRAM1.N10 221.99,174.2 v2(222.25,174.45)
FBB_FB_TMS0: length 1.9
  TOP w0.14: TPG1.1 224.01,180.03 v2(224.66,179.38)
  BOTTOM w0.102: VRAM1.F5 224.72,179.45 v2(224.66,179.38)
FBB_VREFC: length 0.8
  BOTTOM w0.3: v2(228.93,176.03) 228.93,176.07 228.87,176.13 228.86,176.13 228.54,176.45 VRAM1.K1
FBB_VREFC_H: length 1.4
  TOP w0.14: v1(207.05,156.18) 207.18,156.04 RG24.1
  BOTTOM w0.102: VRAM4.K1 206.88,156.35 v1(207.05,156.18)
FBB_ZQ_1_A: length 1.6
  TOP w0.203: v2(218.03,177.27) 217.26,177.27 217.16,177.36 RG7.1
  BOTTOM w0.12: v2(218.03,177.27) 218.1,177.2 VRAM1.J14
FBB_ZQ_1_B: length 1.8
  TOP w0.203: RG12.1 217.15,176.56 217.29,176.42 217.88,176.42 v2(218.01,176.55)
  BOTTOM w0.12: v2(218.01,176.55) 218.53,176.55 VRAM1.K14
FBB_ZQ_2_A: length 2.2
  BOTTOM w0.14: VRAM4.J14 207.58,166.49 207.58,168.27 RG112.1
FBB_ZQ_2_B: length 2.2
  BOTTOM w0.14: VRAM4.K14 206.96,166.53 206.96,168.38 RG111.1
FBC_CMD0: length 18.7
  IN4 w0.102: v2(255.3,167.16) 255.84,167.16 256.78,168.09 257.34,168.09 259.05,169.8 259.05,174.73 258.17,175.62 257.65,175.62 256.64,176.63 256.64,177.01 256.47,177.19 255.1,177.19 254.74,177.55 254.74,177.56 v2(254.72,177.57)
  BOTTOM w0.102: v2(254.72,177.57) 254.74,177.57 255.11,177.2 VRAM3.J4
  BOTTOM w0.129: UG6.B5 254.31,165.48 254.31,166.01 255.3,167 v2(255.3,167.16)
FBC_CMD1: length 20.7
  IN4 w0.102: v2(255.5,178.33) 255.51,178.31 255.51,178.3 255.87,177.95 256.56,177.95 256.69,178.08 257.21,178.08 257.46,177.82 258.16,177.82 258.39,177.6 258.39,176.71 259.97,175.12 259.97,169.76 257.2,167 256.85,167 255.73,165.88 254.7,165.88 v2(254.15,166.43)
  BOTTOM w0.129: UG6.A5 253.95,166.23 v2(254.15,166.43) ; v2(255.5,178.33) 255.5,178.31 255.86,177.95 VRAM3.H3
FBC_CMD2: length 20.2
  IN4 w0.102: v2(253.31,166.54) 253.6,166.83 254.47,166.83 254.53,166.77 256.08,166.77 256.78,167.47 257.2,167.47 259.45,169.71 259.45,175.13 258.17,176.41 257.76,176.41 257.53,176.64 257.53,176.95 257.28,177.2 256.82,177.2 256.44,177.57 256.27,177.57 v2(256.26,177.57)
  BOTTOM w0.102: v2(256.26,177.57) 256.24,177.57 255.88,177.2 VRAM3.J3
  BOTTOM w0.129: UG6.C5 253.6,164.77 253.6,166.25 v2(253.31,166.54)
FBC_CMD3: length 20.9
  BOTTOM w0.102: VRAM3.J1 257.77,176.8 259.05,176.8 259.33,176.52 RG108.1 259.33,175.96 259.77,175.53
  BOTTOM w0.129: UG6.A6 253.25,165.95 252.92,166.28 252.92,167.5 253.05,167.63 258.59,167.63 258.73,167.5 259.47,167.5 259.48,167.49 260.13,167.49 260.26,167.62 ; 259.77,175.53 259.92,175.37
  BOTTOM w0.165: 259.92,175.37 260.35,174.94 260.35,167.71 260.26,167.62
FBC_CMD4: length 18.3
  IN4 w0.102: v2(252.26,166.77) 253.42,167.94 255.59,167.94 256.43,168.77 257.19,168.77 258.35,169.93 258.35,173.88 256.52,175.71 256.04,175.71 255.88,175.87 255.88,176.43 255.5,176.8 v2(255.5,176.8)
  BOTTOM w0.129: v2(252.26,166.77) 252.65,166.38 252.65,166.19 252.9,165.94 252.9,165.47 UG6.B7 ; VRAM3.K3 255.86,176.45 255.5,176.8 v2(255.5,176.8)
FBC_CMD5: length 16.4
  IN4 w0.102: v2(252.2,166.17) 253.69,167.66 255.92,167.66 256.62,168.36 257.19,168.36 258.64,169.81 258.64,173.95 256.49,176.09 v2(256.26,176.09)
  BOTTOM w0.102: VRAM3.L3 255.89,175.7 256.26,176.07 v2(256.26,176.09) ; v2(252.2,166.17) 252.55,165.82 UG6.A7
FBC_CMD6: length 15.5
  IN4 w0.102: v2(252.2,167.67) 252.37,167.67 253.21,168.51 255.29,168.51 256.64,169.87 256.64,174.05 256.51,174.18 256.08,174.18 255.88,174.39 255.88,174.76 255.7,174.94 255.27,174.94 255.11,175.1 255.11,175.66 254.72,176.05 v2(254.72,176.07)
  BOTTOM w0.102: VRAM3.K4 255.09,176.45 v2(254.72,176.07)
  BOTTOM w0.129: UG6.A8 251.78,165.9 251.78,166.92 252.2,167.35 v2(252.2,167.67)
FBC_CMD7: length 18.2
  IN4 w0.102: v2(251.18,166.51) 251.36,166.51 252.05,167.2 252.29,167.2 253.31,168.22 255.37,168.22 256.57,169.42 256.97,169.42 257.48,169.93 257.48,174.07 257.36,174.19 256.84,174.19 256.64,174.39 256.64,174.74 256.44,174.94 256.07,174.94 255.69,175.32 v2(255.5,175.32)
  BOTTOM w0.102: v2(255.5,175.32) 255.5,175.32 VRAM3.M4 ; 251.51,164.88 251.51,164.32 251.85,163.98 UG6.D8
  BOTTOM w0.129: 251.51,164.88 251.51,166.19 v2(251.18,166.51)
FBC_CMD8: length 11.7
  BOTTOM w0.165: UG6.A9 251.15,165.93 250.77,166.31 250.77,166.74 251,166.97 251.34,166.97 251.59,167.22 251.59,167.68 253.33,169.43 253.33,174.65 VRAM3.L5
FBC_CMD9: length 17
  IN4 w0.102: v2(251.17,167.4) 251.35,167.4 252.08,168.12 252.44,168.12 253.15,168.83 254.83,168.83 255.88,169.88 255.88,174.02 255.72,174.18 255.29,174.18 255.11,174.37 255.11,174.73 254.89,174.95 254.37,174.95 253.86,175.46 v2(253.86,176.14)
  BOTTOM w0.129: VRAM3.K5 254.17,176.45 v2(253.86,176.14) ; v2(251.17,167.4) 250.94,167.4 250.5,166.95 250.5,166.23 250.79,165.93 250.79,165.46 UG6.B10
FBC_CMD10: length 16.1
  IN4 w0.102: v2(250.09,166.21) 250.52,166.64 250.52,167.31 251.59,168.38 252.27,168.38 253.08,169.2 254.48,169.2 255.11,169.83 255.11,172.9 254.29,173.71 254.29,174.42 253.36,175.34 253.36,176.36 v2(253.87,176.86)
  BOTTOM w0.129: v2(250.09,166.21) 250.45,165.85 UG6.A10 ; v2(253.87,176.86) 254.2,177.2 VRAM3.J5
FBC_CMD11: length 15
  BOTTOM w0.165: VRAM3.H5 253.78,177.95 253.34,177.51 253.34,175.24 252.98,174.88 252.98,169.57 251.37,167.95 251.02,167.95 250.28,167.21 249.83,167.21 249.55,166.93 249.55,166.17 249.75,165.97 UG6.A11
FBC_CMD12: length 21.2
  IN4 w0.102: v2(253.82,178.49) 253.07,177.74 253.07,174.26 253.53,173.81 253.89,173.81 254.26,173.44 254.26,169.9 253.9,169.53 253.03,169.53 252.11,168.62 251.48,168.62 250.48,167.62 v2(250.02,167.62)
  BOTTOM w0.129: v2(250.02,167.62) 249.8,167.62 249.25,167.07 249.25,166.09 249.41,165.93 249.41,164.98 249.45,164.94 249.45,164.6 249.41,164.56 249.41,164.06 UG6.D11 ; v2(253.82,178.49) 253.82,178.63 254.27,179.08 254.74,179.08 255.12,178.7 VRAM3.G4
FBC_CMD13: length 16.9
  IN4 w0.102: v2(250.26,178.31) 250.27,178.31 250.59,177.99 251.35,177.99 251.78,177.56 251.78,170.22 251.43,169.87 250.68,169.87 249.88,169.07 249.17,169.07 248.1,167.99 248.1,167.53 v2(248.52,167.11)
  BOTTOM w0.102: VRAM3.G11 v2(250.26,178.31)
  BOTTOM w0.129: v2(248.52,167.11) 248.99,166.64 248.99,165.88 UG6.A12
FBC_CMD14: length 20
  TOP w0.165: RG4.2 252.14,178.99 251.98,178.83 v2(251.49,178.83)
  BOTTOM w0.129: VRAM3.G10 250.75,178.83 v2(251.49,178.83)
  BOTTOM w0.165: UG6.B13 248.7,165.47 248.7,166.34 248.07,166.97 248.07,167.95 248.44,168.32 251.25,168.32 252.68,169.74 252.68,177.1 251.49,178.28 v2(251.49,178.83)
FBC_CMD15: length 17.1
  BOTTOM w0.165: UG6.A13 248.35,166.18 247.74,166.78 247.74,168.18 248.24,168.68 251.14,168.68 252.37,169.91 252.37,176.8 251.19,177.98 250.66,177.98 VRAM3.H10
FBC_CMD16: length 14.7
  BOTTOM w0.165: VRAM3.L10 250.84,175.49 251.68,175.49 252.04,175.13 252.04,170 251.16,169.12 248.14,169.12 247.41,168.38 247.41,166.64 247.65,166.4 UG6.A14
FBC_CMD17: length 16.9
  TOP w0.165: RG18.2 251.49,174.82 v2(251.27,175.04)
  BOTTOM w0.129: v2(251.27,175.04) 251.18,174.95 VRAM3.M10
  BOTTOM w0.165: v2(251.27,175.04) 251.7,174.62 251.7,170.16 251.04,169.51 247.94,169.51 247.07,168.64 247.07,166.54 247.31,166.29 247.31,164.06 UG6.D14
FBC_CMD18: length 12.9
  IN4 w0.102: v2(246.39,168.11) 246.79,168.11 248.35,169.67 248.35,170.29 248.51,170.44 249.75,170.44 249.88,170.57 249.88,174.94 v2(250.27,175.32)
  BOTTOM w0.102: VRAM3.M11 250.25,175.32 v2(250.27,175.32)
  BOTTOM w0.129: UG6.A15 246.95,166.22 246.76,166.41 246.76,167.74 v2(246.39,168.11)
FBC_CMD19: length 15.3
  IN2 w0.102: v2(246.28,175.25) 246.28,175.69 246.67,176.07 v2(249.5,176.07)
  BOTTOM w0.102: VRAM3.K11 v2(249.5,176.07)
  BOTTOM w0.165: v2(246.28,175.25) 246.55,174.99 246.55,168.95 245.87,168.27 245.87,167.43 246.23,167.07 246.37,166.93 246.37,166.27 246.61,166.03 246.61,165.48 UG6.B16
FBC_CMD20: length 11.3
  IN4 w0.102: v2(248.74,175.34) 248.74,175.19 247.54,173.99 247.54,169.9 245.96,168.32 v2(245.96,166.69)
  BOTTOM w0.129: UG6.A16 245.96,166.11 v2(245.96,166.69) ; v2(248.74,175.34) 248.77,175.34 VRAM3.L12
FBC_CMD21: length 13.5
  BOTTOM w0.165: UG6.A17 245.54,165.83 245.54,168.4 245.87,168.73 245.87,175.5 246.45,176.07 248.75,176.07 VRAM3.K12
FBC_CMD22: length 17.4
  BOTTOM w0.165: VRAM3.J12 248.74,177.58 247.42,177.58 247.31,177.7 246.59,177.7 245.56,176.67 245.56,169 245.21,168.65 245.21,164.06 UG6.D17
FBC_CMD23: length 17.7
  IN2 w0.114: v2(249.52,177.57) 247.99,177.57 247.53,178.04 247.53,178.43 v2(247.08,178.88)
  BOTTOM w0.102: VRAM3.J11 249.88,177.21 v2(249.52,177.57)
  BOTTOM w0.165: UG6.A18 244.85,168.79 245.27,169.2 245.27,176.86 246.49,178.08 246.49,178.29 v2(247.08,178.88)
FBC_CMD24: length 17.3
  IN4 w0.102: v2(248.74,178.32) 248.27,177.86 246.72,177.86 245.59,176.73 245.59,169.43 243.87,167.7 v2(243.87,166.26)
  BOTTOM w0.129: VRAM3.H12 249.11,177.95 v2(248.74,178.32) ; v2(243.87,166.26) 244.27,166.26 244.47,166.05 244.47,165.44 UG6.B19
FBC_CMD28: length 15.6
  IN4 w0.102: v2(232.22,166.33) 232.61,166.72 232.61,169 231.79,169.82 231.79,176.8 232.17,177.18 234.61,177.18 v2(234.99,176.8)
  BOTTOM w0.102: UG6.A36 232.25,166.29 v2(232.22,166.33)
  BOTTOM w0.129: VRAM2.K4 235.36,177.2 234.99,176.82 v2(234.99,176.8)
FBC_CMD29: length 18.1
  IN4 w0.102: v2(234.25,177.56) 233.86,177.95 232.05,177.95 231.41,177.31 231.41,169.71 232.19,168.93 v2(232.19,167.2)
  BOTTOM w0.102: v2(234.25,177.56) 234.25,177.57 VRAM2.L3
  BOTTOM w0.129: UG6.D35 232.68,164 232.68,164.21 232.61,164.28 232.61,164.88 232.6,164.89 232.6,166.05 232.69,166.15 232.69,166.69 v2(232.19,167.2)
FBC_CMD30: length 14.1
  IN4 w0.102: v2(234.24,176.8) 234.23,176.8 233.85,176.42 233.19,176.42 232.96,176.65 232.45,176.65 232.21,176.41 232.21,169.96 232.85,169.32 232.85,166.65 v2(233.29,166.22)
  BOTTOM w0.102: v2(234.24,176.8) 234.24,176.81 234.63,177.19 VRAM2.K3 ; UG6.A35 233.29,166.16 v2(233.29,166.22)
FBC_CMD31: length 17.6
  TOP w0.165: v1(229.81,177.04) 230.37,177.04 230.38,177.02 RG10.1
  BOTTOM w0.129: UG6.A34 233.68,165.85 233.68,167.11 233.51,167.28 232.82,167.28 231.84,168.25 v1(231.84,169) 231.84,174.45 231.37,174.92 231.37,175.43 229.81,176.99 v1(229.81,177.04) 229.9,176.95 231.32,176.95 231.65,176.63 232.95,176.63 VRAM2.J1
FBC_CMD32: length 13.7
  IN4 w0.102: v2(234.98,176.07) 234.84,176.07 234.46,175.69 233.18,175.69 233.08,175.58 233.08,169.71 233.25,169.55 v2(233.25,167.68)
  BOTTOM w0.102: UG6.B34 233.65,165.13 233.96,165.43 233.96,167.24 233.52,167.68 v2(233.25,167.68) ; v2(234.98,176.07) 234.98,176.09 VRAM2.J3
FBC_CMD33: length 10.4
  IN4 w0.102: v2(234.35,166.36) 233.87,166.84 233.87,174.94 v2(234.24,175.3)
  BOTTOM w0.102: UG6.A33 v2(234.35,166.36) ; VRAM2.H3 234.63,175.69 v2(234.24,175.3)
FBC_CMD34: length 14.3
  IN4 w0.102: v2(235.78,176.07) 235.77,176.07 235.39,175.69 234.81,175.69 234.63,175.51 234.63,167.85 v2(234.34,167.55)
  BOTTOM w0.129: VRAM2.J4 235.4,176.45 235.77,176.07 v2(235.78,176.07) ; UG6.D32 234.68,164.09 234.68,165.99 234.9,166.21 234.9,166.99 v2(234.34,167.55)
FBC_CMD35: length 9.9
  IN4 w0.102: v2(235.01,174.56) 235.07,174.56 235.39,174.24 235.39,168.89 234.97,168.46 234.97,167.01 v2(235.37,166.61)
  BOTTOM w0.102: v2(235.01,174.56) 235.01,174.57 235.38,174.93 VRAM2.G4
  BOTTOM w0.129: v2(235.37,166.61) 235.37,166.14 UG6.A32
FBC_CMD36: length 11.2
  BOTTOM w0.165: UG6.A31 235.79,165.86 235.79,167.73 237.14,169.07 237.14,175.24 236.88,175.5 236.47,175.5 236.27,175.7 VRAM2.H5
FBC_CMD37: length 13.7
  IN4 w0.102: v2(236.64,176.55) 236.22,176.13 236.22,175.84 236.53,175.53 237,175.53 237.47,175.06 237.47,168.71 v2(236.41,167.65)
  BOTTOM w0.129: v2(236.41,167.65) 236.06,167.3 236.06,166.18 236.11,166.13 236.11,165.48 UG6.B31 ; v2(236.64,176.55) 236.53,176.45 VRAM2.J5
FBC_CMD38: length 12.9
  IN4 w0.102: v2(236.65,177.16) 237.09,176.73 237.09,175.85 237.73,175.21 237.73,167.73 v2(236.45,166.46)
  BOTTOM w0.102: UG6.A30 v2(236.45,166.46)
  BOTTOM w0.129: v2(236.65,177.16) 236.6,177.22 236.15,177.22 VRAM2.K5
FBC_CMD39: length 15.6
  BOTTOM w0.165: VRAM2.L5 236.43,177.64 237.07,177.64 237.55,177.16 237.55,167.56 237.05,167.06 237.05,166.38 236.8,166.13 236.8,164.07 UG6.D29
FBC_CMD40: length 14.7
  IN4 w0.102: v2(237.47,166.73) 237.94,167.2 237.94,175.46 237.36,176.04 237.36,177.4 236.44,178.32 235.75,178.32 v2(235.74,178.33)
  BOTTOM w0.129: v2(237.47,166.73) 237.47,166.35 237.15,166.03 UG6.A29 ; VRAM2.M4 v2(235.74,178.33)
FBC_CMD41: length 16.2
  TOP w0.165: RG5.2 239.1,178.72 239.21,178.82 v2(239.29,178.82)
  BOTTOM w0.129: VRAM2.M10 239.67,178.9 239.37,178.9 v2(239.29,178.82)
  BOTTOM w0.165: v2(239.29,178.82) 239.2,178.73 238.47,178.73 238.21,178.98 237.98,178.98 237.75,178.75 237.75,178.51 237.95,178.31 237.95,178.08 237.88,178.01 237.88,167.05 237.93,167 237.93,166.34 237.85,166.25 UG6.A28
FBC_CMD42: length 14.8
  BOTTOM w0.165: UG6.B28 238.21,165.48 238.21,177.72 238.78,178.29 239.59,178.29 239.88,178 VRAM2.L10
FBC_CMD43: length 10.6
  BOTTOM w0.165: VRAM2.H10 239.6,175.7 238.55,174.65 UG6.A27
FBC_CMD44: length 17.9
  TOP w0.165: v2(239.31,174.57) 239.29,174.55 238.73,174.55 238.57,174.38 RG19.2
  BOTTOM w0.102: v2(239.31,174.57) 239.33,174.59 239.33,175.09 239.55,175.32 239.77,175.32 239.88,175.22 VRAM2.G10
  BOTTOM w0.165: UG6.D26 239.08,163.72 238.91,163.89 238.91,167.44 239.2,167.72 239.2,167.95 238.88,168.27 238.88,168.69 239.05,168.86 240.8,168.86 240.97,169.02 240.97,169.35 240.8,169.52 239.08,169.52 238.91,169.68 238.91,174.41 239.08,174.57 v2(239.31,174.57)
FBC_CMD45: length 9.8
  IN4 w0.102: v2(240.22,174.57) 239.79,174.14 239.79,167.76 v2(239.58,167.55)
  BOTTOM w0.102: v2(239.58,167.55) 239.19,167.16 239.19,165.88 UG6.A26 ; v2(240.22,174.57) 240.6,174.95 VRAM2.G11
FBC_CMD46: length 10.8
  IN4 w0.102: v2(240.98,175.33) 240.6,174.95 240.6,169.46 240.11,168.97 240.11,166.72 v2(239.6,166.21)
  BOTTOM w0.102: UG6.A25 239.95,165.86 v2(239.6,166.21)
  BOTTOM w0.129: VRAM2.H12 241.36,175.7 241,175.34 241,175.34 v2(240.98,175.33)
FBC_CMD47: length 17.2
  IN2 w0.102: v2(243.4,175.36) 242.69,176.07 240.96,176.07 240.25,176.78 240.25,176.79 v2(240.22,176.82)
  BOTTOM w0.102: VRAM2.J11 240.61,176.45 240.24,176.82 v2(240.22,176.82)
  BOTTOM w0.165: v2(243.4,175.36) 243.87,174.89 243.87,170.08 243.33,169.54 242.06,169.54 240.3,167.78 240.3,165.47 UG6.B25
FBC_CMD48: length 15
  BOTTOM w0.165: UG6.A24 240.65,167.51 242.33,169.18 243.53,169.18 244.22,169.88 244.22,175.36 243.72,175.87 243.35,175.87 243.14,176.08 241.75,176.08 VRAM2.J12
FBC_CMD49: length 19
  BOTTOM w0.165: VRAM2.K12 241.74,177.56 243.65,177.56 243.96,177.26 243.96,176.68 244.58,176.06 244.58,169.65 243.7,168.77 242.47,168.77 240.96,167.27 240.96,166 241,165.96 241,164.07 UG6.D23
FBC_CMD50: length 18.9
  IN4 w0.102: v2(241.61,167.11) 241.61,167.52 242.39,168.3 243.63,168.3 245,169.67 245,177.74 243.69,179.05 243.23,179.05 242.86,178.68 242.11,178.68 v2(241.75,178.32)
  BOTTOM w0.102: VRAM2.L12 241.38,177.96 241.73,178.32 v2(241.75,178.32)
  BOTTOM w0.129: v2(241.61,167.11) 241.23,166.73 241.23,166.24 241.35,166.12 UG6.A23
FBC_CMD51: length 18.5
  IN2 w0.114: v2(243.46,178.04) 242.82,177.4 241.55,177.4 v2(240.98,176.83)
  BOTTOM w0.102: v2(240.98,176.83) 240.98,176.85 240.64,177.2 VRAM2.K11
  BOTTOM w0.165: UG6.A22 242.11,165.88 242.11,167.92 242.59,168.39 243.97,168.39 244.94,169.36 244.94,176.85 243.75,178.04 v2(243.46,178.04)
FBC_CMD52: length 20.2
  IN4 w0.102: v2(240.98,179.07) 241.37,179.46 244.11,179.46 245.36,178.22 245.36,169.61 243.28,167.54 242.92,167.54 v2(242.66,167.27)
  BOTTOM w0.102: v2(242.66,167.27) 242.4,167.02 242.4,165.61 242.05,165.25 UG6.B22 ; VRAM2.M11 240.63,178.72 v2(240.98,179.07)
FBC_DBI0: length 17.1
  IN2 w0.102: v2(257.02,172.31) 257.46,171.88 257.46,171.67 257.83,171.29 257.97,171.29 258.27,170.99 258.27,169.76 256.06,167.55 255.11,167.55 254.53,166.98 254.53,164.99 253.64,164.1 253.64,162.78 252.8,161.94 v2(252.8,160.48)
  BOTTOM w0.102: v2(257.02,172.31) 257.01,172.31 VRAM3.R2
  BOTTOM w0.13: v2(252.8,160.48) 252.88,160.56 252.88,161.29
  BOTTOM w0.161: UG6.G7 252.88,161.29
FBC_DBI1: length 25.5
  IN1 w0.102: v2(256.27,181.32) 256.6,181.66 256.6,182.27 256.76,182.43 258.18,182.43 258.82,181.79 258.82,169.69 257.51,168.38 257.51,165.07 256.82,164.38 256.82,163.09 v2(256.39,162.67)
  BOTTOM w0.102: UG6.E3 255.37,163 255.64,163 255.93,162.71 256.34,162.71 v2(256.39,162.67)
  BOTTOM w0.161: v2(256.27,181.32) 256.63,180.96 VRAM3.D2
FBC_DBI2: length 13.4
  IN2 w0.102: v2(248.74,172.31) 248.73,172.31 247.51,171.1 247.51,169.88 247.26,169.62 247.26,166.63 246.65,166.02 246.65,165.29 246.28,164.93 246.28,164.24 246.42,164.11 246.42,161.79 v2(245.9,161.27)
  BOTTOM w0.161: UG6.G16 v2(245.9,161.27) ; v2(248.74,172.31) 248.74,172.33 VRAM3.R13
FBC_DBI3: length 25
  IN1 w0.102: v2(248.72,181.32) 249.1,180.94 250.03,180.94 251.87,179.11 251.87,168.59 251.68,168.4 251.68,164.13 251.23,163.68 251,163.68 250.62,163.3 250.62,161.92 250.3,161.6 249.18,161.6 v2(249,161.42)
  BOTTOM w0.102: v2(248.72,181.32) 248.38,180.97 VRAM3.D13
  BOTTOM w0.161: UG6.G13 248.56,161.42 v2(249,161.42)
FBC_DBI4: length 24.8
  IN1 w0.102: v2(234.27,181.32) 234.64,180.95 234.64,179.67 234.39,179.43 233.35,179.43 233.08,179.16 233.08,174.34 233.24,174.19 233.68,174.19 233.87,174 233.87,173.64 234.06,173.45 235.17,173.45 236.2,172.42 236.2,169.36 237.89,167.67 237.89,162.37 v2(237.5,161.98)
  BOTTOM w0.102: v2(234.27,181.32) 233.9,180.95 VRAM2.R2 ; v2(237.5,161.98) 237.16,162.32 UG6.F29
FBC_DBI5: length 13.2
  IN2 w0.102: v2(234.25,172.34) 233.59,172.34 233.07,171.82 233.07,169.53 234.73,167.87 234.73,164.98 235,164.71 235,162.38 235.39,161.99 v2(235.39,161.97)
  BOTTOM w0.102: VRAM2.D2 233.9,172.7 v2(234.25,172.34) ; UG6.F32 235.39,161.98 v2(235.39,161.97)
FBC_DBI6: length 22.7
  IN1 w0.102: v2(241.77,181.32) 242.13,180.96 242.66,180.96 242.89,180.72 242.89,179.75 243.88,178.76 243.88,167.01 244.25,166.65 244.25,161.95 v2(244.77,161.42)
  BOTTOM w0.102: v2(241.77,181.32) 242.13,180.96 VRAM2.R13
  BOTTOM w0.161: v2(244.77,161.42) 244.57,161.62 UG6.G19
FBC_DBI7: length 13.6
  IN2 w0.102: v2(242.51,172.3) 243.01,171.8 243.01,169.54 242.27,168.8 242.27,165.44 242.09,165.26 242.09,163.74 242.09,162.36 v2(241.71,161.97)
  BOTTOM w0.102: VRAM2.D13 242.13,172.69 v2(242.51,172.3) ; UG6.G25 239.98,161.59 240.79,161.59 241.17,161.97 v2(241.71,161.97)
FBC_EDC0: length 12
  IN2 w0.102: v2(252.98,164.12) 253.69,164.83 253.69,167.43 254.27,168.01 255.66,168.01 257.43,169.79 257.43,170.94 257.18,171.2 256.63,171.2 v2(256.26,171.57)
  BOTTOM w0.102: v2(256.26,171.57) 256.26,171.57 256.63,171.93 VRAM3.T2
  BOTTOM w0.161: v2(252.98,164.12) 252.58,163.72 UG6.D7
FBC_EDC1: length 20.3
  IN1 w0.102: v2(257,182.04) 257.83,182.04 258.35,181.52 258.35,169.87 257.03,168.54 v2(257.03,166.54)
  BOTTOM w0.102: v2(257,182.04) 256.66,181.7 VRAM3.C2 ; v2(257.03,166.54) 256.05,166.54 255.66,166.15 255.66,165.6 255.35,165.29 UG6.B3
FBC_EDC2: length 9.5
  IN2 w0.102: v2(248.74,171.57) 248.35,171.19 248.35,169.65 247.71,169 247.71,166.44 247.16,165.89 247.16,164.48 v2(246.89,164.21)
  BOTTOM w0.102: VRAM3.T13 248.38,171.94 v2(248.74,171.57)
  BOTTOM w0.161: v2(246.89,164.21) 246.4,163.72 UG6.D16
FBC_EDC3: length 21.4
  IN1 w0.102: v2(248.01,182.06) 247.64,181.68 246.95,181.68 246.62,181.35 246.62,176.39 246.91,176.11 247.22,176.11 247.52,175.81 247.52,169.79 247.89,169.42 247.89,166.71 249.15,165.45 249.15,164.49 v2(248.79,164.13)
  BOTTOM w0.102: VRAM3.C13 v2(248.01,182.06)
  BOTTOM w0.161: v2(248.79,164.13) 248.76,164.13 UG6.D13
FBC_EDC4: length 22.8
  IN1 w0.102: v2(237.49,164.77) 236.95,165.32 236.95,167.9 235.39,169.45 235.39,170.99 235.19,171.19 234.86,171.19 234.63,171.42 234.63,171.78 234.45,171.96 233.95,171.96 233.06,172.84 233.06,173.38 232.87,173.57 232.39,173.57 232.22,173.74 232.22,179.93 232.49,180.19 233.64,180.19 233.87,180.43 233.87,181.66 233.53,182 233.53,182.06 v2(233.51,182.08)
  BOTTOM w0.102: v2(237.49,164.77) 237.15,164.43 UG6.C29 ; v2(233.51,182.08) 233.88,181.71 VRAM2.T2
FBC_EDC5: length 8.6
  IN2 w0.102: v2(233.49,171.58) 233.87,171.2 233.87,169.42 234.96,168.33 234.96,165.19 v2(235.39,164.76)
  BOTTOM w0.102: v2(233.49,171.58) 233.5,171.59 233.51,171.59 233.86,171.95 VRAM2.C2 ; UG6.C32 v2(235.39,164.76)
FBC_EDC6: length 20.3
  IN1 w0.102: v2(242.5,182.06) 242.91,181.64 242.91,181.32 243.22,181.02 243.49,181.02 244.26,180.25 244.26,167.16 244.77,166.65 v2(244.77,164.21)
  BOTTOM w0.102: v2(242.5,182.06) 242.14,181.7 VRAM2.T13
  BOTTOM w0.161: v2(244.77,164.21) 244.64,164.21 UG6.D19
FBC_EDC7: length 10
  IN2 w0.102: v2(240.44,164.16) 240.78,164.5 240.78,165.1 240.45,165.43 240.45,167.83 240.25,168.03 240.25,168.86 240.59,169.2 240.59,171.08 240.69,171.19 241.39,171.19 241.75,171.55 v2(241.75,171.55)
  BOTTOM w0.161: v2(240.44,164.16) 240,163.72 UG6.D25 ; VRAM2.C13 242.13,171.93 241.75,171.55 v2(241.75,171.55)
FBC_VREFC: length 0.8
  BOTTOM w0.3: VRAM3.K1 257.52,176.45 v2(257.95,176.02)
FBC_VREFC_H: length 3.7
  TOP w0.14: v1(230.6,178.16) 230.63,178.12 RG6.1
  BOTTOM w0.3: v1(230.6,178.16) 230.79,177.97 231.37,177.97 232.36,176.98 232.8,176.98 233.01,177.2 VRAM2.K1
FBC_ZQ_1_A: length 1.4
  TOP w0.203: v2(247.03,177.27) 246.88,177.12 RG9.1
  BOTTOM w0.12: v2(247.03,177.27) 247.1,177.2 VRAM3.J14
FBC_ZQ_1_B: length 1.8
  TOP w0.203: RG13.1 247.81,176.18 247.45,176.55 v2(247.01,176.55)
  BOTTOM w0.12: v2(247.01,176.55) 247.11,176.45 VRAM3.K14
FBC_ZQ_2_A: length 1.4
  TOP w0.14: v2(243.5,176.35) 243.86,175.99 RG14.1
  BOTTOM w0.102: v2(243.5,176.35) 243.41,176.45 VRAM2.J14
FBC_ZQ_2_B: length 1.4
  TOP w0.203: v2(243.45,177.01) 243.51,177.08 RG8.1
  BOTTOM w0.102: v2(243.45,177.01) 243.27,177.2 VRAM2.K14
FBD_CMD0: length 17
  IN4 w0.102: v2(268.5,143.85) 267.88,143.85 267.38,143.35 267.38,142.69 267.39,142.69 267.39,141.39 267.06,141.06 260.2,141.06 259.5,141.76 257.14,141.76 256.94,141.56 256.94,140.9 257.31,140.53 v2(257.31,140.24)
  BOTTOM w0.102: VRAM7.J4 268.13,143.47 268.5,143.85 v2(268.5,143.85) ; UG6.AU1 256.94,140.62 v2(257.31,140.24)
FBD_CMD1: length 19.1
  IN4 w0.102: v2(269.26,143.08) 269.26,143.08 268.89,142.71 268.89,142.1 268.98,142.01 268.98,140.1 268.27,139.39 259.32,139.39 v2(258.48,140.24)
  BOTTOM w0.129: UG6.AU4 255,140.97 257.06,140.97 257.24,140.79 257.92,140.79 v2(258.48,140.24) ; v2(269.26,143.08) 269.26,143.08 268.88,142.7 VRAM7.H3
FBD_CMD2: length 14.6
  IN4 w0.102: v2(257.38,141.3) 257.96,140.72 258.88,140.72 259.8,139.8 267.12,139.8 267.52,140.2 267.52,140.77 268.08,141.33 268.08,141.89 v2(268.5,142.31)
  BOTTOM w0.102: UG6.AT1 257.36,141.32 v2(257.38,141.3)
  BOTTOM w0.129: v2(268.5,142.31) 268.13,142.69 VRAM7.J3
FBD_CMD3: length 16
  BOTTOM w0.129: VRAM7.J1 267.95,141.02
  BOTTOM w0.165: 267.95,141.02 267.95,139.12 267.65,138.82 RG115.1 266.79,138.82 266.58,138.61 260.81,138.61 258.44,140.98 258.44,141.51 258.22,141.73 256.94,141.73 256.9,141.68 256.39,141.68 UG6.AR2
FBD_CMD4: length 14.8
  IN4 w0.102: v2(267.77,143.08) 267.77,141.41 267.19,140.83 266.8,140.83 266.64,140.67 266.64,140.43 266.31,140.1 260.05,140.1 v2(258.86,141.29)
  BOTTOM w0.102: UG6.AR1 256.8,141.98 258.32,141.98 258.86,141.44 v2(258.86,141.29) ; v2(267.77,143.08) 267.77,143.07 267.4,142.7 VRAM7.K3
FBD_CMD5: length 11.3
  IN4 w0.102: v2(266.99,142.31) 266.6,141.93 259.7,141.93 259.63,142 257.54,142 v2(257.16,142.38)
  BOTTOM w0.102: v2(257.16,142.38) 256.82,142.72 UG6.AP1 ; VRAM7.L3 266.63,142.67 v2(266.99,142.31)
FBD_CMD6: length 13.9
  IN4 w0.102: v2(267,143.85) 266.96,143.8 266.94,143.8 266.6,143.47 260.45,143.47 259.98,143 258.9,143 v2(258.33,142.43)
  BOTTOM w0.102: VRAM7.K4 267.38,143.48 v2(267,143.85)
  BOTTOM w0.129: v2(258.33,142.43) 257.94,142.82 257.27,142.82 257.03,143.06 254.99,143.06 UG6.AP4
FBD_CMD7: length 10.7
  IN4 w0.102: v2(266.24,143.08) 266.24,143.08 266.23,143.08 265.85,142.7 259.89,142.7 259.6,142.41 v2(258.97,142.41)
  BOTTOM w0.129: v2(258.97,142.41) 258.09,143.29 257.41,143.29 257.28,143.42 UG6.AN1 ; VRAM7.M4 266.24,143.08 v2(266.24,143.08)
FBD_CMD8: length 12.4
  BOTTOM w0.165: UG6.AM2 256.39,143.78 258.74,143.78 259.5,144.53 259.5,144.78 260.02,145.31 266.26,145.31 266.63,144.95 VRAM7.L5
FBD_CMD9: length 12
  IN4 w0.102: v2(257.14,144.43) 257.61,143.95 259.7,143.95 261.03,145.28 266.45,145.28 v2(267.06,144.67)
  BOTTOM w0.102: v2(257.14,144.43) 257.13,144.43 256.82,144.12 UG6.AM1 ; v2(267.06,144.67) 267.06,144.51 VRAM7.K5
FBD_CMD10: length 12.5
  IN4 w0.102: v2(258.28,144.45) 259.79,144.45 260.83,145.48 266.89,145.48 v2(267.68,144.69)
  BOTTOM w0.129: VRAM7.J5 268.13,144.25 v2(267.68,144.69) ; v2(258.28,144.45) 257.9,144.82 UG6.AL1
FBD_CMD11: length 15.6
  BOTTOM w0.165: UG6.AL4 254.99,145.16 256.89,145.16 256.99,145.07 259.24,145.07 259.78,145.61 268.14,145.61 268.69,145.05 268.69,144.38 VRAM7.H5
FBD_CMD12: length 15.2
  IN4 w0.102: v2(257.24,145.5) 257.89,144.85 259.5,144.85 260.33,145.68 267.88,145.68 269.3,144.26 269.59,144.26 v2(270,143.85)
  BOTTOM w0.102: UG6.AK1 257.22,145.52 v2(257.24,145.5)
  BOTTOM w0.129: VRAM7.G4 269.63,143.47 270,143.84 v2(270,143.85)
FBD_CMD13: length 15.1
  IN4 w0.102: v2(258.68,145.8) 259.3,146.42 267.53,146.42 269.24,148.14 v2(269.24,148.3)
  BOTTOM w0.102: VRAM7.G11 269.63,148.67 269.25,148.3 v2(269.24,148.3)
  BOTTOM w0.129: v2(258.68,145.8) 258.58,145.9 256.37,145.9 UG6.AJ2
FBD_CMD14: length 15.4
  TOP w0.165: RG36.2 270.28,147.06 v2(269.99,147.36)
  BOTTOM w0.129: v2(269.99,147.36) 269.99,147.58 VRAM7.G10
  BOTTOM w0.165: UG6.AJ1 259.09,146.22 259.4,145.91 268.55,145.91 v2(269.99,147.36)
FBD_CMD15: length 13.2
  BOTTOM w0.165: UG6.AH1 257.11,146.56 259.3,146.56 259.63,146.22 267.32,146.22 268.88,147.78 VRAM7.H10
FBD_CMD16: length 13.5
  BOTTOM w0.165: UG6.AH4 254.99,147.26 256.93,147.26 257.27,146.93 259.49,146.93 259.9,146.52 266.02,146.52 266.63,147.12 VRAM7.L10
FBD_CMD17: length 14.5
  TOP w0.165: RG38.2 264.98,146.17 265.92,147.11 v2(265.92,147.26)
  BOTTOM w0.129: VRAM7.M10 265.92,147.9 v2(265.92,147.26)
  BOTTOM w0.165: UG6.AG1 256.99,147.62 257.39,147.23 258.67,147.23 258.83,147.39 258.83,148.41 259,148.57 259.33,148.57 259.49,148.41 259.49,147.39 259.66,147.23 260.09,147.23 260.47,146.84 265.49,146.84 v2(265.92,147.26)
FBD_CMD18: length 10.9
  IN4 w0.102: v2(257.56,147.7) 258.54,148.68 265.15,148.68 265.51,148.32 v2(265.51,148.3)
  BOTTOM w0.102: UG6.AF2 256.05,148.27 256.32,148.01 257.26,148.01 v2(257.56,147.7) ; VRAM7.M11 265.5,148.32 v2(265.51,148.3)
FBD_CMD19: length 14.3
  IN2 w0.102: v2(265.62,151.6) 266.19,151.03 266.58,151.03 267.01,150.6 v2(267.01,149.06)
  BOTTOM w0.102: VRAM7.K11 267.37,148.7 v2(267.01,149.06)
  BOTTOM w0.165: UG6.AF1 257.95,148.32 261.51,151.88 265.34,151.88 v2(265.62,151.6)
FBD_CMD20: length 10.6
  IN4 w0.102: v2(257.41,148.78) 258.07,149.44 265.89,149.44 v2(266.27,149.82)
  BOTTOM w0.102: VRAM7.L12 266.63,149.47 v2(266.27,149.82) ; v2(257.41,148.78) 257.18,149.02 UG6.AE1
FBD_CMD21: length 16.3
  BOTTOM w0.165: UG6.AE4 254.99,149.36 257.98,149.36 260.86,152.24 265.75,152.24 266,151.99 266.63,151.99 267.01,151.61 267.01,149.81 VRAM7.K12
FBD_CMD22: length 16.1
  BOTTOM w0.165: UG6.AD1 257.54,149.72 260.44,152.61 265.99,152.61 266.16,152.44 266.97,152.44 267.13,152.28 268.23,152.28 268.66,151.85 268.66,151.31 268.51,151.16 268.51,149.83 VRAM7.J12
FBD_CMD23: length 18.7
  IN2 w0.114: v2(268.51,149.06) 268.51,149.06 268.79,149.35 268.79,151.6 v2(269.19,152)
  BOTTOM w0.12: v2(268.51,149.06) 268.49,149.06 VRAM7.J11
  BOTTOM w0.165: UG6.AC2 256.4,150.07 257.11,150.07 260.05,153.01 266.26,153.01 266.39,152.89 268.14,152.89 269.03,152 v2(269.19,152)
FBD_CMD24: length 13.6
  IN4 w0.102: v2(257.11,150.8) 257.7,150.21 268.88,150.21 269.25,149.84 v2(269.25,149.82)
  BOTTOM w0.102: v2(257.11,150.8) 256.75,150.44 UG6.AC1
  BOTTOM w0.129: v2(269.25,149.82) 269.24,149.82 268.88,149.46 VRAM7.H12
FBD_CMD28: length 15.4
  IN4 w0.102: v2(267.75,163.57) 267.74,163.57 267.36,163.94 267.36,164.53 266.39,165.51 260.69,165.51 259.98,164.8 259.98,164.56 258.47,163.05 v2(258.47,162.75)
  BOTTOM w0.102: VRAM5.K4 268.11,163.2 267.75,163.56 v2(267.75,163.57) ; v2(258.47,162.75) 257.69,161.97 256.28,161.97 256.05,161.74 UG6.G2
FBD_CMD29: length 17.9
  IN4 w0.102: v2(269.24,164.33) 269.22,164.31 269.2,164.31 268.85,163.95 268.29,163.95 268.13,164.11 268.13,165.44 267.2,166.37 260.87,166.37 259.71,165.2 259.71,164.98 258.08,163.36 258.08,162.59 257.2,161.71 v2(257.2,161.42)
  BOTTOM w0.102: UG6.G1 257,161.62 v2(257.2,161.42)
  BOTTOM w0.129: VRAM5.L3 268.88,163.97 v2(269.24,164.33)
FBD_CMD30: length 18
  IN4 w0.102: v2(255.7,161.97) 256.44,161.97 256.82,162.34 256.82,163.19 257.4,163.78 257.97,163.78 259.41,165.22 259.41,165.4 260.62,166.61 267.32,166.61 268.52,165.42 v2(268.52,164.33)
  BOTTOM w0.129: v2(268.52,164.33) 268.51,164.33 VRAM5.K3 ; UG6.G3 255.36,161.62 v2(255.7,161.97)
FBD_CMD31: length 20.2
  BOTTOM w0.165: VRAM5.J1 267.38,165.48 267.77,165.87 267.77,167.25 RG109.1 266.51,168.2 266.4,168.09 261.48,168.09 260.62,167.22 259.39,167.22 259.36,167.25 258.61,167.25 258.45,167.08 258.45,163.57 258.95,163.07 258.95,162.28 258.39,161.72 257.83,161.72 257.61,161.51 257.61,161.12 257.43,160.94 256.77,160.94 UG6.H1
FBD_CMD32: length 13.9
  IN4 w0.102: v2(256.4,161.27) 256.4,161.2 256.64,160.96 257.4,160.96 257.62,161.18 257.62,161.54 258.21,162.13 258.52,162.13 259.13,162.73 259.13,163.01 260.84,164.72 266.6,164.72 v2(266.98,164.33)
  BOTTOM w0.102: UG6.H2 256.05,160.92 v2(256.4,161.27) ; VRAM5.J3 267.36,163.95 266.98,164.32 v2(266.98,164.33)
FBD_CMD33: length 12
  IN4 w0.102: v2(266.24,164.33) 265.85,163.95 260.79,163.95 258.42,161.58 258.42,161.13 258.07,160.78 257.74,160.78 257.48,160.53 v2(257.19,160.53)
  BOTTOM w0.102: v2(257.19,160.53) 257.06,160.53 UG6.J1 ; VRAM5.H3 266.61,163.95 266.24,164.32 v2(266.24,164.33)
FBD_CMD34: length 14.5
  IN4 w0.102: v2(257.98,160.35) 258.1,160.24 258.95,160.24 259.42,160.7 259.42,161 260.81,162.39 266.43,162.39 266.83,162.79 v2(267,162.79)
  BOTTOM w0.102: UG6.K4 254.9,159.52 255.29,159.91 256.89,159.91 257.02,160.05 257.29,160.05 257.59,160.35 v2(257.98,160.35) ; VRAM5.J4 267.38,163.17 267,162.8 v2(267,162.79)
FBD_CMD35: length 11.4
  IN4 w0.102: v2(258.83,161.3) 260.72,163.19 264.66,163.19 265.05,162.79 v2(265.5,162.79)
  BOTTOM w0.102: v2(265.5,162.79) 265.5,162.8 265.88,163.17 VRAM5.G4 ; v2(258.83,161.3) 258.36,160.83 258.36,160.17 258.13,159.94 257.47,159.94 257.05,159.52 UG6.K1
FBD_CMD36: length 12.1
  BOTTOM w0.165: VRAM5.H5 265.53,161.35 260.08,161.35 258.32,159.6 257.59,159.6 257.17,159.17 256.58,159.17 256.23,159.52 UG6.K2
FBD_CMD37: length 12.6
  IN4 w0.102: v2(257.66,159.08) 258,158.74 259.15,158.74 259.44,159.03 259.44,159.28 260.99,160.83 265.33,160.83 266.22,161.71 266.67,161.71 v2(266.92,161.96)
  BOTTOM w0.102: v2(257.66,159.08) 257.4,158.82 UG6.L1 ; v2(266.92,161.96) 267.38,162.41 VRAM5.J5
FBD_CMD38: length 14.4
  IN4 w0.102: v2(267.78,161.91) 267.33,162.36 266.76,162.36 266.46,162.06 266.11,162.06 265.09,161.04 260.64,161.04 v2(258.8,159.2)
  BOTTOM w0.102: VRAM5.K5 268.13,162.26 v2(267.78,161.91) ; UG6.L2 256.37,158.5 257.63,158.5 257.93,158.79 258.45,158.79 258.8,159.14 v2(258.8,159.2)
FBD_CMD39: length 15.3
  BOTTOM w0.165: UG6.M1 257.59,158.12 257.99,158.52 258.93,158.52 259.26,158.85 259.26,160.06 260.2,161 266.01,161 266.37,161.36 268.71,161.36 269.04,161.69 269.04,162.28 VRAM5.L5
FBD_CMD40: length 17.8
  IN4 w0.102: v2(257.88,157.76) 258.46,158.35 259.18,158.35 259.71,158.88 259.71,159.16 261.14,160.59 265.51,160.59 266.24,161.32 267.78,161.32 268.2,161.74 268.2,162.14 268.41,162.35 268.81,162.35 v2(269.25,162.79)
  BOTTOM w0.102: 255.51,157.75 255.49,157.73 254.99,157.73 254.68,157.42 UG6.N4 ; VRAM5.M4 269.25,162.82 v2(269.25,162.79)
  BOTTOM w0.129: v2(257.88,157.76) 255.91,157.76 255.89,157.75 255.51,157.75
FBD_CMD41: length 18.9
  TOP w0.165: RG23.2 268.76,158.62 v2(269.44,159.3)
  BOTTOM w0.129: VRAM5.M10 269.44,158.88 v2(269.44,159.3)
  BOTTOM w0.165: UG6.N1 256.9,157.27 258.78,157.27 259.59,158.08 259.59,159.95 260.37,160.73 268.43,160.73 269.44,159.73 v2(269.44,159.3)
FBD_CMD42: length 16.2
  BOTTOM w0.165: VRAM5.L10 268.92,158.74 268.92,159.67 268.53,160.06 266.42,160.06 266.08,160.4 260.53,160.4 259.91,159.79 259.91,157.64 259.14,156.86 256.89,156.86 UG6.P1
FBD_CMD43: length 14.3
  BOTTOM w0.165: VRAM5.H10 266.57,158.7 266.04,159.22 266.04,159.48 265.46,160.07 260.69,160.07 260.24,159.62 260.24,157.35 259.27,156.38 256.39,156.38 UG6.P2
FBD_CMD44: length 13.4
  TOP w0.165: v2(265.58,159.29) 265.87,159.29 266.06,159.11 RG22.2
  BOTTOM w0.129: v2(265.58,159.29) 265.58,158.99 VRAM5.G10
  BOTTOM w0.165: UG6.R1 259.44,156.02 260.53,157.11 260.53,159.4 260.88,159.74 265.13,159.74 v2(265.58,159.29)
FBD_CMD45: length 13.3
  IN4 w0.102: v2(258.42,155.18) 260.47,157.23 261.11,157.23 261.38,157.5 261.38,157.86 261.48,157.96 262.24,157.96 265.12,157.96 v2(265.5,158.34)
  BOTTOM w0.129: VRAM5.G11 265.88,157.97 v2(265.5,158.34) ; UG6.T4 254.67,155.32 255,155.64 255.35,155.64 255.37,155.66 257.93,155.66 v2(258.42,155.18)
FBD_CMD46: length 11.7
  IN4 w0.102: v2(266.26,157.56) 265.88,157.18 265.88,156.61 265.71,156.44 260.61,156.44 258.94,154.77 257.66,154.77 v2(257.24,155.19)
  BOTTOM w0.102: v2(257.24,155.19) 257.11,155.32 UG6.T1 ; VRAM5.H12 266.63,157.2 v2(266.26,157.56)
FBD_CMD47: length 13.5
  IN2 w0.114: v2(266.3,155.06) 267.17,155.93 267.17,157.01 v2(267.74,157.58)
  BOTTOM w0.102: VRAM5.J11 v2(267.74,157.58)
  BOTTOM w0.165: v2(266.3,155.06) 265.95,155.06 265.55,154.66 258.84,154.66 258.64,154.46 257.1,154.46 256.93,154.62 UG6.U1
FBD_CMD48: length 13.9
  BOTTOM w0.165: UG6.U2 256.4,154.27 256.89,154.27 257.11,154.06 259.23,154.06 259.39,154.22 265.75,154.22 266.17,154.64 266.6,154.64 266.75,154.79 266.75,155.19 267.01,155.45 267.01,156.83 VRAM5.J12
