# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+5V on TOP (solid shape): 244.83,68.95 244.83,67.16 244.53,66.86 243.83,66.86 243.4,67.28 243.4,68.68 243.85,69.13 244.66,69.13
+5V on TOP (solid shape): 294.29,81.74 294.29,81.4 293.7,80.81 292.94,80.81 292.89,80.86 292.89,81.45 293.36,81.92 294.11,81.92
+5V on TOP (solid shape): 59.46,67.5 59.46,66.1 59.19,65.83 58.73,65.83 58.58,65.67 58.58,64.5 58.42,64.35 56.07,64.35 55.85,64.57 55.85,67.48 56,67.63 59.34,67.63
+5V on TOP (solid shape): 135.69,79.44 135.69,77.05 135.59,76.95 132.31,76.95 132.3,76.96 131.11,76.96 130.89,77.18 130.89,79.36 131.12,79.59 135.54,79.59
+5V on TOP (solid shape): 286.62,42.13 286.62,40.27 286.43,40.09 286.17,40.09 286.14,40.08 286.11,40.07 285.93,40.07 285.92,40.08 285.88,40.1 285.83,40.11 285.45,40.11 285.4,40.1 285.36,40.08 285.35,40.07 283.31,40.07 282.96,40.43 282.96,42.18 283.21,42.43 286.31,42.43
+5V on TOP (solid shape): 20.99,41.5 20.99,40.95 20.83,40.55 20.49,40.22 19.8,39.52 18.5,39.52 18.43,39.55 18.4,39.63 18.41,39.69 18.39,39.8 18.34,39.91 18.34,40.2 18.34,40.21 18.38,40.37 18.34,40.54 18.34,40.55 18.34,40.74 18.74,41.15 18.76,41.15 18.83,41.17 18.88,41.21 19.23,41.56 20.94,41.56
+5V on TOP (solid shape): 303.15,76.12 303.15,74.51 301.95,73.31 301.95,71.62 301.73,71.41 301.73,70.42 301.92,70.23 301.92,68.67 301.88,68.63 301.77,68.63 301.74,68.64 301.72,68.68 301.72,69.62 301.52,69.62 301.52,68.68 301.51,68.64 301.47,68.63 301.37,68.63 301.34,68.64 301.32,68.68 301.32,69.62 301.12,69.62 301.12,68.68 301.11,68.64 301.07,68.63 300.97,68.63 300.94,68.64 300.92,68.68 300.92,69.63 300.73,69.63 300.72,69.62 300.72,68.66 300.7,68.63 300.53,68.63 300.53,68.64 300.53,69.85 300.68,70.01 300.68,71.61 300.53,71.76 300.53,71.9 300.52,71.92 300.55,71.99 300.55,72.04 300.55,72.63 300.53,72.72 300.48,72.8 300.33,72.95 300.33,73.28 300.21,73.4 300.21,74.51 300.34,74.63 300.34,75.33 301.32,76.32 302.95,76.32
+5V on TOP (solid shape): outline of 96 points within 310.01,75 315.5,80.15
+5V on BOTTOM (solid shape): 307.62,62.68 307.62,61.79 307.47,61.63 306.79,61.63 306.66,61.76 306.66,62.22 307.16,62.73 307.18,62.73 307.28,62.83 307.47,62.83
+5V on BOTTOM (solid shape): 310.04,65.8 310.06,65.8 310.08,65.79 310.26,65.6 310.26,63.67 309.98,63.39 309.53,63.39 309.38,63.54 309.38,63.57 309.1,63.85 308.7,63.85 308.66,63.9 308.42,63.9 308.41,63.91 308.41,65.32 308.89,65.8
+5V on BOTTOM (solid shape): 107.42,107.53 107.42,106.57 107.24,106.39 107.02,106.39 106.76,106.39 106.56,106.59 106.56,107.68 106.64,107.76 106.84,107.76 106.9,107.77 106.97,107.79 107.17,107.79
+5V on IN1 (solid shape): 310.35,63.62 310.35,62.24 309.94,61.84 308.64,61.84 308.36,62.11 308.27,62.11 308.25,62.12 308.17,62.15 308.09,62.16 307.01,62.16 306.87,62.3 306.87,62.76 307.16,63.05 307.56,63.05 307.63,63.02 307.77,62.7 308.02,62.59 308.3,62.73 308.37,63.03 308.37,63.06 308.38,63.08 308.43,63.13 308.45,63.14 308.48,63.15 308.52,63.14 308.59,63.15 308.65,63.17 308.73,63.17 308.78,63.11 308.91,62.94 309.12,62.88 309.37,62.99 309.47,63.24 309.37,63.48 309.14,63.59 309.05,63.66 309.07,63.77 309.24,63.94 310.03,63.94
+5V on IN2 (solid shape): outline of 612 points within 19.05,39.41 91.8,78.3
+5V on SVCC (solid shape): outline of 1201 points within 240.8,36.03 321.37,83.02
+5V on SVCC1 (solid shape): outline of 671 points within 129.32,66.13 251.26,92.58
+5V on IN4 (solid shape): outline of 2365 points within 89.3,74.34 136.64,86.03
+5V_HDD on TOP (solid shape): 282.35,46.78 284.08,46.78 284.21,46.64 284.21,46.6 284.2,46.6 284.2,46.32 284.64,45.89 287.91,45.89 288.19,45.61 288.19,43.78 287.2,42.79 286.13,42.79 286.09,42.8 286.06,42.81 284.69,42.81 284.65,42.8 284.61,42.79 282.73,42.79 280.62,44.9 280.62,46.93 280.83,47.13 281.99,47.13
+5V_HDD on BOTTOM (solid shape): 285.3,46.67 285.3,45.53 284.41,44.64 281.77,44.64 281.1,45.3 281.07,45.3 281.05,45.32 279.94,45.32 279.91,45.35 279.91,45.53 279.93,45.56 279.96,45.58 281.05,45.58 281.05,45.82 279.96,45.82 279.93,45.84 279.91,45.87 279.91,46.03 279.93,46.06 279.96,46.08 281.05,46.08 281.05,46.32 279.96,46.32 279.93,46.34 279.91,46.37 279.91,46.53 279.93,46.56 279.96,46.58 281.05,46.58 281.05,46.82 279.96,46.82 279.93,46.84 279.91,46.87 279.91,47.03 279.96,47.08 281.05,47.08 281.08,47.11 281.18,47.11 281.59,47.51 284.46,47.51
+5V_HDMIC on TOP (solid shape): 16.88,39.22 16.89,39.19 16.89,39.16 16.86,39.08 16.86,39 16.87,38.89 16.92,38.78 16.92,38.57 16.82,38.47 16.37,38.47 15.8,37.9 14.38,37.9 13.06,36.57 12.33,36.57 12.28,36.62 12.28,37.24 13.67,38.64 15.21,38.64 15.86,39.29 16.81,39.29
+5V_HDMIC on BOTTOM (solid shape): 18.97,30.26 18.97,29.2 18.96,29.19 18.96,29.01 18.82,28.88 18.43,28.88 18.13,28.57 18.13,28.52 18.13,28.52 18.13,28.24 17.97,28.09 17.96,28.05 17.9,27.96 17.87,27.85 17.87,27.84 17.28,27.24 17.28,27.01 16.77,26.5 16.43,26.5 16.34,26.54 16.26,26.54 16.17,26.54 16.08,26.5 16.06,26.5 16.03,26.47 15.98,26.43 15.94,26.38 15.01,25.45 13.74,25.45 13.37,25.83 13.37,26.85 13.54,26.85 13.54,27.7 13.37,27.7 13.37,28.01 13.8,28.44 16.5,28.44 16.53,28.47 16.55,28.47 16.72,28.51 16.87,28.6 17.05,28.78 17.2,28.78 17.35,28.81 17.48,28.87 17.49,28.88 17.62,28.88 17.8,29.07 17.82,29.07 17.89,29.1 17.92,29.17 17.92,29.19 17.94,29.21 17.94,30.31 18.04,30.42 18.81,30.42
+5V_KB on TOP (solid shape): 185.43,49.84 185.43,48.52 185.35,48.44 184.92,48.44 184.82,48.34 184.82,47.65 184.08,46.91 183.38,46.91 182.94,46.46 182.94,44.75 182.86,44.67 182.53,44.67 182.3,44.44 182.3,42.77 181.94,42.42 180.46,42.42 180.25,42.63 180.25,47.11 181.09,47.96 183.18,47.96 183.81,48.59 183.81,49.58 184.18,49.95 185.33,49.95
+5V_KB on BOTTOM (solid shape): 183.28,45.88 183.28,43.34 182.67,42.73 181.43,42.73 180.64,43.52 180.64,45 183,45 183,45.84 182.8,45.84 182.8,45 182.5,45 182.5,45.84 182.3,45.84 182.3,45 180.64,45 180.64,45.66 181.07,46.09 183.07,46.09
+5V_LED on TOP (solid shape): 254.55,213.43 254.55,212.83 254.67,212.7 254.67,212.05 254.67,212.05 254.26,212.05 253.92,211.71 252.9,211.71 252.67,211.94 252.67,212.01 252.98,212.32 253.51,212.32 253.93,212.75 253.93,213.4 254,213.47 254.51,213.47
+5V_LED on TOP (solid shape): 227.85,217.6 227.85,217.1 227.73,216.98 227.73,216.6 227.65,216.53 227.62,216.53 227.58,216.54 227.53,216.54 227.25,216.54 227.24,216.54 226.72,217.06 226.12,217.06 226.03,217.15 226.03,217.51 226.08,217.56 226.36,217.56 226.36,217.56 227.23,217.56 227.34,217.67 227.78,217.67
+5V_LED on TOP (solid shape): 225.45,218.79 225.45,218.48 225.4,218.44 224.65,218.44 224.51,218.3 224.5,218.3 224.42,218.26 224.38,218.18 224.38,218.16 224.12,217.91 222.82,217.91 222.66,217.9 222.3,217.54 220.85,217.54 220.72,217.67 220.72,218.34 220.73,218.35 220.88,218.5 221.19,218.5 221.54,218.15 222.39,218.15 222.57,218.32 223.04,218.32 223.1,218.32 223.81,218.32 223.96,218.32 224.45,218.82 225.42,218.82
+5V_LED on TOP (solid shape): 250.34,213.58 250.34,212.79 250.35,212.73 250.34,212.7 250.24,212.6 249.62,212.6 249.57,212.55 249.55,212.54 249.52,212.54 249.48,212.55 249.44,212.55 249.21,212.48 249.07,212.29 249.06,212.28 249.04,212.26 249.04,212.14 249.04,211.38 249.04,211.08 248.92,210.96 248.19,210.96 247.98,211.17 247.98,212.1 248.08,212.2 248.08,212.25 248.27,212.44 248.29,212.47 248.31,212.5 248.33,212.52 248.36,212.52 248.46,212.57 248.5,212.67 248.5,212.7 248.6,212.8 248.6,213.4 248.61,213.42 248.63,213.43 248.75,213.5 248.84,213.62 248.86,213.64 248.88,213.65 250.27,213.65
+5V_LED on TOP (solid shape): 172.1,219.6 172.1,218.5 172.23,218.36 172.43,218.36 172.48,218.36 172.52,218.35 172.56,218.36 172.61,218.36 172.86,218.36 173.02,218.2 173.02,216.93 172.58,216.48 171.62,216.48 171.43,216.54 171.23,216.48 170.48,216.48 170.48,216.48 169.97,216.48 169.83,216.61 169.83,216.84 169.75,216.92 169.71,216.96 169.67,217 169.4,217.27 169.06,217.27 168.87,217.46 168.87,217.81 168.89,217.83 169.06,217.83 169.88,217.83 170.01,217.71 170.01,217.68 169.99,217.6 169.99,217.54 170.1,217.26 170.38,217.15 170.49,217.16 170.6,217.21 170.61,217.22 170.67,217.22 170.8,217.34 170.8,217.63 170.75,217.68 170.71,217.76 170.66,217.82 170.65,217.84 170.64,217.86 170.64,218.81 170.64,218.91 170.64,219.22 170.5,219.36 168.89,219.36 168.27,218.74 167.29,218.74 167.25,218.78 166.45,218.78 166.35,218.87 166.35,219.74 166.54,219.93 171.76,219.93
+5V_LED on BOTTOM (solid shape): 267.04,192.77 269.28,192.77 269.5,192.55 269.5,191.99 269.29,191.78 268.83,191.78 268.66,191.95 267.83,191.95 267.63,192.15 266.86,192.15 266.53,192.49 266.53,192.76 266.59,192.82 266.98,192.82
+5V_LED on BOTTOM (solid shape): 148.71,202.97 148.91,202.97 148.91,202.96 148.91,202.75 148.5,202.75 148.26,203 147.09,203 146.99,202.9 146.99,202.24 146.46,201.7 145.44,201.7 145.23,201.91 144.73,201.91 144.57,201.75 144.33,201.75 144.19,201.89 144.19,202.1 144.34,202.26 145.31,202.26 145.51,202.05 146.45,202.05 146.73,202.34 146.73,203.08 147.01,203.36 148.32,203.36
+5V_LED on BOTTOM (solid shape): 145.99,215.62 145.99,215.04 145.65,214.69 145.65,213.42 145.26,213.03 145.2,213.01 145.13,213.02 144.99,213.21 144.76,213.29 144.48,213.17 144.37,212.81 144.4,212.73 144.43,212.64 144.49,212.55 144.51,212.49 144.49,212.42 144.42,212.3 144.39,212.17 144.51,211.89 144.86,211.74 144.88,211.67 144.88,210.2 145.27,209.82 145.3,209.82 145.32,209.81 145.44,209.73 145.58,209.71 145.72,209.74 145.85,209.82 145.98,209.82 146.36,210.2 146.36,211.89 146.37,211.93 146.37,211.95 146.37,212.78 146.61,213.02 146.92,213.02 147.17,212.76 147.17,209.79 146.64,209.26 145.5,209.26 145.49,209.26 145.34,209.29 145.19,209.26 145.18,209.26 144.73,209.26 144.3,209.69 144.3,211.24 144.09,211.45 144.08,211.47 144.04,211.56 143.94,211.59 142.57,211.59 142.51,211.58 142.46,211.53 142.44,211.51 141.79,211.51 141.78,211.53 141.72,211.58 141.66,211.59 140.29,211.59 140.22,211.58 140.17,211.53 140.16,211.51 140.05,211.51 139.63,211.93 139.63,213.33 139.62,213.34 139.62,214.71 139.68,214.77 142.01,214.77 142.14,214.64 142.14,214.47 142.37,214.24 144.81,214.24 144.97,214.4 144.97,215.29 145.49,215.81 145.8,215.81
+5V_LIGHT on TOP (solid shape): 219.33,42.48 219.33,42.1 219.25,42.03 218.81,42.03 218.5,41.72 218.5,41.35 218.44,41.29 218.44,39.4 218.22,39.18 217.44,39.18 217.29,39.34 217.29,40.27 217.61,40.59 217.61,41.43 217.77,41.59 217.77,41.95 218.07,42.25 218.07,42.56 218.24,42.73 219.08,42.73
+5V_LIGHT on BOTTOM (solid shape): 219.79,44.37 219.79,42.41 219.43,42.05 218.31,42.05 218.13,42.23 218.13,42.53 217.92,42.74 217.82,42.74 217.81,42.75 217.72,42.78 217.63,42.79 217.54,42.78 217.45,42.75 217.44,42.74 217.17,42.74 217.16,42.75 217.07,42.78 216.98,42.79 216.89,42.78 216.8,42.75 216.79,42.74 215.64,42.74 215.55,42.83 215.55,44.35 215.84,44.64 219.52,44.64
+5V_MCU on TOP (solid shape): 145.9,207.79 145.9,206.8 145.73,206.8 145.45,207.07 144.03,207.07 144.03,207.07 143.91,207.07 143.72,206.88 143.68,206.88 143.28,206.48 143.28,205.87 143.52,205.63 143.52,204.74 143.52,204.47 143.51,204.46 142.43,204.46 142.42,204.48 142.42,206.18 142.54,206.31 142.71,206.31 142.88,206.47 142.88,206.96 143.5,207.58 144.55,207.58 144.77,207.79 145.9,207.79
+5V_MCU on BOTTOM (solid shape): 155.3,205.17 155.3,204.59 154.86,204.15 153.37,204.15 153.25,204.27 151.87,204.27 151.84,204.29 151.84,204.59 151.86,204.62 151.9,204.64 152.88,204.64 153.53,205.29 155.19,205.29
+5V_MCU on BOTTOM (solid shape): 151.18,203.31 151.18,202.88 150.47,202.17 150.44,202.17 149.74,202.87 149.55,202.87 149.46,202.92 149.47,203.03 149.53,203.14 149.55,203.27 149.55,203.29 149.58,203.32 150.22,203.32 150.25,203.35 151.14,203.35
+5V_MCU on BOTTOM (solid shape): 148.12,208.46 148.12,207.89 148.49,207.52 148.49,206.8 148.45,206.76 148.26,206.76 147.81,207.22 144.53,207.22 144.33,207.01 144.29,207.02 144.22,207.04 144.14,207.05 144.04,207.04 143.95,207 143.94,207 143.82,207 143.54,206.71 143.54,205.96 143.47,205.89 142.12,205.89 142.01,205.99 142.01,206.11 141.61,206.52 139.99,206.52 139.97,206.54 139.97,207.61 139.98,207.65 140.02,207.66 140.03,207.66 141.4,207.66 141.45,207.67 141.49,207.69 141.5,207.7 141.53,207.7 142.04,208.21 143.5,208.21 143.71,208 146.95,208 147.49,208.54 148.05,208.54
+5V_PVDD on TOP (solid shape): 311.48,77.28 312.27,77.28 312.6,76.95 313.19,76.95 313.31,76.82 313.31,76.19 313.41,76.09 313.41,74.97 313.34,74.89 313.24,74.89 312.83,74.49 312.83,71.82 313.03,71.62 313.03,69.03 312.98,68.97 312.91,68.97 312.85,69.03 312.85,70.04 312.75,70.14 312.75,71.44 312.5,71.69 312.5,75.02 312.17,75.35 310.42,75.35 310.21,75.15 310.21,73.27 310.04,73.09 309.73,73.09 309.5,72.86 309.5,71.77 311.08,70.19 311.08,70.03 311.05,70.03 311.04,69.03 310.85,69.03 310.85,70.03 310.81,70.03 310.42,70.42 309.78,70.42 308.56,71.64 308.56,73.55 308.87,73.85 308.87,74.61 309.15,74.89 309.15,76.47 309.53,76.85 309.86,76.85 310.14,77.13 310.14,77.46 310.26,77.59 311.18,77.59
+5V_PVDD on BOTTOM (solid shape): 307.18,65.41 307.18,64.95 307.6,64.53 307.6,64.11 307.45,63.97 307.13,63.97 306.31,64.78 306.31,65.41 306.33,65.45 306.36,65.46 307.12,65.46
+5V_S5 on TOP (solid shape): 128.2,78.16 128.2,75.36 127.99,75.15 126.11,75.15 125.76,75.5 125.76,78.14 125.91,78.3 128.06,78.3
+5V_S5 on TOP (solid shape): 260.97,213.99 260.97,213.72 260.06,212.82 258.82,212.82 258.7,212.94 258.7,213.55 258.78,213.63 259.53,213.63 260.25,214.34 260.62,214.34
+5V_S5 on TOP (solid shape): 222.18,43.24 222.18,42.5 221.98,42.3 221.93,42.3 221.78,42.15 221.78,41.63 221.49,41.34 221.49,41.32 221.37,41.2 220,41.2 219.92,41.28 219.92,41.72 219.5,42.14 219.5,42.6 219.05,43.04 219.05,43.49 219.14,43.58 221.84,43.58
+5V_S5 on TOP (solid shape): 284.64,85.91 284.64,85.36 284.61,85.27 284.6,85.19 284.6,85.17 284.35,84.93 283.52,84.93 283.46,84.99 283.44,85.02 283.46,85.06 283.47,85.07 283.47,85.89 283.48,85.93 283.52,85.94 283.95,85.94 284.08,86.07 284.48,86.07
+5V_S5 on TOP (solid shape): 167.32,213.51 167.33,213.5 167.33,213.48 167.33,213.05 167.47,212.91 167.5,212.91 167.59,212.82 167.59,212.55 167.46,212.41 167.25,212.41 167.08,212.58 167.08,212.69 166.81,212.97 166.3,212.97 166.25,212.98 165.56,212.98 165.51,212.97 165.34,212.97 165.03,212.67 165.03,212.16 164.88,212.01 164.21,212.01 164.2,212.01 164.2,212.82 164.26,212.88 164.57,212.88 165.05,213.35 166.42,213.35 166.66,213.59 167.24,213.59
+5V_S5 on TOP (solid shape): 164.59,206.23 164.62,206.22 164.64,206.18 164.64,205.72 164.66,205.7 164.66,205.25 163.7,204.29 163.41,204.29 162.99,203.88 162.99,203.33 162.9,203.24 162.84,203.2 162.79,203.16 162.52,203.16 162.31,203.38 162.31,204.35 162.31,204.62 162.31,204.68 162.31,204.74 162.31,204.76 162.32,204.78 162.51,204.96 163.27,204.96 163.28,204.96 164,204.96 164.43,205.39 164.43,205.72 164.44,205.72 164.44,206.22 164.44,206.23
+5V_S5 on TOP (solid shape): 253.52,81.42 253.52,81.32 253.65,81.19 254.46,81.19 254.66,80.99 254.66,79.01 254.28,78.63 254.28,72.07 254.28,72.07 254.28,71.89 254.11,71.72 253.71,71.72 253.45,71.98 253.45,72.44 253.79,72.79 253.79,73.55 253.93,73.69 253.93,77.38 253.93,77.41 253.93,77.45 253.93,77.48 253.93,77.52 253.93,78.15 253.93,78.16 253.95,78.23 253.96,78.31 253.95,78.38 253.93,78.46 253.93,78.73 254,78.8 254.23,78.8 254.41,78.99 254.41,79.34 254.21,79.54 253.97,79.54 252.67,80.83 252.67,81.44 252.84,81.61 253.33,81.61
+5V_S5 on TOP (solid shape): outline of 139 points within 183.84,41.81 195.34,45.16
+5V_S5 on BOTTOM (solid shape): 112.44,200.46 112.44,199.19 112.34,199.09 111.96,199.09 111.59,198.71 110.92,198.71 110.8,198.83 110.8,200.36 110.99,200.55 112.35,200.55
+5V_S5 on BOTTOM (solid shape): 122.05,199.67 122.05,199.17 121.96,199.08 121.34,199.08 121.04,198.77 120.63,198.77 120.53,198.87 120.53,199.61 120.63,199.71 122.01,199.71
+5V_S5 on BOTTOM (solid shape): 141.41,199.83 141.41,199.2 141.3,199.09 140.69,199.09 140.3,198.71 140.27,198.71 139.89,198.71 139.73,198.86 139.73,199.74 139.89,199.9 141.34,199.9
+5V_S5 on BOTTOM (solid shape): 160.86,200 160.86,199.25 160.73,199.12 160.12,199.12 159.7,198.7 159.62,198.7 159.6,198.71 159.58,198.71 159.2,198.71 159.19,198.71 159.19,198.97 159.42,199.2 159.42,200.12 159.89,200.6 160.26,200.6
+5V_S5 on BOTTOM (solid shape): 203.08,105.79 203.08,105.27 203.09,105.22 203.09,104.72 203.44,104.38 203.94,104.38 204,104.32 204,103.77 203.94,103.71 201.62,103.71 201.56,103.78 201.56,105.35 202.02,105.81 203.06,105.81
+5V_S5 on BOTTOM (solid shape): 256.31,92.16 256.31,90.92 256.38,90.85 257.63,90.85 257.66,90.82 257.66,90.67 257.61,90.62 256.42,90.62 256.21,90.41 255.81,90.41 255.73,90.49 255.73,92.16 255.81,92.24 256.24,92.24
+5V_S5 on BOTTOM (solid shape): 151.36,199.41 151.36,199.16 151.22,199.01 150.69,199.01 150.09,198.41 149.55,198.41 149.22,198.74 148.92,198.74 148.74,198.92 148.74,199.24 148.89,199.4 149.18,199.4 149.34,199.24 149.34,199.02 149.55,198.81 150.15,198.81 150.56,199.22 150.56,199.43 150.72,199.59 151.18,199.59
+5V_S5 on BOTTOM (solid shape): 113.67,50.58 113.67,50 113.91,49.76 113.91,49.39 114.16,49.15 114.16,48.95 113.76,48.95 113.7,48.93 113.66,48.89 113.65,48.86 113.57,48.86 113.53,48.89 113.53,49.03 113.12,49.44 113.12,50.59 113.21,50.68 113.57,50.68
+5V_S5 on BOTTOM (solid shape): 119.74,196.1 120.24,196.1 120.78,195.56 120.87,195.56 120.87,195.56 121.51,195.56 121.53,195.54 121.53,195.28 121.5,195.25 120.89,195.25 120.87,195.26 120.85,195.27 120.79,195.33 120.33,195.33 120.11,195.56 119.53,195.56 118.95,196.14 118.95,196.35 119.1,196.5 119.34,196.5
+5V_S5 on BOTTOM (solid shape): 109.74,196.87 109.74,196.54 109.94,196.35 110.62,196.35 111.07,195.9 111.07,195.7 111.22,195.55 111.8,195.55 111.82,195.52 111.82,195.26 111.82,195.25 110.84,195.25 110.78,195.32 110.48,195.32 110.32,195.47 110,195.47 109.89,195.58 109.31,195.58 109.12,195.77 109.12,196.89 109.25,197.02 109.59,197.02
+5V_S5 on BOTTOM (solid shape): 158.38,196.08 158.97,196.08 159.35,195.7 159.38,195.65 159.43,195.62 159.48,195.57 159.48,195.56 160.05,195.56 160.09,195.54 160.11,195.51 160.11,195.28 160.08,195.25 159.32,195.25 159.02,195.56 158.13,195.56 157.52,196.17 157.52,196.39 157.66,196.53 157.92,196.53
+5V_S5 on BOTTOM (solid shape): 148.62,196.13 149.28,196.13 149.69,195.73 149.69,195.71 149.73,195.65 149.79,195.62 149.8,195.61 149.82,195.59 149.82,195.56 150.42,195.56 150.45,195.54 150.47,195.51 150.47,195.29 150.43,195.25 149.7,195.25 149.39,195.56 148.44,195.56 147.89,196.12 147.89,196.38 148.01,196.5 148.25,196.5
+5V_S5 on BOTTOM (solid shape): 138.93,196.21 139.54,196.21 140.04,195.71 140.04,195.7 140.07,195.65 140.12,195.62 140.13,195.62 140.17,195.58 140.17,195.56 140.78,195.56 140.78,195.56 140.82,195.52 140.82,195.3 140.81,195.27 140.77,195.25 140.17,195.25 140.17,195.24 140.06,195.24 139.85,195.46 138.86,195.46 138.22,196.1 138.22,196.46 138.32,196.56 138.58,196.56
+5V_S5 on BOTTOM (solid shape): 132.03,200.84 132.03,199.52 131.57,199.07 131,199.07 130.65,198.71 130.25,198.71 130.05,198.91 130.05,199.53 129.39,200.2 129.34,200.2 129.33,200.2 129.24,200.24 129.14,200.26 129.04,200.24 128.94,200.2 128.93,200.2 128.88,200.2 128.7,200.02 128.7,199.4 129.01,199.09 129.01,197.65 128.94,197.49 128.95,197.32 128.95,197.32 128.95,196.62 128.96,196.57 128.99,196.52 129.01,196.51 129.43,196.08 129.96,196.08 130.47,195.58 130.5,195.58 130.52,195.56 131.15,195.56 131.18,195.53 131.18,195.28 131.15,195.25 130.52,195.25 130.34,195.25 130.01,195.57 129.19,195.57 128.57,196.19 128.57,198.54 128.5,198.61 128.46,198.66 128.42,198.69 127.7,199.41 127.7,200.71 128.17,201.17 131.69,201.17
+5V_S5 on BOTTOM (solid shape): outline of 150 points within 126.59,207.86 144,215.09
+5V_S5 on BOTTOM (solid shape): outline of 2085 points within 125.73,54.68 181.45,79.9
+5V_S5 on IN1 (solid shape): outline of 1847 points within 179.58,39.97 223.04,58.23
+5V_S5 on IN1 (solid shape): outline of 2918 points within 101.77,111.7 128.54,217.84
+5V_S5 on IN2 (solid shape): outline of 1100 points within 101.81,77.09 128.81,115.69
+5V_S5 on IN4 (solid shape): outline of 1584 points within 109.1,204.31 139.7,217.87
+5V_S5_TYPEC on TOP (solid shape): 65.28,57.93 65.28,56.89 65.18,56.79 64.67,56.79 64.67,56.79 64.04,56.79 63.68,56.43 63.68,54.78 63.81,54.65 63.81,54.19 63.55,53.94 62.63,53.94 62.31,54.26 62.31,55.21 62.42,55.49 62.31,55.76 62.31,55.91 62.42,56.18 62.31,56.45 62.31,57.2 63.08,57.98 65.23,57.98
+5V_S5_TYPEC on TOP (solid shape): outline of 240 points within 51.84,75.43 62.46,97.22
+5V_S5_TYPEC on BOTTOM (solid shape): outline of 1065 points within 49.28,53.77 66.22,95.72
+5V_S5_TYPEC_R on TOP (solid shape): 55.16,74.97 55.16,73.42 55.2,73.38 55.2,72.46 55.2,72.45 55,72.45 55,73.16 54.8,73.16 54.8,72.45 54.57,72.45 54.22,72.81 52.15,72.81 51.84,73.11 51.84,74.69 52.24,75.08 55.04,75.08
+5V_S5_TYPEC_R on TOP (solid shape): 72.05,56.37 72.05,55.32 71.92,55.2 70.95,55.2 70.24,54.49 70,54.49 70,55.2 69.8,55.2 69.8,54.49 69.61,54.49 69.6,54.5 69.6,55.2 69.6,55.2 69.6,55.47 69.9,55.77 69.9,56 70.49,56.58 71.83,56.58
+5V_S5_TYPEC_R on TOP (solid shape): 67.03,56.32 67.84,56.32 68.02,56.14 68.02,55.89 68.2,55.7 68.2,54.5 68.2,54.49 68,54.49 68,55.2 67.8,55.2 67.8,54.49 66.71,54.49 66.39,54.17 64.75,54.17 64.32,54.6 64.32,54.62 63.83,55.11 63.83,56.25 64.18,56.59 64.56,56.59 64.6,56.63 66.71,56.63
+5V_S5_TYPEC_R on TOP (solid shape): outline of 137 points within 56.6,68.16 75.39,75.1
+5V_S5_TYPEC_R on BOTTOM (solid shape): 54.21,75.15 55.15,75.15 55.78,74.51 56.49,74.51 57.08,75.1 60.38,75.1 60.58,74.89 60.58,72.78 60.47,72.67 60.16,72.67 60.16,72.67 57.54,72.67 56.96,72.09 52.34,72.09 51.87,72.56 51.87,75.07 51.96,75.16 54.19,75.16
+5V_S5_TYPEC_R on BOTTOM (solid shape): outline of 309 points within 64.89,54.25 76.35,69.86
+5V_S5_TYPEC_R on IN1 (solid shape): outline of 220 points within 51.67,67.76 75.34,75.86
+5V_S5_TYPEC_R on IN2 (solid shape): outline of 323 points within 64.78,54.15 76.36,70.08
+5V_S5_TYPEC_R on IN4 (solid shape): outline of 196 points within 51.49,66.82 77.37,75.36
+5V_TP_LED on TOP (solid shape): 196.95,46.79 196.95,45.61 196.67,45.32 194.32,45.32 193.96,45.68 193.27,45.68 193.15,45.81 193.15,47.05 193.27,47.18 196.56,47.18
+5V_TP_LED on BOTTOM (solid shape): 194.28,47.34 194.28,46.96 194.64,46.59 195.02,46.59 195.51,46.1 195.51,45.43 195.89,45.05 196.47,45.05 196.59,45.17 196.59,46.43 196.79,46.62 197.42,46.62 197.57,46.47 197.57,44.48 197.28,44.2 194.43,44.2 193.16,45.47 193.16,47.1 193.47,47.41 194.21,47.41
+5VA on TOP (solid shape): 315.31,74.06 315.31,73.4 315.25,73.34 315.19,73.31 315.14,73.29 314.94,73.29 314.7,73.05 314.7,72.79 314.54,72.62 314.46,72.62 314.42,72.57 314.31,72.57 314.11,72.37 314.11,72.07 313.69,71.66 313.58,71.55 313.58,71.53 313.53,71.47 313.53,70.89 313.54,70.84 313.58,70.78 313.58,70.76 313.58,70.51 313.54,70.46 313.54,70.45 313.51,70.42 313.51,70.13 313.45,70.07 313.45,70.03 313.45,69.07 313.43,69.04 313.4,69.02 313.3,69.02 313.26,69.04 313.25,69.07 313.25,70.03 313.24,70.03 313.24,70.47 313.24,70.48 313.24,71.72 313.37,71.85 313.37,74.23 313.44,74.3 315.08,74.3
+5VA on BOTTOM (solid shape): 314.71,73.82 314.71,72.84 314.53,72.66 314.02,72.66 313.92,72.56 313.92,72.3 313.87,72.25 313.87,71.44 313.82,71.39 313.79,71.35 313.79,70.28 313.87,70.21 314.26,70.21 314.31,70.16 314.31,69.66 314.24,69.6 313.45,69.6 313.34,69.71 313.34,72.02 313.22,72.14 313.22,72.79 313.66,73.23 313.67,73.24 313.81,73.32 313.87,73.47 313.88,73.81 313.95,73.89 314.64,73.89
+5VPCU on TOP (solid shape): 287.75,117.93 287.75,116.23 287.34,115.81 284.8,115.81 284.27,116.34 284.27,118.01 284.31,118.05 287.63,118.05
+5VPCU on TOP (solid shape): 319.61,92.52 319.61,92.01 319.92,91.71 319.92,90.89 319.61,90.59 318.32,90.59 318.09,90.82 318.09,92.5 318.21,92.62 319.51,92.62
+5VPCU on TOP (solid shape): 61.8,71.96 61.8,70.62 61.65,70.47 61.65,69.3 60.66,68.31 58.88,68.31 58.78,68.42 58.78,70.63 59.11,70.96 59.81,70.96 61.03,72.18 61.58,72.18
+5VPCU on TOP (solid shape): 74.63,54.12 74.63,53.68 74.22,53.28 73.26,53.28 72.82,53.71 71.96,53.71 71.68,53.99 71.68,54.93 71.76,55 73.74,55
+5VPCU on TOP (solid shape): 268.68,202.81 268.68,201.89 268.56,201.77 267.03,201.77 266.98,201.72 266.98,201.4 265.7,201.4 265.7,201.2 266.98,201.2 266.98,200.93 266.96,200.9 265.53,200.9 265.38,201.05 265.38,202.6 265.79,203.01 268.48,203.01
+5VPCU on TOP (solid shape): 62.89,53.58 63.88,53.58 64.24,53.23 65.28,53.23 65.48,53.02 65.48,51.7 65.33,51.55 63.99,51.55 63.99,51.55 63.04,51.55 61.85,52.74 61.85,53.51 62.11,53.76 62.72,53.76
+5VPCU on TOP (solid shape): 301.71,110.34 301.71,109.16 301.57,109.01 301.57,108.39 301.5,108.32 301.5,108 301.31,107.81 298.4,107.81 298.22,107.99 298.22,108.88 298.49,109.15 298.94,109.15 300.36,110.58 301.47,110.58
+5VPCU on TOP (solid shape): 74.2,91.56 74.2,91.13 74.07,91 72.12,91 71.65,90.53 71.65,90.29 71.64,90.28 71.62,90.24 71.61,90.2 71.61,89.82 71.61,89.78 71.6,89.76 71.55,89.71 71.19,89.71 71.07,89.83 71.07,91.18 71.58,91.69 74.06,91.69
+5VPCU on TOP (solid shape): 51.13,69.49 51.18,69.41 51.26,69.38 52.63,69.38 52.66,69.39 52.7,69.4 52.76,69.33 52.76,69.33 52.81,69.29 52.81,67.07 52.83,67.05 52.83,66.46 52.58,66.21 49.17,66.21 48.94,66.45 48.94,69.39 49.05,69.51 51.12,69.51
+5VPCU on TOP (solid shape): 310.21,98.77 310.21,97.37 310.39,97.19 310.7,97.19 310.84,97.05 310.84,96.89 310.84,96.89 310.84,96.61 310.82,96.58 310.44,96.58 310.38,96.6 310.32,96.6 309.63,96.6 309.61,96.58 309.1,96.58 309.01,96.67 309.01,97.34 308.97,97.39 308.46,97.39 308.41,97.44 308.41,97.64 308.17,97.88 307.67,97.88 307.5,98.06 307.5,98.67 307.85,99.02 309.96,99.02
+5VPCU on TOP (solid shape): 317,99.25 317,98.9 317.27,98.62 317.27,98.24 317.2,98.16 317.2,96.62 317.18,96.59 317.15,96.57 316.81,96.57 316.73,96.59 316.67,96.6 316.25,96.6 316.21,96.61 316.2,96.65 316.2,97.42 315.51,98.1 315.51,98.43 315.76,98.68 315.76,99.16 315.93,99.33 316.92,99.33
+5VPCU on TOP (solid shape): 313.34,92.69 313.34,91.32 313.26,91.25 312.91,91.25 312.51,91.65 312.49,91.65 312.45,91.66 312.44,91.7 312.44,91.72 312.48,91.81 312.49,91.9 312.37,92.18 312.09,92.29 312.06,92.3 311.88,92.48 311.88,92.75 311.91,92.78 313.24,92.78
+5VPCU on TOP (solid shape): 138.05,69.46 138.05,67.73 137.67,67.35 126.42,67.35 126.23,67.54 126.23,69.18 126.59,69.55 128.63,69.55 129.27,68.91 132.54,68.91 132.6,68.96 132.62,68.97 132.7,69.01 132.74,69.11 132.74,69.49 132.74,69.52 132.76,69.6 132.84,69.63 133.16,69.63 133.22,69.62 133.26,69.62 133.31,69.62 133.36,69.63 133.82,69.63 133.87,69.68 137.83,69.68
+5VPCU on TOP (solid shape): 31.04,55.59 31.04,54.73 31.03,54.7 31.02,54.66 31.02,54.64 31.02,54.16 31.02,54.14 31.03,54.1 31.04,54.07 31.04,54 31.22,53.81 31.22,52.88 30.89,52.56 30.62,52.56 30.61,52.56 30.57,52.55 30.53,52.53 30.49,52.51 30.41,52.44 30.27,52.29 29.25,52.29 29.23,52.29 29.19,52.29 29.15,52.27 29.11,52.25 29.03,52.17 27.83,52.17 27.1,52.91 28.2,52.91 28.2,52.85 28.21,52.79 28.23,52.74 28.25,52.69 28.28,52.64 28.32,52.6 28.36,52.56 28.41,52.53 28.46,52.51 28.51,52.49 28.57,52.48 28.63,52.48 28.68,52.49 28.74,52.51 28.79,52.53 28.83,52.56 28.88,52.6 28.91,52.64 28.94,52.69 28.97,52.74 28.98,52.79 28.99,52.85 28.99,52.91 28.98,52.96 28.97,53.01 28.94,53.07 28.91,53.11 28.88,53.16 28.83,53.19 28.79,53.22 28.74,53.25 28.68,53.26 28.63,53.27 28.57,53.27 28.51,53.26 28.46,53.25 28.41,53.22 28.36,53.19 28.32,53.16 28.28,53.11 28.25,53.07 28.23,53.01 28.21,52.96 28.2,52.91 27.1,52.91 26.27,53.73 25.98,53.73 25.88,53.84 25.88,54.91 26.93,55.96 30.67,55.96
+5VPCU on BOTTOM (solid shape): 180.19,49.6 180.19,48.21 179.98,48 176.57,48 176.26,47.69 169.8,47.69 169.6,47.89 169.6,50.03 169.95,50.38 179.41,50.38
+5VPCU on BOTTOM (solid shape): 210.45,175.12 210.45,174.56 210.14,174.25 209.88,174.25 209.88,174.25 208.35,174.25 208.32,174.27 208.32,174.44 208.35,174.47 208.76,174.47 209.53,175.24 210.32,175.24
+5VPCU on BOTTOM (solid shape): 207.26,185.45 207.26,185.3 206.8,184.84 205.46,184.84 205.14,185.16 203.99,185.16 203.99,185.16 203.99,185.37 204.01,185.38 204.39,185.38 204.41,185.37 204.5,185.37 204.58,185.44 206.19,185.44 206.36,185.61 207.1,185.61
+5VPCU on BOTTOM (solid shape): 60.55,72.19 60.92,72.19 60.92,72.19 61.64,72.19 61.76,72.07 61.76,71.58 59.8,69.62 59.01,69.62 58.45,69.06 57.45,69.06 57.36,69.15 57.36,69.68 57.44,69.76 57.54,69.76 57.59,69.75 57.64,69.75 57.68,69.75 57.73,69.76 57.9,69.76 58.12,69.98 58.12,71.44 58.39,71.71 59.61,71.71 60.09,72.19 60.55,72.19
+5VPCU on BOTTOM (solid shape): 213.85,46.01 213.85,44.69 213.74,44.59 213.23,44.59 213.22,44.59 211.36,44.59 210.81,44.04 210.81,43.43 210.79,43.36 210.79,43.3 210.79,43.23 210.81,43.16 210.81,41.69 210.81,41.68 210.81,41.47 210.13,40.79 209.99,40.79 209.83,40.63 209.83,40.55 208.97,39.69 208.97,38.8 208.86,38.69 208.43,38.69 208.29,38.83 208.29,39.25 208.09,39.45 208.09,40.2 209.07,41.18 209.56,41.18 209.56,41.19 209.61,41.19 209.73,41.31 209.73,41.36 209.89,41.51 209.9,41.51 210.13,41.65 210.23,41.9 210.21,42.02 210.15,42.13 210.15,43.62 210.15,43.63 210.18,43.78 210.15,43.93 210.15,43.94 210.15,44.32 211.05,45.22 212.98,45.22 213.08,45.33 213.08,45.94 213.24,46.09 213.77,46.09
+5VPCU on BOTTOM (solid shape): outline of 687 points within 21.49,48.2 52.32,70
+5VPCU on IN1 (solid shape): outline of 1844 points within 25.75,52.04 63.06,73.4
+5VPCU on IN2 (solid shape): 287.63,116.97 287.63,116.06 287.35,115.78 284.77,115.78 284.52,116.04 284.52,116.84 284.92,117.25 287.35,117.25
+5VPCU on IN2 (solid shape): 269.09,202.2 269.09,201.54 269,201.44 265.98,201.44 265.98,202.4 266.16,202.57 268.71,202.57
+5VPCU on SVCC (solid shape): 42.11,54.96 42.14,54.9 42.19,54.85 42.93,54.11 42.93,48.22 42.97,48.03 43.08,47.86 43.71,47.23 43.87,47.12 44.07,47.08 44.2,46.82 44.47,46.71 44.74,46.82 44.87,47.07 45.01,46.83 45.28,46.73 45.54,46.83 45.68,47.08 55.76,47.08 55.95,47.12 56.12,47.23 62.84,53.95 62.98,54.04 63.07,54.18 63.71,54.83 66.7,54.83 66.85,54.62 67.08,54.55 67.32,54.62 67.47,54.83 74.21,54.83 75.83,53.21 75.83,44.54 75.76,44.43 75.74,44.3 75.76,44.18 75.83,44.07 75.83,42.35 75.65,42.22 75.58,42.01 75.65,41.8 75.83,41.67 75.83,40.53 60.7,40.53 59.92,40.38 59.26,39.93 57.36,38.03 51.41,38.03 49.98,37.44 49.38,36 49.38,34.03 33.51,34.03 33.51,36.49 31.25,38.75 30.38,38.75 29.92,39.21 29.92,53.9 30.98,54.96
+5VPCU on SVCC1 (solid shape): outline of 2863 points within 29.92,34.03 321.37,137.05
+5VPCU on IN3 (solid shape): outline of 435 points within 169.34,38.53 209.98,50.28
+5VPCU on IN3 (solid shape): outline of 1496 points within 285.22,91.07 319.92,117.54
+5VPCU on IN4 (solid shape): outline of 244 points within 48.43,66.33 62.46,72.52
+12V_FAN on TOP (solid shape): 292.71,87.24 292.71,85.74 292.43,85.46 290.83,85.46 290.78,85.51 290.78,85.87 291.14,86.23 291.14,87.21 291.39,87.47 292.48,87.47
+12V_FAN on TOP (solid shape): 145.09,212.28 145.09,211.6 144.61,211.11 143.77,211.11 143.74,211.14 143.74,211.7 143.87,211.82 144.5,211.82 144.55,211.88 144.55,212.33 144.68,212.46 144.91,212.46
+12V_FAN on TOP (solid shape): 98.09,99.34 98.09,97.85 97.84,97.6 96.32,97.6 95.86,97.14 89.72,97.14 89.72,97.14 89.53,96.96 89.53,95.57 89.41,95.44 86.09,95.44 86.09,95.44 85.47,95.44 85.12,95.09 85.12,94.22 84.99,94.09 83.93,94.09 83.75,94.27 83.75,97.79 85.14,99.18 89.98,99.18 90.4,99.61 97.82,99.61
+12V_FAN on BOTTOM (solid shape): 115.41,104.6 115.41,103.05 115.42,103.04 115.42,97.27 114.18,96.03 108.44,96.03 107.06,97.4 107.06,98.16 107.36,98.45 109.11,98.45 109.78,97.78 113.39,97.78 113.72,98.11 113.72,103.42 112.35,104.79 111.59,104.79 111.36,105.02 110.01,105.02 109.88,105.14 109.88,106.19 110.21,106.52 113.49,106.52
+12V_FAN on IN1 (solid shape): 110.48,97.9 110.48,89.38 110.48,89.37 110.45,89.23 110.48,89.09 110.48,89.08 110.48,87.8 110.48,87.66 110.48,86.3 110.48,86.26 110.48,86.23 110.48,86.2 110.48,86.16 110.48,77.31 110.26,77.08 107.38,77.08 106.85,77.61 106.85,82.7 107.75,83.6 107.75,94.35 106.31,95.79 103.24,95.79 101.44,93.98 93.03,93.98 92.89,94.12 92.85,94.2 92.8,94.25 92.79,94.27 92.78,94.29 92.78,97.47 93.26,97.95 96.05,97.95 97.65,96.35 98.02,96.35 98.23,96.28 98.45,96.35 99.56,96.35 101.68,98.48 109.91,98.48
+12V_FAN on IN2 (solid shape): outline of 3509 points within 160.53,71.01 242.09,81.19
+12V_FAN on IN3 (solid shape): outline of 455 points within 108.09,73.23 164.29,79.44
+12V_FAN on IN3 (solid shape): outline of 1253 points within 237.19,65.55 270.49,86.42
+12V_FAN on IN4 (solid shape): outline of 433 points within 268.18,85.31 292.63,89.62
+12V_FAN1 on BOTTOM (solid shape): 109.98,104.77 110.59,104.77 110.85,104.51 110.85,103.09 110.14,102.38 110.14,101.74 110.11,101.72 109.36,101.72 109.36,102.2 109.35,102.2 109.35,104.2 109.1,104.46 109.1,104.74 109.15,104.79 109.98,104.79
+12V_FAN2 on TOP (solid shape): 290.31,85.28 290.74,85.28 290.74,85.19 291.41,85.19 291.42,85.18 291.42,84.57 290.48,83.63 290.48,83.2 290.47,83.2 290.47,81.57 290.09,81.19 288.5,81.19 288.32,81.36 288.32,81.55 288.95,82.18 289.67,82.18 289.81,82.32 289.81,83.16 289.08,83.88 289.08,84.62 289.74,85.28
+12V_FAN2 on BOTTOM (solid shape): 289.45,81.94 289.69,81.7 289.87,81.7 290.22,81.5 290.44,81.89 290.47,81.91 290.51,81.91 291.1,81.56 291.13,81.53 291.12,81.49 290.9,81.11 290.91,81.08 290.91,81.05 290.9,81.03 290.87,81 290.87,80.6 290.05,79.77 288.95,79.77 288.54,80.18 288.54,81.65 288.87,81.98 289.38,81.98
+19V_VIN1 on TOP (solid shape): 185.5,207.53 185.5,197.52 185.17,197.19 180.29,197.19 179.84,197.65 179.84,198.87 179.5,199.2 177.68,199.2 177.6,199.12 176.71,199.12 176.38,199.45 176.38,202.78 176.94,203.34 177.73,203.34 177.83,203.44 181.92,203.44 182.3,203.82 182.3,207.51 182.73,207.94 185.09,207.94
+19V_VIN1 on BOTTOM (solid shape): outline of 91 points within 171.81,197.19 200.6,212.24
+19V_VIN1 on SVCC (solid shape): 188.42,208.25 189.42,206.64 190.92,207.79 191.29,207.89 191.65,208.05 191.65,202.1 190.55,201 181.38,201 180.11,199.73 177.12,199.73 176.17,200.68 176.07,200.89 175.85,201 175.39,201.46 175.39,201.94 175.62,202.27 175.39,202.61 175.39,204.34 176.08,205.02 176.13,205.11 176.15,205.2 176.15,208.05 176.5,207.89 176.88,207.79 178.38,206.64 179.38,208.25
+19V_VIN2 on TOP (solid shape): 213.46,207.3 213.46,204.46 215.52,202.4 215.52,197.3 215.4,197.17 211.18,197.17 210.62,196.61 210.62,195.77 210.34,195.49 210.34,195.47 205.37,195.47 205.26,195.58 205.26,202.3 206.63,203.67 209.78,203.67 210.29,204.18 210.29,207.38 210.77,207.86 212.91,207.86
+19V_VIN2 on BOTTOM (solid shape): 223.11,214.41 223.11,209.94 222.98,209.8 222.48,209.8 222.33,209.65 222.33,206.18 222.68,205.83 224.58,205.83 224.78,205.63 224.78,203.49 224.53,203.25 219.61,203.25 219.36,203.49 215.87,203.49 215.52,203.15 215.52,197.3 215.4,197.17 211.18,197.17 210.62,196.61 210.62,195.76 210.6,195.76 210.31,195.47 205.37,195.47 205.01,195.84 205.01,202.45 206.23,203.67 209.78,203.67 210.29,204.18 210.29,206.8 210.32,206.82 210.32,207.35 210.82,207.86 212.96,207.86 213.52,207.3 213.52,205.84 213.76,205.6 216.13,205.6 216.14,205.59 219.69,205.59 219.95,205.32 219.95,204.98 220.12,204.81 221.37,204.81 221.57,205.01 221.57,210.32 222.54,211.28 222.54,214.43 222.56,214.46 223.07,214.46
+19V_VIN2 on SVCC (solid shape): 216.42,208.25 216.77,206.97 218.06,206.69 218.06,206.55 211.46,199.94 211.46,196.71 210.16,195.42 201.13,195.42 200.54,196.01 200.54,204.25 202.35,206.06 202.35,205.75 203.1,205 203.85,205.75 203.85,207.56 204.28,207.99 204.57,207.87 204.88,207.79 206.38,206.64 207.38,208.25
+V3.3DX_RT_TCP0 on TOP (solid shape): 56.19,98.34 56.19,95.95 56.09,95.85 53.6,95.85 53.5,95.95 53.5,96.81 53.7,97.02 53.7,98.51 53.75,98.57 55.96,98.57
+V3.3DX_RT_TCP1 on TOP (solid shape): 49.03,80.48 49.03,78.09 48.87,77.94 46.46,77.94 46.31,78.09 46.31,80.53 46.41,80.63 48.87,80.63
+VCC0V9_SVR_TCP0 on TOP (solid shape): 47.91,96.86 47.91,95.01 47.48,94.58 47.48,94.07 47.17,93.77 46.69,93.77 46.28,93.36 45.14,93.36 45.06,93.43 45.06,95.67 45.47,96.08 45.47,96.97 45.57,97.07 47.7,97.07
+VCC0V9_SVR_TCP0 on BOTTOM (solid shape): 38.12,90.25 38.12,89.38 37.94,89.2 37.92,89.19 37.89,89.18 37.74,89.16 37.61,89.09 37.58,89.08 37.55,89.09 37.4,89.18 37.24,89.21 37.07,89.18 36.92,89.08 36.8,88.96 36.71,88.82 36.67,88.64 36.67,88.58 36.59,88.5 36.2,88.5 36.06,88.64 36.06,89.01 36.13,89.24 36.06,89.46 36.06,89.94 36.21,90.1 36.44,90.1 36.49,90.1 36.59,90.12 36.72,90.16 36.81,90.26 36.81,90.28 36.84,90.3 38.08,90.3
+VCC0V9_SVR_TCP0 on IN1 (solid shape): outline of 706 points within 36.33,87.21 47.91,96.01
+VCC0V9_SVR_TCP0_PHASE on TOP (solid shape): 44.55,95.49 44.55,93.49 44.29,93.22 44.28,93.21 44.17,93.16 44.07,93.08 43.99,93 43.97,93 43.62,92.9 43.32,92.68 42.89,92.26 42.43,92.26 42.36,92.25 42.27,92.3 42.17,92.32 42.07,92.3 41.98,92.25 41.97,92.24 41.9,92.24 41.89,92.24 41.75,92.29 41.6,92.3 41.28,92.3 41.24,92.32 41.23,92.35 41.23,93.03 43.03,94.83 43.03,95.42 43.18,95.57 44.48,95.57
+VCC0V9_SVR_TCP1 on TOP (solid shape): 42.52,79.43 43.17,79.43 43.31,79.29 43.31,76.75 43.06,76.49 42.12,76.49 41.71,76.09 40.57,76.09 40.49,76.16 40.49,78.12 41.3,78.93 41.3,79.62 41.41,79.72 42.23,79.72
+VCC0V9_SVR_TCP1 on BOTTOM (solid shape): 33.56,72.96 33.56,72.56 32.91,71.91 32.88,71.89 32.85,71.89 32.77,71.92 32.68,71.93 32.51,71.89 32.36,71.8 32.27,71.71 32.18,71.56 32.14,71.39 32.14,71.25 32.13,71.21 32.09,71.2 31.67,71.2 31.6,71.26 31.6,72.19 31.77,72.35 31.82,72.35 31.86,72.36 31.9,72.37 32.01,72.37 32.16,72.52 32.16,72.94 32.26,73.04 33.48,73.04
+VCC0V9_SVR_TCP1 on IN1 (solid shape): outline of 1122 points within 31.75,70.96 43.44,79.16
+VCC0V9_SVR_TCP1_PHASE on TOP (solid shape): 39.98,78.22 39.98,76.21 39.71,75.94 39.7,75.94 39.6,75.89 39.5,75.81 39.42,75.73 39.4,75.72 39.17,75.68 38.96,75.58 38.82,75.74 38.61,75.8 38.43,75.75 38.28,75.62 37.91,75.62 37.9,75.61 37.62,75.53 37.51,75.27 37.26,75.03 36.67,75.04 36.66,75.08 36.66,75.76 38.46,77.56 38.46,78.05 38.71,78.3 39.91,78.3
+VCC1.05_OUT_FET on TOP (solid shape): 211.33,69.8 211.33,67.58 211.24,67.49 211.24,66.96 211.11,66.83 210.75,66.83 210.63,66.95 210.63,68.34 210.61,68.36 210.6,68.37 210.55,68.44 210.47,68.46 210.06,68.46 209.98,68.54 209.98,68.84 210.07,68.93 210.46,68.93 210.51,68.98 210.51,69.76 210.51,69.81 210.57,69.87 211.25,69.87
+VCC1.05_OUT_FET on BOTTOM (solid shape): 203.98,184.27 203.98,182.62 203.97,182.62 204.53,182.06 204.53,181.17 204.28,180.92 203.59,180.92 203.45,181.07 203.45,181.54 203.25,181.75 203.25,183.31 203.14,183.41 203.14,184.28 203.2,184.33 203.91,184.33
+VCC1.05_OUT_FET on BOTTOM (solid shape): 210.47,182.61 210.47,181.9 210.3,181.73 209.46,181.73 209.15,181.43 209.15,180.42 208.85,180.13 208.57,180.13 208.22,180.48 207.96,180.48 207.8,180.63 207.8,181.52 208.18,181.9 208.18,182.26 208.65,182.74 210.35,182.74
+VCC1.05_OUT_FET on IN1 (solid shape): 192.18,169.41 192.18,168.39 191.87,168.09 190.33,168.09 189.89,168.52 189.89,169.61 190.27,169.99 191.6,169.99
+VCC1.05_OUT_FET on IN1 (solid shape): 204.24,182.95 204.24,182.43 204.77,181.89 207.94,181.89 209.07,180.76 209.07,180.15 208.86,179.94 208.06,179.94 207.37,180.63 204.25,180.63 203.23,181.65 203.23,182.94 203.51,183.22 203.97,183.22
+VCC1.05_OUT_FET on IN2 (solid shape): 191.47,168.82 191.47,167.35 191.11,166.99 190.02,166.99 189.75,167.26 189.75,168.53 190.35,169.13 191.16,169.13
+VCC1.05_OUT_FET on IN2 (solid shape): 209.46,110 209.46,108.42 209.2,108.17 209.05,108.17 208.98,108.19 208.92,108.19 208.85,108.19 208.78,108.17 208.74,108.17 208.23,108.67 208.23,109.2 207.01,110.42 207.01,111.17 207.22,111.37 208.08,111.37
+VCC1.05_OUT_FET on IN3 (solid shape): outline of 1370 points within 208.94,66.82 215.67,82.88
+VCC1.05_OUT_FET on IN4 (solid shape): outline of 801 points within 205.43,81.47 215.47,109.92
+VCC3P3_ANA_TCP1 on BOTTOM (solid shape): 37.17,75.32 37.17,74.91 37.17,74.9 37.13,74.75 37.15,74.6 37.15,74.57 37.13,74.55 37.08,74.5 37.06,74.49 37.01,74.49 36.71,74.49 36.62,74.48 36.53,74.42 36.51,74.42 36.09,74.42 36.08,74.42 36,74.45 35.92,74.46 35.86,74.46 35.79,74.44 35.76,74.45 35.67,74.54 35.67,74.81 35.67,75.32 35.76,75.41 37.08,75.41
+VCC3P3_LC_TCP0 on TOP (solid shape): 43,85.02 43,84.76 43.18,84.59 43.19,84.56 43.17,84.5 43.17,84.44 43.21,84.27 43.33,84.13 43.36,84.1 43.38,84.1 43.47,84.06 43.56,84.05 43.66,84.06 43.75,84.1 43.76,84.1 43.83,84.1 43.93,84.2 43.93,84.3 43.95,84.38 43.96,84.44 43.92,84.62 43.8,84.76 43.78,84.82 43.74,84.87 43.74,85.09 43.79,85.14 44.35,85.14 44.44,85.05 44.44,83.85 44.07,83.48 42.92,83.48 42.8,83.6 42.8,84.05 42.38,84.46 42.38,85.1 42.45,85.16 42.86,85.16
+VCC3P3_LC_TCP0 on BOTTOM (solid shape): outline of 102 points within 38.51,82.69 43.26,90.35
+VCC3P3_LC_TCP0 on IN3 (solid shape): outline of 158 points within 38.89,85.84 42.06,90.31
+VCC3P3_LC_TCP1 on TOP (solid shape): 39.89,67.86 39.94,67.81 39.94,66.39 39.79,66.23 37.86,66.23 37.68,66.42 37.67,66.44 37.67,66.47 37.67,66.51 37.67,66.71 37.67,66.75 37.64,66.8 37.64,67.79 37.69,67.83 38.25,67.83 38.39,67.69 38.39,67.47 38.5,67.37 38.51,67.31 38.53,67.25 38.53,67.01 38.76,66.77 39.11,66.77 39.34,67 39.34,67.33 39.27,67.4 39.27,67.83 39.31,67.86 39.74,67.86
+VCC3P3_LC_TCP1 on BOTTOM (solid shape): outline of 182 points within 33.82,65.46 38.65,73.11
+VCC3P3_LC_TCP1 on IN3 (solid shape): 34.91,72.27 34.92,72.26 34.92,72.24 34.92,72.06 35.19,71.79 35.39,71.79 35.56,71.62 35.56,71.39 35.8,71.14 36.01,71.14 36.03,71.14 36.05,71.13 37.42,69.76 37.54,69.54 37.77,69.46 37.9,69.48 38.01,69.55 38.27,69.55 38.37,69.38 38.54,69.29 38.72,69.11 38.72,68.77 38.45,68.5 37.14,68.5 36.96,68.68 36.86,68.92 36.61,69.03 36.58,69.06 36.03,69.06 34.67,70.41 34.67,71.09 34.9,71.31 34.9,71.6 34.79,71.71 34.77,71.74 34.69,71.81 34.53,71.81 34.3,72.05 34.3,72.36 34.41,72.48 34.7,72.48
+VCC3V3_SX_TCP0 on TOP (solid shape): 57.03,95.47 57.03,94.32 56.9,94.2 55.63,94.2 55.5,94.32 55.5,95.47 55.63,95.59 56.9,95.59
+VCC3V3_SX_TCP0 on TOP (solid shape): 39.85,83.53 39.85,83.21 39.84,83.19 39.75,83.05 39.73,82.9 39.74,82.82 39.76,82.74 39.76,82.71 39.75,82.69 39.73,82.67 38.32,82.67 38.24,82.75 38.24,83.52 38.34,83.62 39.76,83.62
+VCC3V3_SX_TCP0 on TOP (solid shape): 33.08,96.84 33.08,96.45 32.9,96.27 32.42,96.27 32.26,96.11 32.26,96.04 32.14,95.92 31.84,95.92 31.78,95.98 31.77,96 31.77,96.04 31.77,96.42 31.77,96.45 31.75,96.49 31.75,96.6 31.8,96.66 31.83,96.67 31.88,96.66 32.08,96.66 32.11,96.66 32.15,96.68 32.17,96.68 32.5,97 32.91,97
+VCC3V3_SX_TCP0 on TOP (solid shape): 42.78,99.18 42.78,96.25 42.09,95.57 42.09,94.96 41.38,94.25 41.02,94.25 40.69,93.92 40.49,93.92 40.24,93.66 40.24,92.83 40.16,92.75 39.47,92.75 39.42,92.8 39.42,93.1 39.49,93.17 39.51,93.19 39.54,93.22 39.65,93.33 39.65,94.02 40.67,95.04 40.92,95.04 41,95.11 41,95.51 41.01,95.53 41.19,95.68 41.25,95.87 41.23,95.98 41.18,96.07 41.17,96.11 41.19,96.14 41.28,96.23 41.28,97.07 41.17,97.18 41.13,97.23 41.09,97.28 40.94,97.43 40.94,98.63 41.59,99.28 42.68,99.28
+VCC3V3_SX_TCP0 on BOTTOM (solid shape): 40.63,84.67 40.73,84.67 40.87,84.53 40.87,84.31 40.73,84.16 40.34,84.16 39.43,85.06 39.43,85.31 39.99,85.31
+VCC3V3_SX_TCP0 on IN3 (solid shape): outline of 762 points within 38.99,92.42 56.9,98.49
+VCC3V3_SX_TCP0 on IN3 (solid shape): outline of 838 points within 28.82,76.16 42.55,83.15
+VCC3V3_SX_TCP0 on IN4 (solid shape): outline of 2070 points within 32.39,82.64 42.47,98.39
+VCC3V3_SX_TCP0_DBRONLY on IN3 (solid shape): 39.14,93 39.14,92.36 39.12,92.34 39.11,92.33 38.94,92.21 38.87,92.02 38.97,91.78 39.21,91.68 39.25,91.69 39.3,91.7 39.32,91.7 39.35,91.68 39.45,91.58 39.45,91.23 39.3,91.07 39.04,91.07 38.89,91.23 38.87,91.25 38.87,91.28 38.88,91.33 38.89,91.38 38.79,91.61 38.56,91.71 38.51,91.71 38.46,91.7 38.43,91.69 38.41,91.71 38.31,91.81 38.31,92.8 38.6,93.09 39.06,93.09
+VCC3V3_SX_TCP1 on TOP (solid shape): 51.21,77.48 51.21,75.83 50.19,74.82 48.77,74.82 48.39,75.2 48.39,77.64 48.47,77.71 50.98,77.71
+VCC3V3_SX_TCP1 on TOP (solid shape): 38.36,81.62 38.36,79.13 37.52,78.3 37.52,77.69 36.81,76.98 36.45,76.98 36.12,76.65 35.92,76.65 35.66,76.39 35.66,75.55 35.59,75.48 34.9,75.48 34.85,75.53 34.85,75.83 34.91,75.89 34.94,75.92 34.97,75.95 35.08,76.06 35.08,76.75 36.1,77.76 36.35,77.76 36.43,77.84 36.43,78.34 36.43,78.36 36.52,78.49 36.54,78.62 36.54,78.68 36.52,78.75 36.52,78.78 36.58,78.83 36.58,79.4 36.68,79.5 36.68,80.16 36.47,80.37 36.47,80.8 36.46,80.81 36.46,81.39 36.79,81.72 38.26,81.72
+VCC3V3_SX_TCP1 on TOP (solid shape): 34.74,66.37 35.12,66.37 35.2,66.38 35.26,66.31 35.26,66.02 35.21,65.96 35.04,65.96 35.03,65.97 34.94,66 34.85,66.01 34.67,65.97 34.53,65.84 34.49,65.8 34.49,65.77 34.46,65.69 34.46,65.62 34.46,65.56 34.48,65.48 34.47,65.46 34.4,65.38 33.77,65.38 33.7,65.45 33.7,66.31 33.73,66.34 33.76,66.35 33.79,66.35 33.82,66.33 33.86,66.33 34.24,66.33 34.29,66.34 34.33,66.37 34.36,66.38 34.69,66.38
+VCC3V3_SX_TCP1 on TOP (solid shape): 28.58,79.55 28.73,79.55 28.73,79.54 28.78,79.53 28.86,79.49 28.92,79.41 29.06,79.3 29.23,79.31 29.5,79.28 29.59,79.04 29.58,78.99 29.59,78.95 29.4,78.75 28.46,78.75 28.34,78.87 28.21,78.97 28.04,79.01 27.83,78.94 27.68,78.77 27.53,78.62 27.24,78.62 27.19,78.67 27.18,78.7 27.2,78.74 27.2,78.77 27.2,79.15 27.21,79.21 27.25,79.23 27.34,79.23 27.5,79.39 27.52,79.39 27.61,79.43 27.65,79.52 27.65,79.54 27.74,79.63 28.5,79.63
+VCC3V3_SX_TCP1 on BOTTOM (solid shape): outline of 503 points within 35.65,74.82 51.21,82.28
+VCC3V3_SX_TCP1 on IN2 (solid shape): outline of 1274 points within 25.85,63.96 37.92,80.06
+VCC3V3_SX_TCP1 on IN4 (solid shape): outline of 1737 points within 27.78,67.17 37.98,79.9
+VCC3V3_SX_TCP1_DBRONLY on IN3 (solid shape): 34.57,75.73 34.57,75.1 34.56,75.08 34.54,75.07 34.4,74.95 34.34,74.77 34.44,74.53 34.67,74.44 34.72,74.44 34.74,74.44 34.76,74.42 34.88,74.31 34.88,73.95 34.72,73.8 34.47,73.8 34.29,73.98 34.28,74 34.28,74.03 34.29,74.08 34.3,74.13 34.2,74.36 33.97,74.46 33.92,74.45 33.87,74.44 33.84,74.44 33.82,74.45 33.73,74.54 33.73,75.53 34.03,75.82 34.48,75.82
+VCC3V3A_SX_TCP0 on BOTTOM (solid shape): outline of 83 points within 36.11,91.78 38.31,97
+VCC3V3A_SX_TCP1 on BOTTOM (solid shape): outline of 118 points within 31.55,74.51 33.68,79.41
+VCC_CORE on TOP (solid shape): 165.7,141.55 165.7,140.92 165.95,140.66 166.21,140.66 166.33,140.53 166.33,140.04 166.29,140.03 166.14,139.95 166.09,139.8 166.09,139.53 165.95,139.39 165.66,139.39 165.58,139.42 165.51,139.42 165.44,139.42 165.36,139.39 165.32,139.39 165.06,139.14 165.06,136.85 165.32,136.6 165.32,136.09 165.19,135.96 163.94,135.96 163.8,136.1 163.8,137.08 163.5,137.38 163.03,137.38 162.76,137.11 162.76,135.8 162.88,135.68 162.88,135.31 162.78,135.2 162.62,135.2 162.58,135.21 162.54,135.21 162.5,135.21 162.46,135.2 161.85,135.2 161.81,135.21 161.77,135.21 161.74,135.21 161.69,135.2 161,135.2 160.95,135.2 160.71,135.44 160.71,136.59 160.67,136.63 159.94,136.63 159.76,136.81 159.76,139.32 159.91,139.48 163.12,139.48 163.17,139.43 163.17,138.8 163.31,138.66 163.84,138.66 163.94,138.76 163.94,139.49 163.73,139.7 163.73,139.7 163.28,140.15 163.28,141.53 163.56,141.8 165.44,141.8
+VCC_CORE on TOP (solid shape): outline of 305 points within 110.93,173.82 166.55,181.06
+VCC_CORE on TOP (solid shape): outline of 4668 points within 120.61,135.33 153.51,157.47
+VCC_CORE on BOTTOM (solid shape): outline of 198 points within 149.8,148.14 153.41,150.61
+VCC_CORE on BOTTOM (solid shape): outline of 245 points within 109.73,173.83 165.69,181.06
+VCC_CORE on BOTTOM (solid shape): outline of 318 points within 160.62,135.01 166.63,141.63
+VCC_CORE on BOTTOM (solid shape): outline of 4238 points within 119.32,134.95 149.76,170.17
+VCC_CORE on IN1 (solid shape): outline of 7398 points within 117.59,135.2 166.48,179.16
+VCC_CORE on IN2 (solid shape): outline of 233 points within 117.86,173.27 165.71,179.11
+VCC_CORE on IN2 (solid shape): outline of 12117 points within 122.28,135.24 166.65,171.48
+VCC_CORE on SVCC (solid shape): outline of 2567 points within 118.62,134.96 167.26,179.92
+VCC_CORE on SVCC1 (solid shape): outline of 2584 points within 118.62,134.96 167.26,179.92
+VCC_CORE on IN3 (solid shape): outline of 8267 points within 117.61,134.82 165.65,179.33
+VCC_CORE on IN4 (solid shape): outline of 96 points within 150.18,149.42 153.25,151.17
+VCC_CORE on IN4 (solid shape): outline of 3108 points within 122.1,135.2 153.76,170.47
+VCCDPHY_1P24 on BOTTOM (solid shape): 225.07,80.46 227.31,80.46 227.54,80.23 227.54,79.71 227.42,79.6 225.03,79.6 224.66,79.96 223.82,79.96 223.56,79.7 223.56,79.66 223.53,79.63 223.53,79.19 223.36,79.01 223.36,78.85 223.21,78.7 222.84,78.7 222.66,78.87 222.66,79.7 223.8,80.84 224.7,80.84
+VCCIN_AUX on TOP (solid shape): 145.9,137.61 145.9,135.42 145.74,135.25 145.28,135.25 144.73,135.8 143.79,135.8 143.66,135.93 143.66,136.74 143.6,136.81 143.6,137.51 143.6,137.51 143.6,137.7 143.64,137.74 145.76,137.74
+VCCIN_AUX on TOP (solid shape): 166.27,216.15 166.27,214.8 166.18,214.71 166.15,214.7 166.07,214.72 166.01,214.73 165.95,214.72 165.89,214.71 165.86,214.71 165.83,214.72 165.74,214.81 164.69,214.81 164.67,214.83 164.67,216.29 164.68,216.32 164.72,216.34 166.08,216.34
+VCCIN_AUX on TOP (solid shape): 174.39,183.86 175.21,183.86 175.36,183.71 175.36,181.34 175.26,181.24 174.79,181.24 174.53,180.98 174.53,177.17 174.68,177.02 174.68,175.09 173.51,173.93 169.32,173.93 168.53,174.72 168.53,175.25 169.16,175.88 169.16,180.7 168.73,181.13 167.76,181.13 167.44,181.44 167.44,183.48 167.46,183.51 167.46,183.81 167.64,183.99 174.26,183.99
+VCCIN_AUX on TOP (solid shape): outline of 1079 points within 154.41,139.46 167.35,161.53
