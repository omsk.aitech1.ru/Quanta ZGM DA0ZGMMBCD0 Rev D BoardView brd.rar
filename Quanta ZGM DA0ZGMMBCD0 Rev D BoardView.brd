# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
PR161  *EV@100K_1%_2  [R0201]  261.62 83.91 270 top
PR162  *EV@22_5%_8  [R0805]  285.43 83.77 0 top
PR163  EV@20.5K_1%_4  [R0402]  263.4 83.53 90 top
PR164  EV@309_1%_4  [R0402]  265.81 83.53 90 top
PR165  EV@16.5K_1%_4  [R0402]  267.21 83.53 270 top
PR166  EV@4.32K_1%_4  [R0402]  268.48 83.53 90 top
PR167  EV@10K_1%_2  [R0201]  280.93 83.27 270 top
PR168  EV@10K_1%_2  [R0201]  270.39 83.15 270 top
PR169  *sEV@0_5%_2  [S0201]  254.51 82.77 270 top
PR170  *sEV@0_5%_2  [S0201]  255.65 82.77 270 top
PR171  *sEV@0_5%_2  [S0201]  256.92 82.77 270 top
PR172  *sEV@0_5%_2  [S0201]  258.07 82.77 270 top
PR173  *sEV@0_5%_2  [S0201]  259.21 82.77 270 top
PR174  *sEV@0_5%_2  [S0201]  260.35 82.77 270 top
PR175  *sEV@0_5%_2  [S0201]  261.62 82.77 270 top
PR176  EV@150K_1%_2  [R0201]  262.51 82.77 270 top
PR177  *sEV@0_5%_2  [S0201]  271.53 81.96 0 top
PR178  EV@6.19K_1%_2  [R0201]  265.43 81.88 270 top
PR179  EV@1M_5%_2  [R0201]  273.94 81.88 0 top
PR180  *EV@100K_1%_2  [R0201]  254 81.62 0 top
PR181  *sEV@0_5%_2  [S0201]  255.02 81.62 0 top
PR182  EV@100K_1%_2  [R0201]  272.8 81.37 0 top
PR183  *sEV@0_5%_2  [S0201]  265.69 80.73 0 top
PR184  EV@10K_1%_2  [R0201]  267.21 80.73 0 top
PR185  EV@2.2_5%_6  [R0603]  254.89 80.48 180 top
PR186  *sEV@0_5%_2  [S0201]  267.21 79.9 0 top
PR187  *EV@0_5%_2  [R0201]  252.73 79.85 0 top
PR188  *sEV@0_5%_2  [S0201]  265.69 79.85 0 top
PR189  EV@10K_1%_2  [R0201]  268.74 79.72 0 top
PR190  EV_SP@0_5%_2  [R0201]  256.04 79.34 180 top
PR191  EV_SP@100K_1%_2  [R0201]  254.31 79.16 180 top
PR192  EV@10K_1%_2  [R0201]  267.21 79.08 0 top
PR193  *EV@0_5%_2  [R0201]  252.75 79.04 0 top
PR194  *sEV@0_5%_2  [S0201]  268.74 78.95 0 top
PR195  *sEV@0_5%_2  [S0201]  265.69 78.7 180 top
PR196  *EV_SP@100K_1%_2  [R0201]  254.38 78.45 0 top
PR197  EV@0_5%_2  [R0201]  256.04 78.45 180 top
PR198  EV@10K_1%_2  [R0201]  267.21 78.19 0 top
PR199  *EV@0_5%_2  [R0201]  252.75 77.95 0 top
PR200  *sEV@0_5%_2  [S0201]  265.69 77.94 180 top
PR201  EV@100_1%_2  [R0201]  268.74 77.81 180 top
PR202  *EV@100K_1%_2  [R0201]  254.38 77.43 0 top
PR203  *sEV@0_5%_2  [S0201]  256.04 77.43 180 top
PR204  EV@10K_1%_2  [R0201]  267.21 77.31 0 top
PR205  *EV@0_5%_2  [R0201]  252.74 77.19 0 top
PR206  *sEV@0_5%_2  [S0201]  265.69 77.18 180 top
PR207  *sEV@0_5%_2  [S0201]  268.74 77.05 0 top
PR208  *s0_5%_8  [S0805]  132.72 76.67 270 top
PR209  *s0_5%_8  [S0805]  134.75 76.67 270 top
PR210  *EV@100K_1%_2  [R0201]  254.38 76.42 0 top
PR211  *sEV@0_5%_2  [S0201]  256.04 76.42 180 top
PR212  *sEV@0_5%_2  [S0201]  268.74 76.29 0 top
PR213  *EV@0_5%_2  [R0201]  252.74 76.1 0 top
PR214  *s0_5%_8  [S0805]  128.4 76.04 180 top
PR215  *s0_5%_8  [S0805]  148.47 75.78 270 top
PR216  *s0_5%_8  [S0805]  146.43 75.78 270 top
PR217  *s0_5%_8  [S0805]  140.72 75.78 90 top
PR218  *s0_5%_8  [S0805]  142.75 75.78 90 top
PR219  *s0_5%_8  [S0805]  54.23 75.27 90 top
PR220  *s0_5%_8  [S0805]  57.92 75.27 90 top
PR221  EV@100_1%_2  [R0201]  268.74 75.53 180 top
PR222  *EV@100K_1%_2  [R0201]  254.38 75.4 0 top
PR223  *sEV@0_5%_2  [S0201]  256.04 75.4 180 top
PR224  *EV@0_5%_2  [R0201]  252.74 75.34 0 top
PR225  *EV@100K_1%_2  [R0201]  254.38 74.38 0 top
PR226  *sEV@0_5%_2  [S0201]  256.04 74.38 180 top
PR227  *EV@0_5%_2  [R0201]  252.74 74.26 0 top
PR228  EV@2K_1%_2  [R0201]  257.18 73.5 270 top
PR229  EV@100K_1%_2  [R0201]  258.33 73.5 270 top
PR230  EV@20K_1%_2  [R0201]  259.14 73.5 90 top
PR231  EV@15K_1%_2  [R0201]  260.23 73.5 270 top
PR232  EV@20K_1%_2  [R0201]  261.12 73.5 90 top
PR233  *sEV@0_5%_2  [S0201]  263.91 73.5 90 top
PR234  EV@2.4K_1%_2  [R0201]  264.67 73.5 90 top
PR235  *EV@0_5%_2  [R0201]  252.74 73.44 0 top
PR236  *EV@100K_1%_2  [R0201]  254.38 73.37 0 top
PR237  *sEV@0_5%_2  [S0201]  256.04 73.37 0 top
PR238  EV@90.9K_1%_4  [R0402]  262 72.99 90 top
PR239  EV@10K_1%_4  [R0402]  263.02 72.99 90 top
PR240  *EV@2.4K_1%_2  [R0201]  267.26 72.99 270 top
PR241  EV@1K_1%_2  [R0201]  265.86 72.94 180 top
PR242  *sEV@0_5%_2  [S0201]  258.19 72.35 270 top
PR243  *EV@100K_1%_2  [R0201]  254.38 72.23 0 top
PR244  *sEV@0_5%_2  [S0201]  256.04 72.23 0 top
PR245  *sEV@0_5%_2  [S0201]  260.44 71.97 90 top
PR246  EV@18.7K_1%_2  [R0201]  258.96 71.97 270 top
PR247  *EV@0_5%_2  [R0201]  266.45 71.97 90 top
PR248  *EV@100K_1%_2  [R0201]  267.26 71.97 270 top
PR249  EV@18.7K_1%_2  [R0201]  261.16 71.97 270 top
PR250  EV@402_1%_4  [R0402]  257.69 71.34 0 top
PR251  *sEV@0_5%_2  [S0201]  263.78 71.21 180 top
PR252  *s0_5%_2  [S0201]  128.98 70.96 270 top
PR253  *s0_5%_2  [S0201]  131.75 70.89 90 top
PR254  *s0_5%_8  [S0805]  135.26 69.94 90 top
PR255  *s0_5%_8  [S0805]  137.29 69.94 90 top
PR256  *s0_5%_2  [S0201]  142.75 69.94 90 top
PR257  *s0_5%_2  [S0201]  145.42 69.94 90 top
PR258  *s0_5%_2  [S0201]  146.18 69.94 270 top
PR259  *s0_5%_8  [S0805]  127.64 69.81 90 top
PR260  *s0_5%_8  [S0805]  51.95 69.56 90 top
PR261  *s0_5%_2  [S0201]  132.58 69.3 0 top
PR262  *s0_5%_2  [S0201]  53.7 69.25 270 top
PR263  *s0_5%_8  [S0805]  58.55 69.05 180 top
PR264  *s0_5%_8  [S0805]  139.32 68.92 90 top
PR265  *s0_5%_8  [S0805]  141.35 68.92 90 top
PR266  *s0_5%_8  [S0805]  148.59 68.8 90 top
PR267  *s0_5%_8  [S0805]  150.63 68.8 90 top
PR268  *2.2_5%_6  [R0603]  262.21 67.06 270 top
PR269  22_5%_8  [R0805]  62.89 66.92 0 top
PR270  *220_5%_8  [R0805]  59.64 66.92 180 top
PR271  *22_5%_8  [R0805]  68.2 66.56 180 top
PR272  *s0_1%_6  [S0603]  155.22 64.48 270 top
PR273  *0_5%_6  [R0603]  156.64 64.48 270 top
PR274  *s0_1%_6  [S0603]  150.88 63.82 0 top
PR275  10K_1%_2  [R0201]  153.09 63.49 180 top
PR276  1M_5%_6  [R0603]  56.54 62.75 90 top
PR277  73.2K_1%_2  [R0201]  156.01 62.24 90 top
PR278  56.2K_1%_4  [R0402]  150.78 62.19 270 top
PR279  9.31K_1%_4  [R0402]  151.77 62.19 270 top
PR280  6.49K_1%_4  [R0402]  153.04 62.19 90 top
PR281  15.8K_1%_4  [R0402]  156.92 62.12 270 top
PR282  100K_1%_2  [R0201]  149.61 62.02 0 top
PR283  10K_1%_2  [R0201]  154.9 61.97 270 top
PR284  100K_1%_2  [R0201]  259.92 61.93 270 top
PR285  *s0_5%_2  [S0201]  260.7 61.93 270 top
PR286  1M_5%_6  [R0603]  62.89 61.58 0 top
PR287  *1M_5%_6  [R0603]  65.66 61.58 180 top
PR288  *1M_5%_6  [R0603]  68.71 61.51 180 top
PR289  *s0_5%_2  [S0201]  149.61 61.25 180 top
PR290  10K_1%_2  [R0201]  262.88 61.04 90 top
PR291  20.5K_1%_4  [R0402]  263.95 61.05 270 top
PR292  *100K_1%_6  [R0603]  58.25 60.9 270 top
PR293  10K_1%_2  [R0201]  150.5 60.67 270 top
PR294  *s0_5%_2  [S0201]  157.1 60.54 180 top
PR295  1_1%_6  [R0603]  157.48 57.62 90 top
PR296  1_1%_6  [R0603]  149.86 57.49 270 top
PR297  22_5%_8  [R0805]  59.37 57.44 180 top
PR298  *0_5%_8  [R0805]  64.54 56.63 90 top
PR299  1M_5%_6  [R0603]  120.15 55.59 90 top
PR300  *s0_1%_6  [S0603]  150.37 55.21 0 top
PR301  *0_5%_8  [R0805]  72.4 53.67 270 top
PR303  *0_5%_8  [R0805]  65.57 52.54 0 top
PR304  1M_5%_6  [R0603]  53.69 52.42 270 top
PR305  *s0_5%_4  [S0402]  70.67 51.19 90 top
PR306  *s0_5%_2  [S0201]  68.76 50.94 90 top
PR307  *4.7_5%_6  [R0603]  152.58 50.28 0 top
PR308  *4.7_5%_6  [R0603]  160.89 50.2 180 top
PR309  *22_5%_8  [R0805]  64.37 49.68 270 top
PR310  1M_5%_6  [R0603]  57.08 49.52 180 top
PR311  1M_5%_6  [R0603]  59.1 48.96 90 top
PR312  100K_1%_2  [R0201]  37.72 47.21 90 top
PR313  100K_1%_2  [R0201]  38.61 47.21 270 top
PR314  *s0_1%_6  [S0603]  60.12 46.9 0 top
PR315  137K_1%_4  [R0402]  35.54 46.45 90 top
PR316  866K_1%_4  [R0402]  34.55 46.44 90 top
PR317  *s0_5%_2  [S0201]  37.85 46.06 90 top
PR318  20_1%_6  [R0603]  42.72 46 180 top
PR319  *s0_5%_2  [S0201]  34.93 45.17 180 top
PR320  10_1%_6  [R0603]  58 45.17 270 top
PR321  2.2_5%_6  [R0603]  238.76 44.79 0 top
PR322  *s0_5%_2  [S0201]  34.8 44.03 180 top
PR323  100_5%_2  [R0201]  76.97 43.52 270 top
PR324  100_5%_2  [R0201]  73.79 43.4 270 top
PR325  *s0_5%_2  [S0201]  34.8 43.27 180 top
PR326  1M_1%_2  [R0201]  72.49 43.24 90 top
PR327  *s0_1%_6  [S0603]  42.93 43.02 90 top
PR328  *22.6K_1%_4  [R0402]  33.2 42.74 270 top
PR329  *0_5%_4  [R0402]  71.38 42.51 270 top
PR330  10K_1%_2  [R0201]  28.58 42.15 270 top
PR331  *s0_5%_2  [S0201]  29.34 42.15 90 top
PR332  100_5%_2  [R0201]  72.49 42.13 90 top
PR333  *s0_5%_2  [S0201]  34.67 42 180 top
PR334  *s0_5%_2  [S0201]  34.67 41.24 180 top
PR335  *0_5%_2  [R0201]  28.58 41.01 90 top
PR336  10K_1%_2  [R0201]  29.34 41.01 90 top
PR337  100K_1%_2  [R0201]  34.67 40.48 180 top
PR338  100K_1%_2  [R0201]  29.21 40.12 180 top
PR339  *4.7_5%_6  [R0603]  129.43 39.85 90 top
PR340  *s0_5%_2  [S0201]  36.41 39.47 90 top
PR341  10K_1%_2  [R0201]  37.13 39.46 90 top
PR342  10K_1%_2  [R0201]  35.69 39.46 90 top
PR343  *0_5%_4  [R0402]  33.65 39.25 90 top
PR344  *102K_1%_4  [R0402]  34.67 39.25 270 top
PR345  *4.7_5%_6  [R0603]  50.55 38.82 180 top
PR346  *2.2_5%_6  [R0603]  236.22 38.06 270 top
PR347  *10K_1%_4  [R0402]  242.09 37.9 270 top
PR348  10K_1%_2  [R0201]  240.66 37.88 180 top
PR349  2.2_5%_6  [R0603]  238.38 37.43 0 top
PR350  *s0_5%_2  [S0201]  118.75 216.75 0 bottom
PR351  EV@402K_1%_4  [R0402]  251.66 216.61 270 bottom
PR352  EV@1_5%_6  [R0603]  254.22 216.52 270 bottom
PR353  20K_1%_4  [R0402]  123.45 216.12 270 bottom
PR354  EV@21K_1%_2  [R0201]  249.54 216.02 90 bottom
PR355  2_1%_6  [R0603]  115.46 215.85 270 bottom
PR356  100_1%_2  [R0201]  125.31 215.79 270 bottom
PR357  100_1%_2  [R0201]  117.98 215.77 270 bottom
PR358  *75_1%_2  [R0201]  118.74 215.77 270 bottom
PR359  45.3_1%_2  [R0201]  119.5 215.77 270 bottom
PR360  *10K_1%_2  [R0201]  120.27 215.77 90 bottom
PR361  10K_1%_2  [R0201]  121.03 215.77 270 bottom
PR362  *0_5%_2  [R0201]  121.8 215.77 270 bottom
PR363  *s0_5%_2  [S0201]  122.56 215.77 270 bottom
PR364  1.5K_1%_4  [R0402]  126.62 215.61 0 bottom
PR365  EV@82.5K_1%_4  [R0402]  248.46 215.38 270 bottom
PR366  EV@0_5%_2  [R0201]  249.43 215.16 180 bottom
PR367  *sEV@0_5%_2  [S0201]  252.94 214.53 270 bottom
PR368  *EV@10K_1%_2  [R0201]  230.12 214.42 270 bottom
PR369  EV@10K_1%_2  [R0201]  249.58 214.42 0 bottom
PR370  *s0_5%_2  [S0201]  119.94 214.41 270 bottom
PR371  *s0_5%_2  [S0201]  118.49 214.4 270 bottom
PR372  *s0_5%_2  [S0201]  119.21 214.4 270 bottom
PR373  *s0_5%_2  [S0201]  120.66 214.4 270 bottom
PR374  *s0_5%_2  [S0201]  121.5 214.4 270 bottom
PR375  118K_1%_2  [R0201]  117.78 214.4 90 bottom
PR376  1K_5%_4  [R0402]  115.31 213.95 180 bottom
PR377  *EV@10K_1%_2  [R0201]  246.52 213.79 0 bottom
PR378  *10K_5%_2  [R0201]  126.55 213.66 0 bottom
PR379  *EV@0_5%_2  [R0201]  247.52 213.42 180 bottom
PR380  *EV@12K_1%_2  [R0201]  246.52 213.07 0 bottom
PR381  26.1K_1%_4  [R0402]  126.88 212.79 180 bottom
PR382  *sEV@0_5%_2  [S0201]  246.51 212.35 180 bottom
PR383  EV@10K_1%_2  [R0201]  254.42 212.34 0 bottom
PR384  EV@49.9K_1%_2  [R0201]  252.75 212.21 0 bottom
PR385  26.1K_1%_4  [R0402]  115.31 212.02 0 bottom
PR386  *EV@30.1K_1%_2  [R0201]  227.6 212 180 bottom
PR387  49.9_1%_4  [R0402]  126.88 211.8 0 bottom
PR388  *sEV@0_5%_2  [S0201]  254.42 211.61 0 bottom
PR389  110K_1%_4  [R0402]  115.31 211.04 0 bottom
PR390  3.3K_1%_4  [R0402]  126.88 210.78 0 bottom
PR391  1K_1%_4  [R0402]  124.83 210.64 0 bottom
PR392  *sEV@0_1%_6  [S0603]  254.36 209.89 90 bottom
PR393  61.9K_1%_4  [R0402]  115.21 209.35 0 bottom
PR394  *sEV@0_1%_6  [S0603]  244.84 209.21 45 bottom
PR395  30.1K_1%_2  [R0201]  124.34 208.62 90 bottom
PR396  *s0_5%_4  [S0402]  115.21 208.39 180 bottom
PR397  133K_1%_4  [R0402]  127.1 208.25 270 bottom
PR398  75K_1%_4  [R0402]  128.06 208.25 270 bottom
PR399  *sEV@0_5%_2  [S0201]  229.23 207.96 0 bottom
PR400  *sEV@0_5%_2  [S0201]  226.66 207.83 90 bottom
PR401  1M_5%_2  [R0201]  195.51 207.02 90 bottom
PR402  EV@1_5%_6  [R0603]  250.37 206.15 0 bottom
PR403  64.9K_1%_4  [R0402]  123.19 205.96 270 bottom
PR404  64.9K_1%_4  [R0402]  124.21 205.96 270 bottom
PR405  64.9K_1%_4  [R0402]  125.35 205.96 270 bottom
PR406  64.9K_1%_4  [R0402]  126.5 205.96 270 bottom
PR407  64.9K_1%_4  [R0402]  127.64 205.96 270 bottom
PR408  64.9K_1%_4  [R0402]  128.78 205.96 270 bottom
PR409  1M_5%_2  [R0201]  195.58 205.93 270 bottom
PR410  200K_5%_2  [R0201]  200.33 205.3 90 bottom
PR411  *sG3@0_5%_4  [S0402]  229.96 204.96 270 bottom
PR412  *s0_5%_4  [S0402]  194.44 204.89 270 bottom
PR413  *sG3@0_5%_4  [S0402]  230.94 204.51 270 bottom
PR414  5.11K_1%_4  [R0402]  115.09 203.9 270 bottom
PR415  5.11K_1%_4  [R0402]  115.47 201.87 270 bottom
PR416  5.11K_1%_4  [R0402]  117.06 201.82 180 bottom
PR417  5.11K_1%_4  [R0402]  118.42 201.34 90 bottom
PR418  5.11K_1%_4  [R0402]  119.48 201.34 90 bottom
PR419  5.11K_1%_4  [R0402]  121.11 201.68 180 bottom
PR420  10_1%_4  [R0402]  122.26 203.93 270 bottom
PR421  10_1%_4  [R0402]  123.23 203.93 270 bottom
PR422  10_1%_4  [R0402]  124.21 203.92 270 bottom
PR423  10_1%_4  [R0402]  125.35 203.92 270 bottom
PR424  10_1%_4  [R0402]  126.5 203.92 270 bottom
PR425  10_1%_4  [R0402]  127.64 203.92 270 bottom
PR426  1M_5%_2  [R0201]  195.3 203.75 270 bottom
PR427  G3@100K_1%_2  [R0201]  228.63 203.61 180 bottom
PR428  1M_5%_2  [R0201]  194.44 203.59 180 bottom
PR429  *EV@2.2_5%_6  [R0603]  266.54 203.11 0 bottom
PR430  4.7_5%_6  [R0603]  114.73 199.56 270 bottom
PR431  4.7_5%_6  [R0603]  124.18 199.84 270 bottom
PR432  4.7_5%_6  [R0603]  162.79 199.58 270 bottom
PR433  4.7_5%_6  [R0603]  133.81 199.66 270 bottom
PR434  4.7_5%_6  [R0603]  143.69 199.66 270 bottom
PR435  *s0_5%_2  [S0201]  232.02 199.48 180 bottom
PR436  4.7_5%_6  [R0603]  153.14 199.48 270 bottom
PR437  EV@0.005_1%_2037  [RC2037-SMT]  229.04 199.12 90 bottom
PR438  2.2_1%_4  [R0402]  112.14 198.97 270 bottom
PR439  2.2_1%_4  [R0402]  121.8 198.97 270 bottom
PR440  2.2_1%_4  [R0402]  131.45 198.97 270 bottom
PR441  2.2_1%_4  [R0402]  141.1 198.97 270 bottom
PR442  2.2_1%_4  [R0402]  160.4 198.97 270 bottom
PR443  2.2_1%_4  [R0402]  150.92 198.96 270 bottom
PR444  *s0_5%_2  [S0201]  232.02 198.72 180 bottom
PR445  *s0_5%_2  [S0201]  110.24 198.59 270 bottom
PR446  *s0_5%_2  [S0201]  111.13 198.59 270 bottom
PR447  *s0_5%_2  [S0201]  119.89 198.59 270 bottom
PR448  *s0_5%_2  [S0201]  120.78 198.59 270 bottom
PR449  *s0_5%_2  [S0201]  129.54 198.59 270 bottom
PR450  *s0_5%_2  [S0201]  130.43 198.59 270 bottom
PR451  *s0_5%_2  [S0201]  139.2 198.59 270 bottom
PR452  *s0_5%_2  [S0201]  140.08 198.59 270 bottom
PR453  *s0_5%_2  [S0201]  158.5 198.59 270 bottom
PR454  *s0_5%_2  [S0201]  159.39 198.59 270 bottom
PR455  *s0_5%_2  [S0201]  148.96 198.27 270 bottom
PR456  *s0_5%_2  [S0201]  149.84 198.27 270 bottom
PR457  G3@100K_1%_2  [R0201]  219.28 197.53 90 bottom
PR458  *s0_5%_2  [S0201]  110.3 196.81 0 bottom
PR459  *s0_5%_2  [S0201]  119.76 196.81 0 bottom
PR460  *s0_5%_2  [S0201]  129.42 196.81 0 bottom
PR461  *s0_5%_2  [S0201]  139.07 196.81 0 bottom
PR462  *s0_5%_2  [S0201]  148.72 196.81 0 bottom
PR463  *s0_5%_2  [S0201]  158.37 196.81 0 bottom
PR464  G3@100K_1%_2  [R0201]  202.97 196.57 90 bottom
PR465  *sG3@0_5%_4  [S0402]  214.94 196.12 180 bottom
PR466  G3@100K_1%_2  [R0201]  217.75 196.09 0 bottom
PR467  100K_1%_2  [R0201]  184.61 195.8 0 bottom
PR468  *s0_5%_4  [S0402]  177.98 195.67 90 bottom
PR469  100K_1%_2  [R0201]  179 195.67 270 bottom
PR470  4.02K_1%_4  [R0402]  182.12 195.09 90 bottom
PR471  *sG3@0_5%_4  [S0402]  214.99 194.7 270 bottom
PR472  *sG3@0_5%_4  [S0402]  200.65 194.7 270 bottom
PR473  G3@100K_1%_2  [R0201]  205.58 194.64 0 bottom
PR474  0.005_1%_2512  [RC2512]  225.68 194.55 0 bottom
PR475  *sG3@0_5%_4  [S0402]  198.5 193.89 270 bottom
PR476  *sG3@0_5%_4  [S0402]  199.53 193.86 270 bottom
PR477  *2.2_5%_6  [R0603]  174.7 193.76 0 bottom
PR478  G3@200K_5%_2  [R0201]  205.6 193.32 180 bottom
PR479  *s0_5%_2  [S0201]  226.12 191.77 270 bottom
PR480  *s0_5%_2  [S0201]  225.38 191.77 270 bottom
PR481  100K_NTC_4_1%  [R0402]  110.47 191.45 90 bottom
PR482  100K_NTC_4_1%  [R0402]  109.49 191.44 270 bottom
PR483  *Short_0201  [S0201]  171.28 190.73 270 bottom
PR484  *Short_0201  [S0201]  171.37 188.2 90 bottom
PR485  4.02K_1%_4  [R0402]  182.53 187.77 0 bottom
PR486  0.005_1%_2512  [RC2512]  180.34 184.75 0 bottom
PR487  G2@0.005_1%_2512  [RC2512]  188.6 184.75 180 bottom
PR488  *Short_0201  [S0201]  113.92 183.73 90 bottom
PR489  *Short_0201  [S0201]  123.57 183.73 90 bottom
PR490  *Short_0201  [S0201]  133.23 183.73 90 bottom
PR491  *Short_0201  [S0201]  142.88 183.73 90 bottom
PR492  *Short_0201  [S0201]  152.53 183.73 90 bottom
PR493  *Short_0201  [S0201]  162.18 183.73 90 bottom
PR494  *Short_0201  [S0201]  113.92 182.59 90 bottom
PR495  *Short_0201  [S0201]  123.57 182.59 270 bottom
PR496  *Short_0201  [S0201]  133.23 182.59 270 bottom
PR497  *Short_0201  [S0201]  142.88 182.59 270 bottom
PR498  *Short_0201  [S0201]  152.53 182.59 270 bottom
PR499  *Short_0201  [S0201]  162.18 182.59 270 bottom
PR500  *s0_5%_2  [S0201]  179.45 182.06 0 bottom
PR501  *s0_5%_2  [S0201]  181.23 182.06 180 bottom
PR502  *sG3@0_5%_4  [S0402]  178.67 180.43 180 bottom
PR503  *sG3@0_5%_4  [S0402]  177.14 180.18 90 bottom
PR504  *sG3@0_5%_4  [S0402]  178.67 178.4 0 bottom
PR505  G3@200K_5%_2  [R0201]  185.25 175.38 90 bottom
PR506  G3@100K_1%_2  [R0201]  186.24 175.38 270 bottom
PR507  *G3@0_5%_4  [R0402]  187.23 175.38 270 bottom
PR508  *sG3@0_5%_4  [S0402]  188.24 175.38 90 bottom
PR509  G3@200K_5%_2  [R0201]  189.18 175.38 90 bottom
PR510  G3@47K_1%_2  [R0201]  190.17 175.38 270 bottom
PR511  20.5K_1%_4  [R0402]  108.33 135.47 180 bottom
PR512  *s0_5%_2  [S0201]  109.73 135.47 90 bottom
PR513  10K_5%_2  [R0201]  108.59 128.74 180 bottom
PR514  *EV@10K_1%_2  [R0201]  291.06 122.63 180 bottom
PR515  *EV@10K_1%_2  [R0201]  289.74 122.14 90 bottom
PR516  EV@10K_1%_2  [R0201]  291.09 121.3 0 bottom
PR517  *5G@2.2_5%_6  [R0603]  299.3 104.28 270 bottom
PR518  EV@1M_5%_2  [R0201]  203.1 106.19 180 bottom
PR519  *Short_0201  [S0201]  277.73 105.75 90 bottom
PR520  *Short_0201  [S0201]  287.25 105.75 90 bottom
PR521  *Short_0201  [S0201]  230.1 105.63 90 bottom
PR522  *Short_0201  [S0201]  239.63 105.63 90 bottom
PR523  *Short_0201  [S0201]  249.15 105.63 90 bottom
PR524  *Short_0201  [S0201]  258.68 105.63 90 bottom
PR525  *Short_0201  [S0201]  268.46 105.63 90 bottom
PR526  EV@100K_1%_2  [R0201]  203.1 105.46 0 bottom
PR527  *Short_0201  [S0201]  220.55 105.4 90 bottom
PR528  *s0_1%_6  [S0603]  206.38 105.37 270 bottom
PR529  *s0_1%_6  [S0603]  204.95 105.38 270 bottom
PR530  EV@47_1%_2  [R0201]  200.18 105.3 90 bottom
PR531  *5G@10K_1%_2  [R0201]  295.49 104.61 180 bottom
PR532  5G@10K_1%_4  [R0402]  295.27 103.96 0 top
PR533  *Short_0201  [S0201]  294.35 102.76 270 bottom
PR534  *sEV@0_5%_2  [S0201]  203.56 102.16 90 bottom
PR535  EV@10K_1%_2  [R0201]  203.56 101.14 270 bottom
PR536  *s0_1%_6  [S0603]  198.25 100.93 0 bottom
PR537  5G@1_1%_6  [R0603]  300.28 100.61 90 bottom
PR538  *s0_1%_6  [S0603]  198.25 99.4 0 bottom
PR539  *s0_5%_2  [S0201]  196.35 95.97 270 bottom
PR540  *0_5%_2  [R0201]  197.11 95.97 270 bottom
PR541  EV@2.2_5%_6  [R0603]  283.45 95.94 0 bottom
PR542  G3@2.2_5%_6  [R0603]  293.37 95.97 0 bottom
PR543  EV@2.2_5%_6  [R0603]  224.74 95.75 0 bottom
PR544  EV@2.2_5%_6  [R0603]  234.5 95.83 0 bottom
PR545  EV@2.2_5%_6  [R0603]  244.35 95.75 0 bottom
PR546  EV@2.2_5%_6  [R0603]  253.89 95.7 0 bottom
PR547  EV@2.2_5%_6  [R0603]  263.65 95.68 0 bottom
PR548  EV@2.2_5%_6  [R0603]  273.43 95.7 0 bottom
PR549  *s0_5%_2  [S0201]  197.11 94.7 270 bottom
PR550  G3@2_1%_4  [R0402]  285.63 91.35 90 bottom
PR551  EV@2_1%_4  [R0402]  275.72 91.35 90 bottom
PR552  EV@2_1%_4  [R0402]  216.92 90.26 90 bottom
PR553  EV@2_1%_4  [R0402]  226.7 90.26 90 bottom
PR554  EV@2_1%_4  [R0402]  236.48 90.26 90 bottom
PR555  EV@2_1%_4  [R0402]  246.26 90.26 90 bottom
PR556  EV@2_1%_4  [R0402]  256.04 90.26 90 bottom
PR557  EV@2_1%_4  [R0402]  265.81 90.26 90 bottom
PR558  G3@100K_1%_2  [R0201]  293.04 88.97 180 bottom
PR559  EV@100K_1%_2  [R0201]  283.47 88.43 180 bottom
PR560  EV@100K_1%_2  [R0201]  244.1 88.23 180 bottom
PR561  EV@100K_1%_2  [R0201]  253.62 88.23 180 bottom
PR562  EV@100K_1%_2  [R0201]  273.31 88.23 180 bottom
PR563  EV@100K_1%_2  [R0201]  224.41 88.18 180 bottom
PR564  EV@100K_1%_2  [R0201]  234.19 88.18 180 bottom
PR565  EV@100K_1%_2  [R0201]  263.53 88.18 180 bottom
PR566  *s0_1%_6  [S0603]  201.55 87.72 0 bottom
PR567  G3@2.2_1%_6  [R0603]  291.79 87.38 180 bottom
PR568  47.5K_1%_4  [R0402]  198 87.34 0 bottom
PR569  EV@2.2_1%_6  [R0603]  280.17 87.34 180 bottom
PR570  *sG3@0_5%_2  [S0201]  285.63 87.29 90 bottom
PR571  *s0_5%_2  [S0201]  199.39 87.21 180 bottom
PR572  *sEV@0_5%_2  [S0201]  275.72 87.21 90 bottom
PR573  *EV@30K_1%_2  [R0201]  276.48 87.21 90 bottom
PR574  *sEV@0_5%_2  [S0201]  277.24 87.21 90 bottom
PR575  *sEV@0_5%_2  [S0201]  278.01 87.21 90 bottom
PR576  *G3@30K_1%_2  [R0201]  286.39 87.21 90 bottom
PR577  *sG3@0_5%_2  [S0201]  287.15 87.21 90 bottom
PR578  *sG3@0_5%_2  [S0201]  287.91 87.21 90 bottom
PR579  *sEV@0_5%_2  [S0201]  217.05 87.08 270 bottom
PR580  *EV@30K_1%_2  [R0201]  217.81 87.08 90 bottom
PR581  *sEV@0_5%_2  [S0201]  218.57 87.08 270 bottom
PR582  *sEV@0_5%_2  [S0201]  219.33 87.08 270 bottom
PR583  EV@2.2_1%_6  [R0603]  221.11 87.08 180 bottom
PR584  *sEV@0_5%_2  [S0201]  226.83 87.08 270 bottom
PR585  *EV@30K_1%_2  [R0201]  227.59 87.08 90 bottom
PR586  *sEV@0_5%_2  [S0201]  228.35 87.08 270 bottom
PR587  *sEV@0_5%_2  [S0201]  229.11 87.08 270 bottom
PR588  EV@2.2_1%_6  [R0603]  230.89 87.08 180 bottom
PR589  *sEV@0_5%_2  [S0201]  236.6 87.08 270 bottom
PR590  *EV@30K_1%_2  [R0201]  237.37 87.08 90 bottom
PR591  *sEV@0_5%_2  [S0201]  238.13 87.08 270 bottom
PR592  *sEV@0_5%_2  [S0201]  238.89 87.08 270 bottom
PR593  EV@2.2_1%_6  [R0603]  240.67 87.08 180 bottom
PR594  *sEV@0_5%_2  [S0201]  246.38 87.08 270 bottom
PR595  *EV@30K_1%_2  [R0201]  247.15 87.08 90 bottom
PR596  *sEV@0_5%_2  [S0201]  247.91 87.08 270 bottom
PR597  *sEV@0_5%_2  [S0201]  248.67 87.08 270 bottom
PR598  EV@2.2_1%_6  [R0603]  250.45 87.08 180 bottom
PR599  *sEV@0_5%_2  [S0201]  256.16 87.08 270 bottom
PR600  *EV@30K_1%_2  [R0201]  256.92 87.08 90 bottom
PR601  *sEV@0_5%_2  [S0201]  257.69 87.08 270 bottom
PR602  *sEV@0_5%_2  [S0201]  258.45 87.08 270 bottom
PR603  EV@2.2_1%_6  [R0603]  260.23 87.08 180 bottom
PR604  *sEV@0_5%_2  [S0201]  265.94 87.08 270 bottom
PR605  *EV@30K_1%_2  [R0201]  266.7 87.08 90 bottom
PR606  *sEV@0_5%_2  [S0201]  267.47 87.08 270 bottom
PR607  *sEV@0_5%_2  [S0201]  268.23 87.08 270 bottom
PR608  EV@2.2_1%_6  [R0603]  270.01 87.08 180 bottom
PR609  100K_1%_2  [R0201]  200.54 86.58 180 bottom
PR610  *s0_5%_2  [S0201]  198.76 86.32 0 bottom
PR611  15K_1%_4  [R0402]  197.21 85.97 90 bottom
PR612  *sEV@0_5%_2  [S0201]  262.78 73.24 180 bottom
PR613  *s0_5%_4  [S0402]  57.2 69.38 0 bottom
PR614  22_5%_8  [R0805]  252.91 64.3 0 bottom
PR615  10_5%_6  [R0603]  265.05 64.29 90 bottom
PR616  *s0_5%_2  [S0201]  255.32 62.98 0 bottom
PR617  *s0_5%_2  [S0201]  261.53 61.65 270 bottom
PR618  *0_5%_2  [R0201]  260.66 60.62 270 bottom
PR619  *s0_5%_2  [S0201]  261.55 60.62 270 bottom
PR620  *0_5%_8  [R0805]  65.19 57.23 180 bottom
PR621  *s0_5%_2  [S0201]  127.16 52.52 180 bottom
PR622  *s0_5%_2  [S0201]  56.36 50.56 270 bottom
PR623  *s0_5%_2  [S0201]  57.1 50.55 270 bottom
PR624  *s0_5%_4  [S0402]  113.9 50.26 180 bottom
PR625  196K_1%_4  [R0402]  116.61 49.21 90 bottom
PR626  *s0_5%_2  [S0201]  113.95 48.83 90 bottom
PR627  *0_5%_2  [R0201]  114.71 48.83 270 bottom
PR628  100K_1%_2  [R0201]  113.06 48.73 0 bottom
PR629  *s0_5%_2  [S0201]  136.77 47.23 0 bottom
PR630  *s0_5%_2  [S0201]  113.06 47.82 180 bottom
PR631  0.005_1%_2037  [RC2037-SMT]  56.68 47.65 0 bottom
PR632  *s0_5%_2  [S0201]  111.86 46.83 0 bottom
PR633  *s0_5%_2  [S0201]  173.13 46.7 270 bottom
PR634  *s0_5%_2  [S0201]  171.05 46.62 270 bottom
PR635  499K_1%_4  [R0402]  113.06 46.55 90 bottom
PR636  100_1%_2  [R0201]  243.46 46.32 90 bottom
PR637  2.2_5%_6  [R0603]  120.04 46.29 90 bottom
PR638  100_1%_2  [R0201]  242.04 46.22 180 bottom
PR639  *0_5%_2  [R0201]  111.86 46.06 0 bottom
PR640  249K_1%_4  [R0402]  239.53 45.68 90 bottom
PR641  *150K_1%_4  [R0402]  240.54 45.68 90 bottom
PR642  5.1_5%_4  [R0402]  245.37 45.68 90 bottom
PR643  100K_1%_2  [R0201]  29.59 45.45 270 bottom
PR644  *s0_5%_2  [S0201]  241.43 45.3 270 bottom
PR645  *s0_5%_2  [S0201]  242.19 45.3 90 bottom
PR646  *s0_5%_2  [S0201]  243.46 45.3 90 bottom
PR647  *0_5%_2  [R0201]  113.06 45.02 180 bottom
PR648  *s0_5%_2  [S0201]  29.59 44.31 270 bottom
PR649  *0_5%_2  [R0201]  111.81 43.35 90 bottom
PR650  8.2K_1%_2  [R0201]  113.57 43.33 0 bottom
PR651  *s0_5%_2  [S0201]  111.03 42.36 90 bottom
PR652  100_5%_2  [R0201]  114.96 42.36 90 bottom
PR653  *s0_5%_2  [S0201]  116.69 42.33 270 bottom
PR654  10K_1%_2  [R0201]  113.06 41.97 90 bottom
PR655  316K_1%_4  [R0402]  41.09 39.69 90 bottom
PR656  100K_1%_2  [R0201]  41.96 39.58 270 bottom
PR657  *0_5%_2  [R0201]  36.41 39.47 90 bottom
PR658  *s0_5%_2  [S0201]  243.49 37.96 90 bottom
PR659  *s0_5%_2  [S0201]  244.25 37.96 90 bottom
PR660  *s0_5%_2  [S0201]  240.04 37.94 90 bottom
PR661  *s0_5%_2  [S0201]  240.78 37.93 90 bottom
PR662  90.9K_1%_2  [R0201]  242.61 37.6 90 bottom
PR663  *100K_1%_2  [R0201]  245.3 36.96 270 bottom
PR664  *100K_1%_2  [R0201]  246.04 36.96 90 bottom
PR665  *100K_1%_2  [R0201]  243.49 36.94 90 bottom
PR666  *100K_1%_2  [R0201]  244.25 36.94 270 bottom
PR667  *s0_5%_2  [S0201]  260.08 60.28 180 top
PR668  *0_5%_2  [R0201]  260.06 59.53 0 top
PR669  5G@1M_5%_6  [R0603]  296.61 95.04 180 bottom
PR670  5G@22_5%_8  [R0805]  295.68 107.68 0 top
PR671  5G@1M_5%_6  [R0603]  296.6 96.51 180 bottom
PR6036  *100K_1%_4  [R0402]  121.05 203.9 90 bottom
PR6037  *100K_1%_4  [R0402]  119.66 203.98 90 bottom
PR6038  *100K_1%_4  [R0402]  118.54 203.9 90 bottom
PR6039  *100K_1%_4  [R0402]  117.32 203.9 90 bottom
PR6040  *100K_1%_4  [R0402]  116.06 203.9 90 bottom
PR6041  *100K_1%_4  [R0402]  114.13 203.9 90 bottom
PU1  G3@AS393MTR-G1  [SOIC8-6-1_27-24AA02]  138.81 213.02 90 top
PU2  EV@NCP45495  [QFN32-4X4-4-33P-NCP45495]  229.39 211.98 0 top
PU3  MC74VHC1G08DFT2G  [SOT353-1-2_125-65-5P]  125.2 211.57 270 top
PU4  NCP81269MNTXG  [QFN20-3X3-4-21P-1_05H]  164.94 207.36 180 top
PU5  G3@NA199B1DCKR  [SC70-2_1-65-6P-SN74AVC1T45]  229.77 188.73 180 top
PU6  G3@INA199B1DCKR  [SC70-2_1-65-6P-SN74AVC1T45]  225.57 188.71 180 top
PU7  EV@SY8386RHC  [QFN16-2_5X2_5-45-17P]  288.6 122.08 270 top
PU8  5G@SY8386RHC  [QFN16-2_5X2_5-45-17P]  298.34 103.78 90 top
PU9  SYV269CQFC  [QFN32-4X4-4-33P-SY9329C]  92.59 89.75 270 top
PU10  EV@UP9512PQGJ  [QFN40-5X5-4-41P-UP9511]  260.99 78.19 180 top
PU11  JW7110DFNC_TRPBF  [DFN14-3X2-4-15P-0_85H]  131.21 73.23 0 top
PU12  JW7110DFNC_TRPBF  [DFN14-3X2-4-15P-0_85H]  144.93 72.34 0 top
PU13  JW7110DFNC_TRPBF  [DFN14-3X2-4-15P-0_85H]  55.9 71.81 0 top
PU14  G2823DRE1U  [DFN10-3X3-5-11P-G5318]  263.68 63.98 270 top
PU15  TPS51225RUKR  [QFN20-3X3-4-26P]  153.8 58.64 180 top
PU16  M74VHC1GT08DFT2G  [SOT353-2_1-65-5P]  261.98 57.87 270 top
PU17  JW7110DFNC_TRPBF  [DFN14-3X2-4-15P-0_85H]  68.9 53.84 0 top
PU18  BQ24780SRUYR  [QFN28-4X4-4-29P-BQ24780RUYR]  38.36 42.76 180 top
PU19  EV@RT8816BGQW  [QFN20-3X3-4-21P-RT6543B]  249.82 211.76 90 bottom
PU20  NCP81305MNTXG  [QFN40-5X5-4-41P-NCP81610]  120.15 210.53 270 bottom
PU21  NCP302155MNTWG  [QFN33-5X5-5-19P]  113.92 194.65 0 bottom
PU22  NCP302155MNTWG  [QFN33-5X5-5-19P]  123.57 194.65 0 bottom
PU23  NCP302155MNTWG  [QFN33-5X5-5-19P]  133.23 194.65 0 bottom
PU24  NCP302155MNTWG  [QFN33-5X5-5-19P]  142.88 194.65 0 bottom
PU25  NCP302155MNTWG  [QFN33-5X5-5-19P]  152.53 194.65 0 bottom
PU26  NCP302155MNTWG  [QFN33-5X5-5-19P]  162.18 194.65 0 bottom
PU27  G708T1U  [SOT23-5-2_8-95-5P-G708]  108.72 132.55 90 bottom
PU28  EV@G9336ADJTP1U  [TSOT23-6-2_8-95-6P-1H]  200.86 103.15 0 bottom
PU29  EV@QD9619AQR1  [QFN39-6X5-45-21P-1H]  279.53 91.91 90 bottom
PU30  G3@QD9619AQR1  [QFN39-6X5-45-21P-1H]  289.44 91.91 90 bottom
PU31  EV@QD9619AQR1  [QFN39-6X5-45-21P-1H]  220.6 91.66 90 bottom
PU32  EV@QD9619AQR1  [QFN39-6X5-45-21P-1H]  230.38 91.66 90 bottom
PU33  EV@QD9619AQR1  [QFN39-6X5-45-21P-1H]  240.16 91.66 90 bottom
PU34  EV@QD9619AQR1  [QFN39-6X5-45-21P-1H]  249.94 91.66 90 bottom
PU35  EV@QD9619AQR1  [QFN39-6X5-45-21P-1H]  259.72 91.66 90 bottom
PU36  EV@QD9619AQR1  [QFN39-6X5-45-21P-1H]  269.5 91.66 90 bottom
PU37  G5719CTB1U  [SOT23-6-2_8-95-6P-G5126TB1U]  198.44 90.4 90 bottom
PU38  RT8231BGQW  [QFN20-3X3-4-21P-RT6543B]  116.23 45.58 180 bottom
PU39  MP2941GL-Z  [QFN19-4X3-4]  242.4 41.57 270 bottom
Q1  *BSS84DW  [SOT363-2_1-65-6P]  168.53 218.28 180 top
Q2  *2N7002KDW  [SOT363-2_1-65-6P]  248.18 218.15 0 top
Q3  *BSS84DW  [SOT363-2_1-65-6P]  225.76 217.98 0 top
Q4  *2N7002K  [SOT23-2-95-3P]  252.55 215.57 270 top
Q5  *BSS84  [SOT23-2-95-3P]  249.03 214.02 270 top
Q6  PJA138K  [SOT23-2-95-3P]  279.34 209.44 270 top
Q7  *2N7002KTB  [SOT23-1_38-5-3P]  223.52 209.27 270 top
Q8  G3@2N7002KTB  [SOT23-1_38-5-3P]  139.34 209.2 0 top
Q9  2N7002K  [SOT23-2-95-3P]  152.78 205.96 0 top
Q10  PJX138K  [SOT563-1_6-5-6P-PJX138K]  140.74 205.85 270 top
Q11  METR3904-G  [SOT23-2-95-3P]  178.29 204.74 180 top
Q12  *EV@DDTC144EUA-7-F  [SOT23-1_7-65-3P]  217.95 189.6 270 top
Q13  *EV@EV@2N7002KW  [SOT23-1_7-65-3P]  220.6 189.4 90 top
Q14  2N7002K  [SOT23-2-95-3P]  208.15 185.53 0 top
Q15  METR3904-G  [SOT23-2-95-3P]  208.79 181.95 0 top
Q16  METR3904-G  [SOT23-2-95-3P]  111.64 121.37 90 top
Q17  2N7002KTB  [SOT23-1_38-5-3P]  111.38 118.33 90 top
Q18  DMP2130L-7  [SOT23-2-95-3P]  304.55 99.15 180 top
Q19  *METR3904-G  [SOT23-2-95-3P]  155.97 95.82 180 top
Q20  *2N7002KDW  [SOT363-2_1-65-6P]  68.58 92.67 0 top
Q21  *PJE8406  [SOT23-1_38-5-3P]  73.41 90.01 0 top
Q22  *2N7002KTB  [SOT23-1_38-5-3P]  69.47 88.99 90 top
Q23  *PJA138K  [SOT23-2-95-3P]  306.25 88.43 90 top
Q24  *PJE8406  [SOT23-1_38-5-3P]  73.41 87.72 180 top
Q25  2N7002KTB  [SOT23-1_38-5-3P]  69.6 86.45 90 top
Q26  5G@PJE8406  [SOT23-1_38-5-3P]  300.93 85.52 270 top
Q27  5G@2N7002KTB  [SOT23-1_38-5-3P]  310.66 84.15 270 top
Q28  PJA138K  [SOT23-2-95-3P]  221.24 84.01 270 top
Q29  2N7002KDW  [SOT363-2_1-65-6P]  68.71 83.91 0 top
Q30  *PJA138K  [SOT23-2-95-3P]  215.66 83.6 270 top
Q31  *2N7002K  [SOT23-2-95-3P]  290.33 82.64 0 top
Q32  PJA138K  [SOT23-2-95-3P]  224.41 79.67 180 top
Q33  *METR3904-G  [SOT23-2-95-3P]  153.42 79.21 0 top
Q34  2N7002KDW  [SOT363-2_1-65-6P]  300.82 79.13 90 top
Q35  METR3904-G  [SOT23-2-95-3P]  287.28 78.32 180 top
Q36  2N7002K  [SOT23-2-95-3P]  297.29 78.19 90 top
Q37  *SUB@PJX138K  [SOT563-1_6-5-6P-PJX138K]  294.03 75.77 270 top
Q38  2N7002KTB  [SOT23-1_38-5-3P]  284.61 75.31 180 top
Q39  PJX138K  [SOT563-1_6-5-6P-PJX138K]  157.71 74.11 0 top
Q40  PJX138K  [SOT563-1_6-5-6P-PJX138K]  319.36 74.1 180 top
Q41  DMP2130L-7  [SOT23-2-95-3P]  271.15 73.96 180 top
Q42  METR3904-G  [SOT23-2-95-3P]  153.55 72.73 90 top
Q43  2N7002KTB  [SOT23-1_38-5-3P]  284.86 72.38 90 top
Q45  2N7002K  [SOT23-2-95-3P]  153.38 69.2 90 top
Q46  2N7002KTB  [SOT23-1_38-5-3P]  155.32 66.89 0 top
Q47  PJX138K  [SOT563-1_6-5-6P-PJX138K]  25.68 65.19 90 top
Q48  PJE8406  [SOT23-1_38-5-3P]  231.14 64.73 0 top
Q49  5G_S@2N7002KDW  [SOT363-2_1-65-6P]  284.23 62.7 90 top
Q50  2N7002KTB  [SOT23-1_38-5-3P]  189.61 61.81 270 top
Q51  5G_S@2N7002KDW  [SOT363-2_1-65-6P]  274.12 57.09 90 top
Q52  2N7002KTB  [SOT23-1_38-5-3P]  31.88 56.6 0 top
Q53  *PJX138K  [SOT563-1_6-5-6P-PJX138K]  257.05 55.79 180 top
Q54  METR3904-G  [SOT23-2-95-3P]  34.93 55.59 270 top
Q55  2N7002KTB  [SOT23-1_38-5-3P]  174.3 53.42 0 top
Q56  PJA138K  [SOT23-2-95-3P]  255.78 52.62 0 top
Q57  2N7002KTB  [SOT23-1_38-5-3P]  186.82 48.35 0 top
Q58  DMP2130L-7  [SOT23-2-95-3P]  221.49 44.21 180 top
Q59  2N7002K  [SOT23-2-95-3P]  217.17 43.52 180 top
Q60  *DMP2130L-7  [SOT23-2-95-3P]  205.51 41.54 270 top
Q61  DMP2130L-7  [SOT23-2-95-3P]  183.26 41.24 0 top
Q62  SSM6N43FU  [SC70-2_1-65-6P]  201.17 41.24 0 top
Q63  2N7002K  [SOT23-2-95-3P]  197.36 40.86 0 top
Q64  2N7002K  [SOT23-2-95-3P]  186.82 40.35 270 top
Q65  2N7002KDW  [SOT363-2_1-65-6P]  42.77 36.7 0 top
Q66  2N7002K  [SOT23-2-95-3P]  37.04 35.83 180 top
Q67  2N7002KTB  [SOT23-1_38-5-3P]  20.93 12.28 180 top
Q68  2N7002KTB  [SOT23-1_38-5-3P]  26.27 11.37 90 top
Q69  2N7002KTB  [SOT23-1_38-5-3P]  23.9 10.38 0 top
Q70  2N7002KTB  [SOT23-1_38-5-3P]  21.24 9.59 180 top
Q71  PJX138K  [SOT563-1_6-5-6P-PJX138K]  17.53 4.66 90 top
Q72  PJX138K  [SOT563-1_6-5-6P-PJX138K]  19.56 4.66 270 top
Q73  *2N7002KDW  [SOT363-2_1-65-6P]  137.04 216.55 0 bottom
Q74  *BSS84DW  [SOT363-2_1-65-6P]  146.05 213.2 270 bottom
Q75  *PJX138K  [SOT563-1_6-5-6P-PJX138K]  257.4 212.2 90 bottom
Q76  *2N7002K  [SOT23-2-95-3P]  165.02 211.31 180 bottom
Q77  *BSS84  [SOT23-2-95-3P]  148.72 209.13 270 bottom
Q78  *BSS84DW  [SOT363-2_1-65-6P]  151.57 203.8 180 bottom
Q79  BSS84DW  [SOT363-2_1-65-6P]  146.82 202.53 180 bottom
Q80  *2N7002K  [SOT23-2-95-3P]  284.86 197.45 270 bottom
Q81  2N7002KDW  [SOT363-2_1-65-6P]  276.23 196.94 0 bottom
Q82  *PJA138K  [SOT23-2-95-3P]  281.32 196.77 90 bottom
Q83  2N7002K  [SOT23-2-95-3P]  266.58 196.3 270 bottom
Q84  *DDTC144EUA-7-F  [SOT23-1_7-65-3P]  285.25 194.15 270 bottom
Q85  BSS84  [SOT23-2-95-3P]  269.12 193.38 270 bottom
Q86  2N7002K  [SOT23-2-95-3P]  272.77 192.42 270 bottom
Q87  2N7002KDW  [SOT363-2_1-65-6P]  201.81 185.89 180 bottom
Q88  *2N7002KDW  [SOT363-2_1-65-6P]  206 183.1 270 bottom
Q89  DMG3414U-7  [SOT23-2-95-3P]  202.95 181.32 180 bottom
Q91  EMF11N02J  [SOT23-2_38-95-3P]  208.66 180.3 270 bottom
Q93  DDTC144EUA-7-F  [SOT23-1_7-65-3P]  194.44 166.97 90 bottom
Q94  AOSS32334C  [SOT23-2_38-95-3P]  189.36 163.54 0 bottom
Q95  2N7002K  [SOT23-2-95-3P]  193.04 163.54 0 bottom
Q96  PJX138K  [SOT563-1_6-5-6P-PJX138K]  121.03 144.39 180 bottom
Q97  METR3904-G  [SOT23-2-95-3P]  113.24 134.62 270 bottom
Q98  DMG301NU-7  [SOT23-2-95-3P]  113.8 130.01 180 bottom
Q99  METR3904-G  [SOT23-2-95-3P]  107.42 110.56 90 bottom
Q100  *2N7002K  [SOT23-2-95-3P]  110.98 110.56 90 bottom
Q101  METR3904-G  [SOT23-2-95-3P]  211.84 109.06 90 bottom
Q102  5G@PJE8406  [SOT23-1_38-5-3P]  300.53 98.02 90 bottom
Q103  PJX138K  [SOT563-1_6-5-6P-PJX138K]  211.97 98.21 0 bottom
Q104  5G@DMG3414U-7  [SOT23-2-95-3P]  296.8 91.97 0 bottom
Q105  2N7002KTB  [SOT23-1_38-5-3P]  68.08 91.91 270 bottom
Q106  2N7002KDW  [SOT363-2_1-65-6P]  68.2 88.23 0 bottom
Q107  *5G@PJE8406  [SOT23-1_38-5-3P]  297.95 86.32 0 bottom
Q108  2N7002KDW  [SOT363-2_1-65-6P]  230.78 80.82 90 bottom
Q109  *5G@PJE8406  [SOT23-1_38-5-3P]  314.2 79.85 180 bottom
Q110  *DMG3414U-7  [SOT23-2-95-3P]  307.78 64.19 180 bottom
Q111  *DDTC144EUA-7-F  [SOT23-1_7-65-3P]  304.8 62.54 270 bottom
Q112  2N7002KTB  [SOT23-1_38-5-3P]  231.78 52.29 0 bottom
Q113  *2N7002KTB  [SOT23-1_38-5-3P]  231.78 50 0 bottom
Q114  2N7002K  [SOT23-2-95-3P]  191.56 49.12 0 bottom
Q115  2N7002K  [SOT23-2-95-3P]  195 48.36 90 bottom
Q116  *METR3904-G  [SOT23-2-95-3P]  210.6 46.63 180 bottom
Q117  SSM6N43FU  [SC70-2_1-65-6P]  18.8 34.91 180 bottom
Q118  METR3904-G  [SOT23-2-95-3P]  153.95 168.35 180 bottom
Q119  METR3904-G  [SOT23-2-95-3P]  170.88 168.39 180 bottom
Q120  METR3904-G  [SOT23-2-95-3P]  171.46 164.86 180 bottom
Q121  2N7002K  [SOT23-2-95-3P]  159.82 168.35 180 bottom
Q122  2N7002K  [SOT23-2-95-3P]  163.89 168.22 180 bottom
Q123  2N7002K  [SOT23-2-95-3P]  167.54 168.38 180 bottom
Q124  *2N7002KTB  [SOT23-1_38-5-3P]  194.82 52.6 90 top
Q125  BSS84  [SOT23-2-95-3P]  253.3 209.64 90 top
Q126  2N7002KDW  [SOT363-2_1-65-6P]  165.28 200.85 270 top
Q127  2N7002K  [SOT23-2-95-3P]  248.44 208.52 180 top
Q128  DDTC144EUA-7-F  [SOT23-1_7-65-3P]  284.99 184.11 270 bottom
QG1  PJX138K  [SOT563-1_6-5-6P-PJX138K]  270.5 215.49 0 top
QG2  PJX138K  [SOT563-1_6-5-6P-PJX138K]  284.11 171.82 180 top
QG3  METR3904-G  [SOT23-2-95-3P]  283.53 141.15 0 top
QG4  METR3904-G  [SOT23-2-95-3P]  274.6 136.52 0 top
QG5  METR3904-G  [SOT23-2-95-3P]  274.6 132.97 0 top
QG6  METR3904-G  [SOT23-2-95-3P]  274.61 129.41 0 top
QG7  METR3904-G  [SOT23-2-95-3P]  279.42 129.41 0 top
QG8  2N7002KDW  [SOT363-2_1-65-6P]  246.79 116.73 180 top
QG9  PJE8406  [SOT23-1_38-5-3P]  237.38 116.41 90 top
QG10  PJX138K  [SOT563-1_6-5-6P-PJX138K]  256.16 114.57 90 top
QG11  PJX138K  [SOT563-1_6-5-6P-PJX138K]  262.31 114.54 90 top
QG12  PJX138K  [SOT563-1_6-5-6P-PJX138K]  259.29 114.53 270 top
QG13  PJE8406  [SOT23-1_38-5-3P]  240.11 114.49 0 top
QG14  PJX138K  [SOT563-1_6-5-6P-PJX138K]  242.48 113.49 90 top
QG15  PJX138K  [SOT563-1_6-5-6P-PJX138K]  250.07 112.56 0 top
QG16  *5G@PJE8406  [SOT23-1_38-5-3P]  313.21 85.56 0 top
QG17  METR3904-G  [SOT23-2-95-3P]  263.4 133.95 90 bottom
QG18  *PJE8406  [SOT23-1_38-5-3P]  262.77 130.01 180 bottom
QG19  PJE8406  [SOT23-1_38-5-3P]  262.35 127.71 180 bottom
QG20  PJE8406  [SOT23-1_38-5-3P]  258.44 117.07 90 bottom
QG21  PJX138K  [SOT563-1_6-5-6P-PJX138K]  256.31 116.99 270 bottom
QG22  2N7002K  [SOT23-2-95-3P]  228.6 116.29 0 bottom
QG23  PJE8406  [SOT23-1_38-5-3P]  231.37 116.14 270 bottom
QG24  PJE8406  [SOT23-1_38-5-3P]  260.78 115.95 90 bottom
QG25  PJE8406  [SOT23-1_38-5-3P]  265.07 115.82 90 bottom
R1  *100K_1%_2  [R0201]  246.36 218.88 90 top
R2  *4.7K_1%_2  [R0201]  166.63 218.66 90 top
R3  *4.7K_1%_2  [R0201]  170.56 218.28 0 top
R4  *124_1%_6  [R0603]  161.17 218.15 180 top
R5  *124_1%_6  [R0603]  173.61 218.15 90 top
R6  *4.7K_1%_2  [R0201]  223.94 217.86 90 top
R7  *200_1%_6  [R0603]  231.86 217.85 0 top
R8  *124_1%_6  [R0603]  234.49 217.78 180 top
R9  *4.7K_1%_2  [R0201]  227.56 217.77 270 top
R10  *100K_1%_2  [R0201]  249.99 217.67 270 top
R11  *124_1%_6  [R0603]  229.23 217.6 0 top
R12  *Short_0402  [S0402]  261.8 216.96 180 top
R13  *Short_0402  [S0402]  264.28 216.94 0 top
R14  *124_1%_6  [R0603]  246.03 216.29 0 top
R15  10K_1%_2  [R0201]  272.27 216.02 0 top
R16  *Short_0603  [S0603]  264.29 215.74 180 top
R17  *4.7K_1%_2  [R0201]  275.32 215.39 0 top
R18  *4.7K_1%_2  [R0201]  276.64 215.38 180 top
R19  *68K_1%_2  [R0201]  275.46 214.08 90 top
R20  *4.7K_1%_2  [R0201]  274.75 214.08 90 top
R21  *68K_1%_2  [R0201]  273.3 214.08 90 top
R22  *4.7K_1%_2  [R0201]  274.02 214.08 90 top
R23  *4.7K_1%_2  [R0201]  271.87 214.07 90 top
R24  *68K_1%_2  [R0201]  272.58 214.07 90 top
R25  4.7K_1%_2  [R0201]  271.15 213.97 270 top
R26  *100K_1%_2  [R0201]  252.14 213.55 0 top
R27  *4.7K_1%_2  [R0201]  247.9 211.91 0 top
R28  *68K_1%_2  [R0201]  273.37 211.5 270 top
R29  *4.7K_1%_2  [R0201]  274.08 211.5 270 top
R30  *4.7K_1%_2  [R0201]  272.65 211.49 270 top
R31  *68K_1%_2  [R0201]  271.94 211.49 270 top
R32  *10K_5%_2  [R0201]  223.47 211.16 270 top
R33  *0_5%_2  [R0201]  257.05 210.42 0 top
R34  *0_5%_2  [R0201]  258.04 210.42 180 top
R35  4.7K_1%_2  [R0201]  272.59 209.71 180 top
R36  4.7K_1%_2  [R0201]  275.69 209.69 90 top
R37  *10K_1%_2  [R0201]  277.22 208.89 90 top
R38  4.7K_1%_2  [R0201]  145.93 208.75 270 top
R39  4.7K_1%_2  [R0201]  147.1 208.75 270 top
R40  *Short_0805  [S0805]  266.9 208.29 90 top
R41  *100K_5%_2  [R0201]  223.21 207.66 0 top
R42  100K_1%_2  [R0201]  278.66 207.41 180 top
R43  4.7K_1%_2  [R0201]  142.75 206.67 0 top
R44  4.7K_1%_2  [R0201]  160.92 206.42 180 top
R45  4.7K_1%_2  [R0201]  142.6 204.36 90 top
R46  *4.7K_1%_2  [R0201]  143.33 204.36 270 top
R47  *124_1%_6  [R0603]  187.71 204.13 90 top
R48  *200_1%_6  [R0603]  189.33 204.13 90 top
R49  *124_1%_6  [R0603]  190.93 203.98 90 top
R50  *100K_1%_2  [R0201]  278.25 203.68 90 top
R51  *100K_1%_2  [R0201]  277.23 203.68 270 top
R52  *100K_1%_2  [R0201]  278.24 202.29 270 top
R53  *100K_1%_2  [R0201]  277.23 202.28 90 top
R54  33_1%_2  [R0201]  268.33 197.65 180 top
R55  DDS@0_5%_2  [R0201]  278.9 195.16 0 top
R56  *2K_1%_2  [R0201]  280.93 195.16 180 top
R57  DDS@0_5%_2  [R0201]  278.9 194.15 0 top
R58  *2K_1%_2  [R0201]  280.93 194.15 180 top
R59  *33_1%_2  [R0201]  278.63 192.78 90 top
R60  *Short_0201  [S0201]  279.34 192.78 90 top
R61  *33_1%_2  [R0201]  279.66 191.22 90 top
R62  *Short_0201  [S0201]  280.38 191.22 90 top
R63  *EV@1M_5%_2  [R0201]  222.32 190.75 270 top
R64  *EV@1M_5%_2  [R0201]  223.08 190.75 90 top
R65  *Short_0201  [S0201]  279.83 190.09 180 top
R66  *Short_0201  [S0201]  279.83 189.37 180 top
R67  *0_5%_2  [R0201]  205.62 189.07 180 top
R68  *EV@22_5%_8  [R0805]  214.92 188.6 270 top
R69  *Short_0201  [S0201]  205.62 188.3 180 top
R70  *Short_0201  [S0201]  202.75 187.64 90 top
R71  33_1%_2  [R0201]  279.65 187.22 0 top
R72  33_1%_2  [R0201]  279.65 186.08 180 top
R73  33_1%_2  [R0201]  279.65 184.94 180 top
R74  *Short_0603  [S0603]  265.69 184.75 180 top
R75  100K_1%_2  [R0201]  206.38 184.24 270 top
R76  100K_1%_2  [R0201]  206.63 183.22 180 top
R77  100K_1%_2  [R0201]  210.82 182.97 270 top
R78  1.1K_1%_2  [R0201]  210.82 181.95 90 top
R79  *10K_1%_2  [R0201]  283.21 180.94 90 top
R80  *Short_0201  [S0201]  283.98 180.94 270 top
R81  100K_1%_2  [R0201]  284.74 180.94 270 top
R82  100K_1%_2  [R0201]  284.38 175.07 180 top
R83  *Short_0201  [S0201]  283.52 174.95 270 top
R84  *0_5%_2  [R0201]  283.56 173.46 90 top
R85  *0_5%_2  [R0201]  282.1 173.45 270 top
R86  *Short_0201  [S0201]  282.83 173.44 90 top
R87  1K_1%_2  [R0201]  285.84 172.52 180 top
R88  10K_1%_2  [R0201]  282.27 171.72 180 top
R89  1K_1%_2  [R0201]  184.15 163.03 180 top
R90  499_1%_2  [R0201]  184.15 162.27 180 top
R91  *1K_1%_2  [R0201]  184.15 161.51 180 top
R92  *Short_0201  [S0201]  184.53 154.9 180 top
R93  *1K_1%_2  [R0201]  169.44 154.68 90 top
R94  1K_1%_2  [R0201]  170.6 154.63 90 top
R95  *Short_0201  [S0201]  184.53 153.89 180 top
R96  *1K_1%_2  [R0201]  170.6 153.61 180 top
R97  *1K_1%_2  [R0201]  168.28 153.38 90 top
R98  10K_1%_2  [R0201]  184.15 152.62 0 top
R99  1K_1%_2  [R0201]  168.81 151.26 90 top
R100  100_1%_2  [R0201]  185.17 151.09 0 top
R101  10K_1%_2  [R0201]  184.15 148.55 0 top
R102  10K_1%_2  [R0201]  184.15 147.03 0 top
R103  2.2K_1%_2  [R0201]  167.26 145.16 0 top
R104  *Short_0402  [S0402]  166.88 138.44 180 top
R105  *Short_0402  [S0402]  165.53 137.98 90 top
R106  2.2K_1%_2  [R0201]  167.08 136.21 0 top
R107  2.2K_1%_2  [R0201]  170.82 130.77 270 top
R108  10K_1%_2  [R0201]  112.93 123.66 270 top
R109  100K_1%_2  [R0201]  112.14 123.66 270 top
R110  10K_1%_2  [R0201]  113.03 119.34 90 top
R111  *10K_1%_2  [R0201]  113.03 118.2 270 top
R112  10K_1%_2  [R0201]  112.27 116.8 90 top
R113  100K_1%_2  [R0201]  113.03 116.8 90 top
R114  *240_1%_2  [R0201]  146.15 103.93 0 top
R115  240_1%_2  [R0201]  144.25 103.82 180 top
R116  *240_1%_2  [R0201]  142.6 103.8 0 top
R117  240_1%_2  [R0201]  145.24 102.02 90 top
R118  *240_1%_2  [R0201]  147.15 100.95 180 top
R119  *240_1%_2  [R0201]  143.26 100.14 180 top
R120  *10K_1%_2  [R0201]  186.81 99.81 0 top
R121  10K_1%_2  [R0201]  51.49 99.78 180 top
R122  10K_1%_2  [R0201]  187.67 99.75 90 top
R123  *240_1%_2  [R0201]  147.53 99.51 180 top
R124  20K_1%_2  [R0201]  317.38 99.28 90 top
R125  39K_1%_2  [R0201]  318.14 99.28 90 top
R126  20K_1%_2  [R0201]  311.93 98.97 90 top
R127  39K_1%_2  [R0201]  312.65 98.97 90 top
R128  *0_5%_4  [R0402]  42.8 98.9 0 top
R129  *240_1%_2  [R0201]  143.89 98.74 90 top
R130  *240_1%_2  [R0201]  145.49 98.72 270 top
R131  10K_1%_2  [R0201]  187.23 98.67 0 top
R132  10K_1%_2  [R0201]  301.99 98.63 180 top
R133  *240_1%_2  [R0201]  142.42 98.46 270 top
R134  10K_1%_2  [R0201]  164.67 98.03 0 top
R135  *10K_1%_2  [R0201]  187.23 97.91 180 top
R136  100K_1%_2  [R0201]  301.99 97.65 180 top
R137  *10K_1%_2  [R0201]  164.67 97.3 180 top
R138  221K_1%_2  [R0201]  12.07 97.27 270 top
R139  *0_5%_6  [R0603]  50.68 97.12 0 top
R141  100K_1%_2  [R0201]  31.75 96.99 180 top
R142  *10K_1%_2  [R0201]  153.94 96.84 270 top
R143  *Short_0201  [S0201]  38.36 96.74 270 top
R144  *Short_0201  [S0201]  39.25 96.74 270 top
R145  *Short_0201  [S0201]  40.01 96.74 270 top
R146  *Short_0201  [S0201]  40.77 96.74 270 top
R147  *3.83K_1%_2  [R0201]  16.61 96.36 0 top
R148  *10K_1%_2  [R0201]  30.36 96.23 180 top
R149  *10K_1%_2  [R0201]  31.75 96.23 0 top
R150  221K_1%_2  [R0201]  12.07 96.2 90 top
R151  *Short_0603  [S0603]  50.68 95.59 0 top
R152  *0_5%_2  [R0201]  30.36 95.47 180 top
R153  *Short_0201  [S0201]  31.75 95.47 0 top
R154  *2M_1%_2  [R0201]  13.7 95.43 90 top
R155  *1M_1%_2  [R0201]  39.5 95.34 180 top
R156  *1M_1%_2  [R0201]  40.52 95.34 0 top
R158  240_1%_2  [R0201]  153.95 94.96 90 top
R159  *Short_0201  [S0201]  68.55 94.45 180 top
R160  *2M_1%_2  [R0201]  13.7 94.44 270 top
R161  2.2_5%_2  [R0201]  33.4 93.56 180 top
R162  **33K_1%_2  [R0201]  17.4 93.28 90 top
R163  **33K_1%_2  [R0201]  18.16 93.28 270 top
R164  3.32K_1%_2  [R0201]  49.94 92.93 0 top
R165  *Short_0201  [S0201]  50.93 92.93 0 top
R166  *Short_0201  [S0201]  52.45 92.93 180 top
R167  10K_1%_2  [R0201]  312.93 92.87 90 top
R168  10K_1%_2  [R0201]  312.07 92.86 90 top
R169  100K_1%_2  [R0201]  310.65 92.8 90 top
R170  2.2_5%_2  [R0201]  33.4 92.67 180 top
R171  100K_1%_2  [R0201]  317.5 92.67 90 top
R172  10K_1%_2  [R0201]  318.52 92.67 90 top
R173  10K_1%_2  [R0201]  319.28 92.67 90 top
R174  1K_1%_2  [R0201]  168.07 92.11 180 top
R175  *Short_0402  [S0402]  65.41 92.04 270 top
R176  2.2_5%_2  [R0201]  33.4 91.53 180 top
R177  1K_1%_2  [R0201]  168.07 91.4 0 top
R178  *Short_0201  [S0201]  68.7 90.76 0 top
R179  2.2_5%_2  [R0201]  33.4 90.64 180 top
R180  2_1%_6  [R0603]  168.89 90.31 0 top
R181  5G@100K_1%_2  [R0201]  310.5 90.45 0 top
R182  *10K_1%_2  [R0201]  71.63 90.01 0 top
R183  221K_1%_2  [R0201]  11.81 89.78 270 top
R184  *Short_0201  [S0201]  65.05 89.62 180 top
R185  *Short_0201  [S0201]  66.07 89.62 0 top
R186  2.2_5%_2  [R0201]  33.4 89.37 180 top
R187  *Short_0402  [S0402]  56.14 89.12 0 top
R188  *240_1%_2  [R0201]  147.53 89.12 180 top
R189  24.9_1%_2  [R0201]  168 88.99 0 top
R190  240_1%_2  [R0201]  146.03 88.91 180 top
R191  *240_1%_2  [R0201]  142.62 88.89 0 top
R192  4.7K_1%_2  [R0201]  65.05 88.86 0 top
R193  *Short_0201  [S0201]  67.88 88.75 90 top
R194  221K_1%_2  [R0201]  11.81 88.71 90 top
R195  2.2_5%_2  [R0201]  33.4 88.48 180 top
R196  *Short_0402  [S0402]  56.14 88.1 0 top
R197  *Short_0201  [S0201]  99.32 87.95 270 top
R198  *100K_1%_2  [R0201]  100.08 87.95 270 top
R199  *240_1%_2  [R0201]  143.51 87.75 270 top
R200  4.7K_1%_2  [R0201]  65.05 87.72 0 top
R201  2.2_5%_2  [R0201]  33.4 87.34 180 top
R202  *5G@100K_1%_2  [R0201]  301.12 87.21 0 top
R203  10K_1%_2  [R0201]  65.05 86.96 0 top
R204  *5G@Short_0201  [S0201]  304.93 86.66 0 top
R205  2.2_5%_2  [R0201]  33.4 86.45 180 top
R206  *0_5%_4  [R0402]  67.82 86.45 90 top
R207  *0_5%_6  [R0603]  75.7 86.45 0 top
R208  *Short_0201  [S0201]  65.05 86.15 180 top
R209  *Short_0201  [S0201]  66.07 86.15 0 top
R210  *5G@Short_0201  [S0201]  304.93 85.89 0 top
R211  *Short_0603  [S0603]  73.03 85.84 0 top
R212  *240_1%_2  [R0201]  145.95 85.59 180 top
R213  240_1%_2  [R0201]  144.4 85.56 180 top
R214  8.2K_1%_2  [R0201]  65.05 85.38 0 top
R215  *Short_0402  [S0402]  291.09 85.31 270 top
R216  10K_1%_2  [R0201]  33.91 85.18 90 top
R217  2.2K_1%_2  [R0201]  34.8 85.18 270 top
R218  10K_1%_2  [R0201]  35.69 85.18 270 top
R219  *2.2K_1%_2  [R0201]  36.83 85.18 270 top
R220  *2.2K_1%_2  [R0201]  37.72 85.18 270 top
R221  *10K_1%_2  [R0201]  38.87 85.31 180 top
R222  *10K_1%_2  [R0201]  39.75 85.18 90 top
R223  *10K_1%_2  [R0201]  40.52 85.18 90 top
R224  *10K_1%_2  [R0201]  41.53 85.18 90 top
R225  10K_1%_2  [R0201]  42.55 85.18 90 top
R226  100_1%_2  [R0201]  43.31 85.18 270 top
R227  10K_1%_2  [R0201]  44.07 85.18 90 top
R228  *Short_0603  [S0603]  75.7 84.93 0 top
R229  1K_1%_2  [R0201]  164.37 84.74 0 top
R230  4.7K_1%_2  [R0201]  64.37 84.29 180 top
R231  4.7K_1%_2  [R0201]  65.56 84.29 0 top
R232  *Short_0201  [S0201]  48.52 83.91 90 top
R233  2.2K_1%_2  [R0201]  49.28 83.91 90 top
R234  2.2K_1%_2  [R0201]  50.04 83.91 90 top
R235  *Short_0201  [S0201]  50.8 83.91 90 top
R236  3.32K_1%_2  [R0201]  51.69 83.91 90 top
R237  10K_1%_2  [R0201]  189.5 83.88 0 top
R238  *10K_1%_2  [R0201]  190.57 83.86 180 top
R239  5G@2.2K_1%_2  [R0201]  301.26 83.82 180 top
R240  *10K_1%_2  [R0201]  34.16 83.66 270 top
R241  10K_1%_2  [R0201]  41.69 83.66 270 top
R242  *10K_1%_2  [R0201]  40.23 83.66 270 top
R243  *Short_0201  [S0201]  34.93 83.66 270 top
R244  10K_1%_2  [R0201]  35.69 83.66 270 top
R245  *10K_1%_2  [R0201]  36.83 83.66 270 top
R246  10K_1%_2  [R0201]  37.72 83.66 90 top
R247  *10K_1%_2  [R0201]  38.61 83.66 270 top
R248  10K_1%_2  [R0201]  39.5 83.66 270 top
R249  10K_1%_2  [R0201]  40.95 83.66 90 top
R250  *5G@10K_1%_2  [R0201]  312.27 83.68 180 top
R251  *5G@100K_1%_2  [R0201]  313.4 83.65 0 top
R252  *5G@Short_0201  [S0201]  304.93 83.61 0 top
R253  221K_1%_2  [R0201]  12.07 83.27 270 top
R254  *0_5%_4  [R0402]  71.03 83.08 180 top
R255  *0_5%_4  [R0402]  66.3 83.02 0 top
R256  10K_1%_2  [R0201]  46.1 83.01 180 top
R257  *Short_0201  [S0201]  209.81 82.89 180 top
R258  *5G@Short_0201  [S0201]  312.3 82.89 0 top
R259  *5G@0_5%_2  [R0201]  313.41 82.88 0 top
R260  *5G@Short_0201  [S0201]  304.93 82.85 0 top
R261  *Short_0201  [S0201]  34.93 82.64 90 top
R262  5G@100K_1%_2  [R0201]  310.52 82.51 180 top
R263  *Short_0402  [S0402]  63.1 82.28 90 top
R264  *1M_1%_2  [R0201]  217.93 82.25 270 top
R265  *240_1%_2  [R0201]  144.17 82.23 180 top
R266  221K_1%_2  [R0201]  12.07 82.2 90 top
R267  *240_1%_2  [R0201]  148.39 82.18 180 top
R268  *240_1%_2  [R0201]  145.85 82 0 top
R269  200K_1%_2  [R0201]  210.95 82 180 top
R270  *240_1%_2  [R0201]  142.8 81.98 0 top
R271  1M_1%_2  [R0201]  219.68 81.84 270 top
R272  10K_1%_2  [R0201]  286.98 81.73 270 top
R273  *10K_1%_2  [R0201]  286.24 81.72 90 top
R274  *Short_0201  [S0201]  287.83 81.62 90 top
R275  1K_1%_2  [R0201]  163.58 81.5 270 top
R276  *0_5%_4  [R0402]  38.45 81.45 0 top
R277  24.9_1%_2  [R0201]  158.93 81.37 270 top
R278  100K_1%_2  [R0201]  301.02 81.02 0 top
R279  2_1%_6  [R0603]  161.67 80.99 180 top
R281  *Short_0201  [S0201]  211.61 80.91 90 top
R282  *Short_0201  [S0201]  209.45 80.86 90 top
R283  10K_1%_2  [R0201]  293.12 80.73 270 top
R284  *3.83K_1%_2  [R0201]  16.25 80.64 270 top
R285  *2M_1%_2  [R0201]  14.85 80.61 90 top
R286  10K_1%_2  [R0201]  71.89 80.61 90 top
