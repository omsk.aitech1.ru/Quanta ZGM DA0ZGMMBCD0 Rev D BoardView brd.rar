# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+FP_FUSE_GPU: length 14.1
  TOP w0.3: RG64.1 240.32,122.33 239.75,122.9 239.75,126.42 239.95,126.61 239.95,127.02 239.39,127.57 239.39,130.24 239.79,130.64 239.79,132.77 v2(240.29,133.27)
  BOTTOM w0.3: v2(240.29,133.27) 240.28,133.26 240.28,133.25 UG6.BH25
+PCH_AUX: length 196
  TOP w0.508: v1(240.79,47.08) 235.26,47.08 233.79,45.61 228.63,45.61 227.76,44.74 v3(227,44.74)
  IN1 w0.508: v3(223.9,43.02) 223.9,42.84 222.36,41.29 221.06,41.29 219.16,39.4 211.16,39.4 210.26,40.3 200.55,40.3 200.11,40.75 195.38,40.75 194.87,41.25 v1(194.87,41.42)
  IN2 w0.508: v1(194.87,41.42) 194.53,41.42 193.92,42.03 192.67,42.03 192.66,42.02 191.58,42.02 189.77,43.82 189.77,44.15 186.42,47.51 185.78,47.51 184.01,49.27 184.01,49.78 183.07,50.72 183.07,51.65 182.22,52.49 182.22,52.81 181.31,53.73 179.2,53.73 177.34,55.59 177.34,56.45 176,57.79 173.53,57.79 172.5,58.82 171.72,58.82 171.01,59.54 168.98,59.54 167.8,60.73 163.5,60.73 162.63,61.59 160.72,61.59 159.96,62.35 159.96,63.11 159.54,63.54 158.51,63.54 158.04,64.01 149.01,64.01 147.9,62.9 145.16,62.9 144.61,62.35 132.87,62.35 132.21,61.68 123.41,61.68 122.12,60.39 119.33,60.39 118.19,59.26 113.16,59.26 111.4,57.5 109.31,57.5 108.87,57.06 104.35,57.06 100.56,53.26 93.53,53.26 88.98,48.72 63.56,48.72 v1(63.21,49.06)
  vias: v1(211.79,60.45) v1(211.79,59.79) v1(211.78,58.5) v1(211.84,59.15) v1(214.06,60.36) v1(214.06,59.68) v1(214.07,59.02) v1(214.08,58.28) v3(224.67,42.99) v3(225.43,43.02) v3(226.19,42.94) v3(226.24,43.7) v3(227,43.8) v3(227,43.04)
+PEX_PLL_HVDD: length 2.3
  TOP w0.254: RG107.1 226.95,132.37 227.03,132.45 CG408.1 227.03,133.93 v2(227,133.96)
  BOTTOM w0.254: UG6.BF43 227,133.97 v2(227,133.96)
+SMDDR_VREF_DQ0: length 7.9
  TOP w0.14: 165.45,81.89 C317.1
  TOP w0.203: R229.2 164.59,84.48 v1(165,84.07)
  TOP w0.508: v1(165,84.07) 165.23,84.07 165.74,83.56 165.74,82.01 165.61,81.89 C316.1
  BOTTOM w0.254: JDIM2.164 164.03,83.1 v1(165,84.07)
+SMDDR_VREF_DQ1: length 7.8
  TOP w0.508: 168.17,93.1 168.09,93.02 v1(166.09,93.02) 164.06,93.02 163.16,93.92
  BOTTOM w0.254: JDIM1.164 164.08,97.69 163.58,98.19 v1(163.41,98.19)
+TPVDD:
  vias: v1(197.08,39.31) v1(197.73,39.26) v1(198.41,39.19) v1(202.75,44.49) v1(203.42,44.48) v1(204.07,44.48)
+USBPWR3:
  vias: v1(19.2,57.21) v1(20.4,54.7) v1(20.58,56) v1(20.51,55.34) v1(21.06,54.9) v1(21.19,56.27) v1(21.13,55.57)
+USBPWR_DB1:
  vias: v1(320.25,99.1) v1(320.47,98.49) v1(320.55,94.3) v1(320.98,98.92) v1(320.98,98.06) v1(320.98,96.72) v1(321.01,97.4)
+USBPWR_DB2:
  vias: v1(314.71,97.88) v1(315.06,97.23) v1(315.09,96.41) v1(315.75,97.3) v1(315.73,96.64)
+VGPU_SRC_R: length 4.6
  TOP w0.203: PR101.2 226.24,193.03 225.87,193.39
  BOTTOM w0.203: PR480.1 225.38,192.66 PR474.1
  vias: v1(193.52,182.98) v3(190.6,182) v3(190.66,181.19) v3(190.66,180.43) v3(190.66,179.67) v3(190.66,178.91) v3(190.66,178.09) v3(190.66,177.33) v3(191.44,181.98) v3(191.44,181.22) v3(191.44,180.46) v3(191.44,179.69) v3(191.44,178.93) v3(191.44,178.12) v3(191.44,177.36) v3(192.2,181.98) v3(192.2,181.22) v3(192.2,180.46) v3(192.2,179.69) v3(192.2,178.93) v3(192.2,178.12) v3(192.2,177.36) v3(219.82,195.17) v3(220.51,196.23) v3(220.51,195.47) v3(220.51,194.71) v3(220.51,193.95) v3(220.51,193.19) v3(221.21,196.72) v3(221.21,195.94) v3(221.21,195.18) v3(221.21,194.42) v3(221.21,193.66)
+WL_VDD: length 7
  TOP w0.508: 282.04,75.76 279.21,75.76 278.58,76.39 278.58,77.2 278.22,77.56 277.01,77.56 276.5,77.05
  vias: v1(272.5,61.52) v1(272.5,60.83) v1(273.19,61.52) v1(273.19,60.83) v1(273.29,79.78) v1(273.34,78.48) v1(273.44,79.15) v1(273.66,75.32) v1(273.94,79.83) v1(274,78.48) v1(273.93,61.52) v1(273.93,60.83) v1(274.09,79.17) v1(276.29,62.21)
A0_DP: length 3.3
  TOP w0.14: R658.2 19.35,25.73 v1(19.89,26.27) 20.35,26.73 R655.2
  BOTTOM w0.14: v1(19.89,26.27) 20.02,26.15 U56.11
A_DE: length 4.5
  BOTTOM w0.14: v1(278.01,44.92) 277.73,45.2 R1167.1 277.44,45.98 277.05,45.98 276.91,46.11 276.53,46.11 276.26,45.84 R1166.2 275.9,45.68 275.51,46.07 U55.9
A_EQ1: length 4
  BOTTOM w0.14: U55.18 270.03,46.57 269.9,46.7 R1154.2 269.09,46.44 268.94,46.3 267.74,46.3 267.56,46.47 R1153.1
A_EQ2: length 3.7
  BOTTOM w0.14: R1141.1 R1142.2 268.64,47.33 268.78,47.18 270.03,47.18 270.14,47.07 U55.19
ACIN: length 169.2
  TOP w0.14: v1(37.16,46.68) 37.55,46.29 PR317.2 37.85,46.74 37.72,46.87 PR312.1 PR313.2 ; U23.72 v1(185.24,61.7)
  IN3 w0.089: v1(37.16,46.68) 38.08,47.61 38.08,48.25 39.41,49.57 41.71,49.57 43.26,51.12 58.07,51.12 60.73,48.47 71.97,48.47 73.33,49.83 73.33,51.07 77.16,54.9 94.68,54.9 98,58.22 100.76,58.22 102.81,60.27 110.9,60.27 111.48,60.85 111.72,60.85 111.84,60.97 121.99,60.97 122.98,61.96 124.45,61.96 125.56,63.08 140.63,63.08 143.1,65.55 146.35,65.55 148.76,67.95 153.24,67.95 154.34,66.86 159.88,66.86 160.68,67.66 161.17,67.66 161.44,67.39 161.44,67.05 161.6,66.89 163.22,66.89 163.46,67.13 165.22,67.13 165.51,67.42 170.42,67.42 170.84,67 177.66,67 178.91,65.75 182.88,65.75 183.93,64.69 183.93,63.01 v1(185.24,61.7)
ACPRESENT: length 54.5
  TOP w0.14: R577.2 217.81,56.53 217.35,56.99 217.35,57.55 216.5,58.4 v1(216.31,58.4) ; U23.84 184.52,66.5 184.88,66.14 185.59,66.14 185.8,66.35 185.8,66.82 186.37,67.38 189.01,67.38 190.14,66.25 192.27,66.25 192.91,65.6 192.91,64.47 191.47,63.03 191.47,56.96 v1(193.09,55.35)
  IN3 w0.089: v1(193.09,55.35) 193.83,54.61 197.36,54.61 198.08,53.89 198.49,53.48 200.23,53.48 201.65,54.91 205.45,54.91 205.88,54.48 206.74,54.48 207.34,55.08 207.34,55.46 209.5,57.63 213.62,57.63 213.76,57.49 214.68,57.49 215.58,58.4 v1(216.31,58.4)
  BOTTOM w0.102: U49.AH46 214.89,57.35 214.89,57.94 215.36,58.41 216.3,58.41 v1(216.31,58.4)
ACZ_BCLK: length 6.6
  BOTTOM w0.102: U49.BE42 223.37,59.01 223.57,58.81 225.09,58.81 225.37,59.09 227.22,59.09 227.55,58.76 C792.2 227.61,58.82 227.9,59.1 228.76,59.1 R1021.2
ACZ_RST#: length 6.3
  BOTTOM w0.102: R1049.2 228.8,56.77 227.72,56.77 227.62,56.87 R1048.1 227.47,57.26 224.91,57.26 224.34,57.83 223.98,57.83 U49.BF44
ACZ_RST#_AUDIO: length 126.6
  TOP w0.14: v1(298.78,82.21) 298.03,82.96 298.03,83.42 297.89,83.56 296.71,83.56 296.57,83.7 296.57,83.98 296.71,84.12 297.89,84.12 298.03,84.26 298.03,85.93 298.93,86.83 298.93,87.28 299.38,87.73 300.46,87.73 301.33,88.6 303.73,88.6 304.56,89.43 Q23.1
  IN2 w0.089: v1(298.78,82.21) 298.78,82.18 298.53,81.93 298.53,81.57 297.96,81 297.6,81 297.52,81.08 297.52,81.6 297.43,81.69 297.2,81.69 297.1,81.59 297.1,80.65 297.01,80.56 296.81,80.56 296.68,80.7 296.68,81.92 296.59,82 296.41,82 296.32,81.92 296.32,81.09 296.18,80.96 296.05,80.96 295.93,81.08 295.93,81.74 295.84,81.83 295.66,81.83 295.57,81.74 295.57,81.5 295.43,81.36 294.77,81.36 294.3,80.89 293.63,80.89 293.16,81.36 290.76,81.36 289.66,80.26 288.82,80.26 288.28,79.72 286.67,79.72 284.81,77.86 284.56,77.86 282.1,75.39 281.07,75.39 280.98,75.3 280.98,74.99 280.89,74.9 279.95,74.9 279.86,74.81 279.86,74.64 279.95,74.55 280.89,74.55 280.98,74.46 280.98,74.28 280.89,74.19 279.95,74.19 279.86,74.1 279.86,73.92 279.95,73.84 280.89,73.84 280.98,73.75 280.98,73.27 281.05,73.19 281.62,73.19 281.71,73.1 281.71,72.75 281.62,72.66 279.91,72.66 279.66,72.91 279.66,73.17 279.37,73.46 278.55,73.46 278.18,73.09 278.18,70.25 276.04,68.11 276.04,63.6 274.77,62.33 274.77,60.05 274.61,59.89 273.16,59.89 272.92,59.65 272.79,59.65 272.55,59.89 272.43,59.89 272.3,59.76 272.3,59.64 272.54,59.4 272.54,59.27 271.76,58.48 271.63,58.48 271.35,58.76 271.23,58.76 271.1,58.63 271.1,58.51 271.38,58.23 271.38,58.11 271.25,57.98 271.13,57.98 270.85,58.26 270.73,58.26 270.6,58.13 270.6,58.01 270.88,57.73 270.88,57.6 270.63,57.36 265.94,57.36 263.58,55 254.08,55 253.67,55.4 249.99,55.4 249.9,55.32 249.9,54.72 249.78,54.6 249.63,54.6 249.54,54.68 249.54,55.32 249.45,55.4 249.28,55.4 249.19,55.32 249.19,54.72 249.07,54.6 248.92,54.6 248.83,54.68 248.83,55.32 248.74,55.4 248.56,55.4 248.48,55.32 248.48,54.72 248.35,54.6 248.21,54.6 248.12,54.68 248.12,55.32 248.03,55.4 247.78,55.4 247.68,55.3 247.68,54.75 247.52,54.6 244.63,54.6 244.51,54.48 241.46,54.48 241.1,54.12 240.47,54.12 240.22,54.37 240.22,54.73 239.77,55.18 239.05,55.18 238.15,56.07 236.77,56.07 236.29,56.56 235.39,56.56 235.3,56.47 235.3,56.03 235.21,55.94 235.03,55.94 234.95,56.03 234.95,56.47 234.86,56.56 234.68,56.56 234.59,56.47 234.59,56.03 234.5,55.94 234.32,55.94 234.23,56.03 234.23,56.47 234.15,56.56 232.62,56.56 232.56,56.61 230.07,56.61 v1(230.01,56.68)
  BOTTOM w0.102: v1(230.01,56.68) 229.85,56.68 229.59,56.93 R1049.1
ACZ_SDIN0: length 133.4
  TOP w0.14: v1(309.93,60.54) 309.93,60.91 R526.2
  IN2 w0.089: v1(226.04,57.81) 226.11,57.87 228.7,57.87 229.16,57.41 231.65,57.41 232,57.07 232.35,57.07 233.01,57.73 237.11,57.73 237.7,57.14 238.42,57.14 239.44,56.12 240.2,56.12 240.9,55.42 244.12,55.42 244.24,55.54 246.49,55.54 247.3,56.34 254.06,56.34 254.47,55.94 256.53,55.94 257.35,56.75 263.75,56.75 265.3,58.3 269.44,58.3 271.33,60.19 271.33,61.58 273.18,63.43 274.54,63.43 275.11,63.99 275.11,68.5 277.25,70.64 277.25,73.48 278.58,74.81 278.58,75.15 279.79,76.35 281.71,76.35 283.9,78.54 283.9,79.31 284.18,79.59 284.61,79.59 284.86,79.85 284.86,80.61 285.5,81.24 288.13,81.24 288.92,82.04 290.1,82.04 290.37,82.3 294.47,82.3 295.18,83 296.55,83 296.7,83.15 300.12,83.15 301.55,84.58 301.55,86.76 301.94,87.16 302.59,87.16 304.21,85.54 304.21,83.43 304.86,82.78 304.86,79.35 307.52,76.69 307.52,72.14 306.11,70.73 306.11,65.36 306.89,64.58 306.89,62.27 307,62.16 307.76,62.16 307.83,62.22 308.44,62.22 309.93,60.72 v1(309.93,60.54)
  BOTTOM w0.102: U49.BG44 225.32,58.1 225.61,57.81 v1(226.04,57.81)
ACZ_SDIN0_U: length 2.8
  TOP w0.14: R526.1 310.34,61.77 311.01,61.77 311.21,61.97 311.21,62.7 311.35,62.84 U20.16
ACZ_SDOUT: length 11.5
  BOTTOM w0.102: R1052.2 230.67,56.65 230.67,56.95 230.57,57.05 R1046.2 R1036.1 230.57,58.7 R1023.1 ; R1052.2 v1(230.57,55.8) ; R1052.2 230.42,56.69 230.42,56.89 230.25,57.07 230.25,57.38 230.05,57.57 228.97,57.57 228.92,57.62 228.45,57.62 228.33,57.5 227.59,57.5 227.09,58 226.88,58 226.5,58.38 223.28,58.38 U49.BE43
ACZ_SDOUT_AUDIO: length 129.8
  TOP w0.14: v1(311.63,61.9) 311.45,62.07 311.45,62.55 311.75,62.84 U20.17
  IN2 w0.089: v1(232.18,57.47) 232.18,57.64 232.7,58.16 237.21,58.16 237.89,57.48 238.56,57.48 239.58,56.46 240.34,56.46 241.04,55.76 243.98,55.76 244.9,56.69 254.2,56.69 254.61,56.28 256.39,56.28 257.21,57.1 263.61,57.1 265.16,58.64 269.3,58.64 270.99,60.33 270.99,61.72 273.03,63.77 274.4,63.77 274.76,64.14 274.76,68.65 276.9,70.79 276.9,73.62 278.24,74.95 278.24,75.29 279.02,76.07 279.02,76.98 279.44,77.4 282.15,77.4 283.56,78.81 283.56,80.11 285.06,81.62 288.02,81.62 288.78,82.38 289.96,82.38 290.22,82.64 294.33,82.64 295.03,83.34 296.34,83.34 296.51,83.5 300,83.5 301.21,84.72 301.21,86.91 301.8,87.5 302.73,87.5 304.55,85.68 304.55,83.57 305.2,82.92 305.2,82.34 307,80.55 307.4,80.55 307.88,80.07 307.88,78.25 308.33,77.79 308.33,70.83 306.45,68.96 306.45,65.5 307.17,64.78 309.25,64.78 310.29,63.74 310.29,62.02 310.72,61.58 311.32,61.58 v1(311.63,61.9)
  BOTTOM w0.14: R1046.1 231.02,57.45 231.27,57.71 231.92,57.71 232.16,57.47 v1(232.18,57.47)
ACZ_SPKR: length 132.2
  TOP w0.14: D25.2 318.1,78.06 317.68,77.64 317.12,77.64 316.7,78.06 316.7,80.26 v1(317.81,81.37)
  IN2 w0.089: v1(317.81,81.37) 316.69,82.49 316.69,82.98 314.77,84.9 314.33,84.9 314.12,85.12 313.56,85.12 312.33,83.89 311.38,83.89 310.76,83.27 309.39,83.27 308.4,84.27 308.4,86.69 307.16,87.92 305.26,87.92 304.83,88.35 304.42,88.35 302.93,89.84 301.47,89.84 299.15,87.52 299.15,86.58 298.65,86.09 298.65,84.79 298.33,84.46 296.14,84.46 295.84,84.16 294.97,84.16 294.79,84.33 294.38,84.33 293.5,83.45 289.89,83.45 289.73,83.29 287.21,83.29 286.41,82.49 284.79,82.49 282.74,80.45 282.74,79.2 282.11,78.56 279.45,78.56 278.21,77.32 278.21,76.41 277.42,75.63 277.42,75.29 276.09,73.96 276.09,71.12 273.95,68.98 273.95,66.2 272.54,64.78 272.54,64.42 271.76,63.64 270.69,63.64 269.98,62.93 269.98,61.98 269.61,61.61 269.44,61.61 268.33,60.49 267.1,60.49 266.06,59.46 263.66,59.46 262.12,57.91 253.58,57.91 253.17,57.5 244.57,57.5 243.64,56.58 241.39,56.58 239.93,58.04 239.15,58.04 238.89,58.29 238.3,58.29 237.04,59.56 235.61,59.56 235.24,59.93 233.73,59.93 232.84,60.82 231.73,60.82 231.23,60.32 v1(230.73,60.32)
  BOTTOM w0.102: U49.BD40 223.32,59.48 223.81,59.48 223.97,59.64 224.48,59.64 224.67,59.83 225.21,59.83 225.54,59.5 226.87,59.5 227.54,60.17 R1009.2 227.54,60.56 227.73,60.75 228.73,60.75 228.89,60.6 R1010.1 228.89,60.18 229.08,59.99 230.61,59.99 230.76,60.14 230.76,60.28 v1(230.73,60.32)
ACZ_SYNC: length 7.1
  BOTTOM w0.102: U49.BD43 222.94,58.75 223.31,58.75 223.48,58.59 226.58,58.59 226.96,58.21 227.17,58.21 227.33,58.05 R1031.1 227.61,57.82 227.72,57.71 227.73,57.7 228.23,57.7 228.37,57.85 229.03,57.85 R1037.2
ACZ_SYNC_AUDIO: length 129.4
  TOP w0.14: v1(310.78,62.31) 310.95,62.48 U20.15
  IN2 w0.089: v1(310.78,62.31) 310.89,62.42 310.89,63.63 309.39,65.13 307.31,65.13 306.8,65.64 306.8,68.82 308.67,70.69 308.67,77.94 308.22,78.39 308.22,80.21 307.54,80.89 307.14,80.89 305.55,82.49 305.55,83.06 304.89,83.71 304.89,85.82 302.64,88.08 302.64,88.21 302.37,88.48 302.04,88.48 300.87,87.31 300.87,84.86 299.87,83.86 296.22,83.86 296.04,83.69 294.89,83.69 294.19,82.98 290.08,82.98 289.82,82.72 288.64,82.72 287.87,81.96 284.92,81.96 283.21,80.25 283.21,78.95 282.01,77.75 279.3,77.75 278.68,77.12 278.68,76.21 277.89,75.43 277.89,75.1 276.56,73.76 276.56,70.93 276.26,70.63 274.42,68.79 274.42,66 273.01,64.59 273.01,64.23 270.64,61.87 270.64,60.84 269.83,60.02 267.29,60.02 266.26,58.99 265.02,58.99 263.47,57.44 257.07,57.44 256.25,56.62 254.75,56.62 254.35,57.03 244.76,57.03 243.84,56.11 241.18,56.11 240.25,57.04 240.25,57.04 239.72,57.57 238.96,57.57 238.7,57.82 238.11,57.82 236.84,59.09 235.41,59.09 235.23,59.27 232.18,59.27 231.92,59.01 230.34,59.01 v1(230.05,58.71)
  BOTTOM w0.102: v1(230.05,58.71) 230.05,58.67 229.6,58.22 R1037.1
ADC_MUX_SEL: length 203.5
  TOP w0.102: v2(252.21,133.28) 251.72,132.79 RG54.1
  TOP w0.14: v1(187.96,164.94) 188.47,164.43 192.15,164.43 193.92,166.19 193.92,167.55 194.15,167.78 194.15,177.83 200.06,183.73 200.06,188.28 200.97,189.19 201.93,189.19 202.59,189.85 v1(209.28,189.85) 210.2,189.85 210.37,189.68 211.2,189.68 211.5,189.97 v1(211.5,190.91)
  TOP w0.203: v1(225.05,210.53) 225.05,210.66 225.43,211.04 PR54.1
  IN1 w0.086: v1(225.05,210.53) 225.24,210.72 226.77,210.72 227.6,209.89 227.6,208.71 228.72,207.59 231.86,207.59 233.86,205.58 233.86,205.02 233.73,204.89 233.73,203.68 234.35,203.05 234.35,199.97 232.94,198.56 232.94,194.9 232.5,194.45 232.5,192.73 231.8,192.03 230.58,192.03 229.87,191.33 224.29,191.33 223.72,191.9 218.26,191.9 217.78,192.38 217.07,192.38 215.79,191.1 211.69,191.1 v1(211.5,190.91) ; 201,125.53 200.36,125.53 194.21,131.68 194.21,151.9 189.88,156.23 189.88,162.33 187.96,164.24 v1(187.96,164.94) ; 217.21,125.98 218.53,125.98 219.21,126.67 237.94,126.67 239.37,128.1 241.03,128.1 241.7,128.76 241.7,133.95 242.1,134.36 242.91,134.36 243.78,133.49 245.14,133.49 245.8,132.83 245.8,132.7 246.36,132.14 246.81,132.14 246.99,132.32 247.37,132.32 247.75,132.7 247.75,133.55 248.45,134.25 249.3,134.25 249.39,134.34 250.26,134.34 250.4,134.2 251.08,134.2 251.23,134.35 251.95,134.35 252.23,134.07 252.23,133.3 v2(252.21,133.28)
  IN1 w0.102: 201,125.53 205.54,125.53 205.69,125.38 207.51,125.38 208.09,125.96 214.26,125.96 214.84,125.38 215.98,125.38 216.58,125.98 217.21,125.98
  BOTTOM w0.102: UG6.BG6 253.24,133.62 252.93,133.94 252.31,133.94 252.21,133.83 v2(252.21,133.28)
ADDR0: length 2.4
  TOP w0.14: U24.36 21.61,65.7 22.1,66.19 22.1,66.37 v1(22.23,66.5) R456.1
ADDR1: length 2.3
  TOP w0.14: R465.1 22.81,66.46 21.65,65.3 U24.35
ADOGND: length 156.9
  TOP w0.203: C397.1 313.77,71.37 C405.1 ; U20.22 313.75,62.8 314.23,62.31 v1(314.23,61.9)
  TOP w0.508: C397.1 314.62,72.23 315.17,72.23 v1(315.2,72.26)
  IN3 w0.508: v1(300.06,61.73) 299.08,61.73 298.41,61.05 297.69,61.05 296.29,62.45 296.29,64.58 295.58,66.31 293.52,68.37 288.93,68.37 286.31,65.74 286.31,60.39 286.57,60.14 286.57,57.75 285.71,56.89 285.71,54.15 283.39,51.83 278.89,51.83 278.12,51.06 274.03,51.06 273.68,50.7 270.51,50.7 267.45,47.64 259.21,47.64 258.58,48.27 258.58,49.83 257.58,50.83 249.6,50.83 249.19,50.42 244.3,50.42 241.82,47.94 240.78,47.94 240.4,47.56 238.25,47.56 237.56,46.86 225.68,46.86 221.96,43.14 219.84,43.14 219.7,43.01 214.5,43.01 213.24,41.75 212.37,41.75 211.86,41.24 211.39,41.24 210.47,40.32 198.07,40.32 196.35,42.05 192.43,42.05 192.23,41.85 191.34,41.85 188.66,44.53 v1(186.98,44.53)
  BOTTOM w0.254: v1(186.98,44.53) 186.65,44.86 CN19.3
  BOTTOM w0.381: R950.1 313.49,73.89 313.92,74.32 C749.1 ; C755.1 315.2,72.27 v1(315.2,72.26)
  BOTTOM w0.508: C749.1 314.85,74.32 315.35,73.81 v1(315.35,72.96) ; R1151.1 190.02,47.27 190.53,46.76 190.53,45.57 189.48,44.53 v1(186.98,44.53)
  vias: v1(301.36,60.32) v1(301.7,61.86) v1(302.08,60.36) v1(302.48,59.61) v1(303.65,59.62) v1(305.2,59.63) v1(307.16,59.62) v1(314.25,61.23) v1(314.49,59.72) v1(314.9,61.5) v1(315.06,69.82) v1(315.05,63.71) v1(315.27,69.15) v1(315.7,63.44) v1(317.76,68.66) v1(318.48,63.06) v1(319.92,66.97) v3(299.34,58.26) v3(301.73,58.22) v3(304.27,58.22) v3(306.81,58.22) v3(309.35,58.22) v3(311.89,58.22) v3(314.43,58.22) v3(316.97,58.22) v3(319.51,58.22) v3(322.05,58.22) v3(322.38,68.35) v3(322.38,65.81) v3(322.38,63.27) v3(322.38,60.73)
ADP1_DET: length 166.2
  TOP w0.14: v1(185.07,64.83) 185,64.9 U23.80 ; v1(198.23,203.15) 198.5,203.42 198.82,203.42 198.96,203.56 PR96.1 198.96,204.48 198.46,204.98 PQ8.3
  IN2 w0.089: v1(187.48,169.18) 187.56,169.25 187.56,182.86 200.07,195.37 200.07,198.94 198.23,200.78 v1(198.23,203.15)
  IN3 w0.089: v1(187.48,169.18) 187.53,169.13 187.83,169.13 189.15,167.81 189.15,153.01 189.88,152.27 189.88,111.63 193.5,108.02 193.5,105.73 194.17,105.05 194.17,89.58 193.15,88.56 193.15,78.84 193,78.69 193,64.36 193.51,63.85 193.51,61.88 192.95,61.31 188.22,61.31 187.34,62.19 187.34,63.14 185.65,64.83 v1(185.07,64.83)
ADP1_SW: length 58.8
  TOP w0.508: v1(197.49,203.14) 197.26,203.14 196.98,203.42 PR95.1
  IN2 w0.508: v1(179.23,181.34) 179.23,183.51 182.4,186.68 182.4,188.89 177.98,193.31 v1(177.98,194.53) 179.4,195.95 188.24,195.95 189.89,194.3 v1(196.78,194.3) 198.43,194.3 199.67,195.54 199.67,198.77 197.49,200.95 v1(197.49,203.14)
  BOTTOM w0.508: PR502.1 178.28,180.9 178.72,181.34 v1(179.23,181.34) ; PR476.2 199.07,194.25 199.05,194.28 PR475.2 196.8,194.28 v1(196.78,194.3) ; PR468.2 v1(177.98,194.53) ; v1(197.49,203.14) 197.23,203.39 197.23,204.18 196.63,204.78 195.67,204.78 195.17,205.28 PR412.2
ADP2_DET: length 218.6
  TOP w0.508: PQ10.3 228.23,204.63 v1(228.23,204.88)
  IN3 w0.508: v1(161.9,67.32) 161.9,67.63 162.41,68.14 163.13,68.14 163.74,67.53 165.05,67.53 165.34,67.82 170.58,67.82 171,67.4 177.83,67.4 179.08,66.15 183.04,66.15 184.33,64.86 184.33,63.63 184.9,63.06 186.41,63.06 186.94,62.53 186.94,61.16 187.53,60.57 188.25,60.57 188.6,60.91 192.93,60.91 193.38,60.47 194.09,60.47 194.6,60.98 194.6,61.41 194.1,61.91 194.1,64.1 193.59,64.61 193.59,78.45 193.74,78.6 193.74,88.32 194.76,89.33 194.76,105.3 194.29,105.77 194.29,108.16 190.47,111.97 190.47,152.52 189.74,153.25 189.74,165.66 192,167.92 192,169.7 193.42,171.13 193.42,175.75 198.74,181.06 204.18,181.06 205.51,182.4 205.51,183.17 209.72,187.37 211.88,187.37 215.01,190.5 225.56,190.5 226.84,191.79 226.84,194.84 225.8,195.89 225.8,202.62 226.59,203.4 227.7,203.4 228.23,203.93 v1(228.23,204.88)
  BOTTOM w0.508: v1(162.01,63.98) 161.15,64.84 161.15,65.68 161.67,66.2 161.67,66.74 161.9,66.97 v1(161.9,67.32)
ADP2_SW: length 75.6
  TOP w0.508: v1(229.78,203.79) 229.78,204.01 230.09,204.33 PR93.2
  IN1 w0.508: v1(215.65,195.09) 219.03,198.47 220.44,198.47 224.95,202.98 229.08,202.98 229.78,203.67 v1(229.78,203.79)
  IN3 w0.508: v1(177.63,181.5) 177.88,181.76 177.88,182.02 179.42,183.56 186.16,183.56 194.39,191.79 206.61,191.79 207.16,192.34 211.18,192.34 212.32,193.49 214.05,193.49 v1(215.65,195.09)
  BOTTOM w0.508: PR411.1 229.96,203.97 v1(229.78,203.79) ; v1(177.63,181.5) 177.63,181.34 177.14,180.86 PR503.1 ; v1(215.65,195.09) PR471.2 214.23,195.09 213.08,193.94 211.47,193.94 210.74,194.68 PQ56.3 207.42,194.68 206.07,193.32
ADP_ID1: length 6.3
  TOP w0.14: PJ8.4 192.15,211.42 194.6,208.97 v1(194.6,207.87) PQ6.1
ADP_ID2: length 25.8
  IN1 w0.086: PJ9.4 220.15,213.05 221.06,213.96 221.06,214.67 221.87,215.48 222.28,215.48 222.89,214.87 226.04,214.87 227.26,213.65 227.26,210.5 227.79,209.97 227.79,208.78 228.8,207.77 231.94,207.77 234.05,205.66 234.05,204.61 v1(234.13,204.53)
  BOTTOM w0.14: v1(235.17,205.15) PQ40.1 234.05,204.61 v1(234.13,204.53)
ADRS0: length 3.1
  TOP w0.14: PR10.2 229.75,214.87 229.51,214.63 v1(229.33,214.63) 229.19,214.49 PU2.21
  BOTTOM w0.14: v1(229.33,214.63) 229.76,214.2 PR368.2
ADRS1: length 6
  TOP w0.14: PR3.1 228.99,216.15 PR7.2 227.87,215.85 PR15.1 227.87,215.14 228.23,214.77 228.59,214.77 v1(228.68,214.68) 228.79,214.58 PU2.22
  BOTTOM w0.14: PC292.1 228.26,214.68 v1(228.68,214.68) 228.68,214.77 228.48,214.97 v1(228.48,215.99)
AFS: length 1.7
  BOTTOM w0.14: v1(273.78,209.82) 274.22,210.25 274.22,210.64 274,210.86 U36.28
  vias: v1(273.05,210.53)
AMP_MUTE#: length 198.3
  TOP w0.14: v1(303.84,80.79) 303.88,80.79 304.11,81.01 307.53,81.01 308.34,80.21 D21.1 ; v1(281.13,69.51) 281.13,69.46 282.23,68.36 282.23,67.25 284.11,65.37 285.37,65.37 288.71,68.7 D37.1 288.71,69.81 288.65,69.87 288.65,71.11 288.16,71.6 R418.1 ; v1(178,59.15) 177.41,59.15 176.25,60.3 176.25,61.41 177.28,62.44 177.28,63.64 178.13,64.48 178.13,65.62 177.01,66.75 177.01,70.54 177.51,71.04 U23.108
  IN2 w0.089: v1(303.84,80.79) 303.84,79.79 303.26,79.21 301.5,79.21 300.99,79.72 299.01,79.72 298.25,78.96 295.87,78.96 294.98,79.85 291.38,79.85 290.28,78.75 289.45,78.75 288.91,78.21 287.62,78.21 283.41,74 283.41,71.07 282.21,69.87 281.49,69.87 v1(281.13,69.51) 281.13,69.03 280.29,68.19 280.29,67.51 281,66.8 281,62.93 281.57,62.36 281.57,58.97 280.44,57.84 279.56,57.84 277.99,56.27 277.99,55.21 277.17,54.38 277.17,54.32 274.29,51.43 270.07,51.43 267.98,49.35 256.98,49.35 256.59,49.73 255.43,49.73 254.85,49.15 248.11,49.15 247.35,48.39 242.35,48.39 241.56,47.6 238.16,47.6 238,47.44 229.33,47.44 229.17,47.6 225.68,47.6 222.43,44.34 211.59,44.34 210.15,42.91 209.43,42.91 209.22,43.12 204.64,43.12 204.24,43.52 197.88,43.52 197.28,44.11 193.17,44.11 192.85,44.44 192.45,44.44 186.43,50.45 186.43,52.08 183.58,54.93 183.06,54.93 180.65,57.34 179.81,57.34 v1(178,59.15)
ASEL: length 3.1
  TOP w0.14: R535.1 298.19,60.51 299.14,61.45 R518.1 299.14,62.04 299.42,62.32 U21.14
AUD_AZACPU_SCLK: length 94.8
  IN2 w0.089: v1(215.62,86.5) 215.53,86.59 215.53,86.89 215.24,87.18 215.24,92.81 215.08,92.98 215.08,94.11 214.85,94.34 214.34,94.34 214.12,94.56 214.12,95.21 211.63,97.69 210.69,97.69 210.25,97.25 209.78,97.25 208.01,99.02 208.01,101.25 206.92,102.34 205.23,102.34 204.94,102.63 204.94,104.07 202.68,106.32 202.68,108.91 199.9,111.69 197.27,111.69 183.57,125.4 183.57,147.28 v1(179.78,151.07)
  BOTTOM w0.14: v1(215.62,86.5) 215.68,86.44 215.7,86.44 215.71,86.43 215.72,86.43 216.43,85.72 216.43,85.29 216.72,85 C728.1 216.72,83.4 216.77,83.35 R905.2 ; R795.1 180.14,151.42 v1(179.78,151.07) 179.78,150.93 177.83,148.98 176.37,148.98 175.85,148.45 U42.B32
AUD_AZACPU_SCLK_R: length 4.7
  BOTTOM w0.102: U49.AJ3 215.71,78.68 215.71,81.46 216.77,82.52 R905.1
AUD_AZACPU_SDI: length 91.7
  IN2 w0.089: v1(184.04,145.35) 184.05,145.34 184.05,125.58 197.47,112.16 200.1,112.16 203.15,109.11 203.15,106.52 203.54,106.13 204,106.13 208.48,101.64 208.48,99.29 209.53,98.24 211.82,98.24 215.55,94.52 215.55,93.17 215.71,93.01 215.71,87.38 215.97,87.12 216.45,86.64 v1(216.45,86.31)
  BOTTOM w0.102: 217.07,84.17 216.94,84.04 216.94,83.6 217.11,83.44 217.11,82.58 215.91,81.38 215.91,78.19 U49.AK4
  BOTTOM w0.14: 217.07,84.17 217.45,84.55 217.45,85.74 216.88,86.31 v1(216.45,86.31) ; v1(184.04,145.35) 183.78,145.61 183.09,145.61 182.55,146.14 182.55,146.5 182.24,146.81 v1(182.24,148.81) 182.24,149.35 R796.1
AUD_AZACPU_SDI_R: length 5.4
  BOTTOM w0.14: R796.2 v1(180.23,150.16) 178.52,148.45 U42.A32
AUD_AZACPU_SDO: length 89.6
  IN2 w0.089: v1(183.1,145.14) 183.09,145.13 183.09,125.21 197.08,111.22 199.71,111.22 202.21,108.72 202.21,107.52 202.12,107.43 201.69,107.43 201.6,107.34 201.6,107.16 201.69,107.08 202.12,107.08 202.21,106.99 202.21,106.13 202.46,105.89 202.46,105.76 202.23,105.54 202.23,105.41 202.36,105.28 202.48,105.28 202.71,105.51 202.83,105.51 202.96,105.38 202.96,105.26 202.73,105.03 202.73,104.91 202.86,104.78 202.98,104.78 203.21,105.01 203.34,105.01 203.46,104.88 203.46,104.76 203.24,104.53 203.24,104.4 203.36,104.28 203.49,104.28 203.71,104.5 203.84,104.5 204.47,103.87 204.47,102.44 205.03,101.87 206.72,101.87 207.54,101.05 207.54,98.83 209.59,96.78 210.63,96.78 211.06,96.35 211.3,96.35 211.54,96.11 211.88,96.11 214.61,93.38 214.61,92.78 214.77,92.62 214.77,86.54 215.08,86.23 215.71,85.6 v1(215.71,85.45)
  BOTTOM w0.102: 177.5,147.91 176.66,147.91 U42.A31
  BOTTOM w0.14: R885.2 215.83,85.33 v1(215.71,85.45) ; v1(183.1,145.14) 183.08,145.12 182.65,145.12 v1(181.74,146.04) 181.74,146.77 180.86,147.65 R797.1 180.49,147.54 180.19,147.54 179.81,147.91 177.5,147.91
AUD_AZACPU_SDO_R: length 7.6
  BOTTOM w0.102: U49.AJ5 215.17,77.84 215.04,77.97 215.04,78.26 215.2,78.42 215.2,78.83 215.3,78.94 215.3,81.63 216.14,82.47 216.14,82.79
  BOTTOM w0.14: 216.14,82.79 216.14,84.22 R885.1
B_CTL: length 705.1
  TOP w0.254: R302.1 296.83,80.23 297.08,79.97 297.95,79.97 298.24,79.67 Q36.2 298.24,78.66 298.48,78.42 298.48,77.17 v1(298.35,77.05)
  IN2 w0.254: v1(34.14,36.87) 34.27,36.74 44.33,36.74 45.84,38.25 45.84,44.75 48.1,47.02 56.77,47.02 60.31,43.47 71.88,43.47 72.83,42.53 78.49,42.53 78.79,42.23 79.95,42.23 80.63,41.55 85.68,41.55 89.29,45.15 89.29,47.64 93.83,52.18 100.86,52.18 104.76,56.08 108.8,56.08 109.03,55.85 111.14,55.85 113.56,58.28 118.6,58.28 119.74,59.42 122.53,59.42 123.82,60.71 132.61,60.71 133.28,61.37 145.01,61.37 145.23,61.58 149.41,61.58 150.23,62.4 157.75,62.4 158.06,62.09 158.42,62.09 161.01,59.5 162.91,59.5 164.65,57.77 165.14,57.77 166.21,56.7 169.69,56.7 171.41,54.98 173.03,54.98 174.63,53.38 177.75,53.38 180.85,50.29 180.85,48.62 184.31,45.15 187.04,45.15 191.26,40.93 202.14,40.93 202.61,40.46 206.18,40.46 206.23,40.42 209.5,40.42 209.78,40.13 219.39,40.13 220.86,41.59 227.14,41.59 228.78,43.23 228.78,44.56 229.7,45.48 238.05,45.48 238.34,45.19 240.34,45.19 241.52,44.02 242.1,44.02 243.83,45.75 244.99,45.75 245.71,45.03 245.71,40.53 246.9,39.34 246.9,38.86 247.47,38.29 249.02,38.29 250.37,36.95 255.25,36.95 258.67,40.37 258.67,43.11 259.64,44.08 261.75,44.08 262.03,43.8 266.86,43.8 268.74,45.68 268.74,46.15 271.51,48.93 274.56,48.93 278.81,53.18 281.14,53.18 281.86,53.9 281.86,54.95 285.29,58.38 285.29,60.8 284.13,61.96 284.13,62.79 282.97,63.95 282.97,67.85 285.4,70.28 285.4,72.68 286.53,73.81 286.53,74.32 287.48,75.27 290.45,75.27 292.36,77.18 297.28,77.18 297.49,76.98 298.28,76.98 v1(298.35,77.05)
  IN3 w0.254: v1(169.59,213.38) 170.18,213.38 173.17,210.39 173.17,207.08 173.92,206.34 173.92,205.22 174.6,204.53 175.85,204.53 177.57,206.26 179.58,206.26 181.23,204.61 189.94,204.61 190.7,203.85 193.37,203.85 194.94,205.41 194.94,207.09 196.22,208.37 199.52,208.37 201.81,206.08 201.81,205.6 202.59,204.81 213.13,204.81 213.64,205.32 219.46,205.32 220.04,204.74 221.19,204.74 221.59,205.14 221.59,210.81 221.11,211.29 221.11,213.32 221.49,213.7 222.51,213.7 223.02,213.2 226.19,213.2 226.56,212.83 227.07,212.83 228.35,214.11 231.14,214.11 v1(231.35,213.91) ; v1(243.64,217.9) 243.64,217.76 244.83,216.58 246.52,216.58 247.54,217.59 250.21,217.59 250.85,218.24 253.49,218.24 253.99,217.74 258.91,217.74 259.58,217.08 262.5,217.08 264.11,218.69 279,218.69 279.99,217.7 279.99,217.06 278.23,215.3 278.23,212.93 280.03,211.13 282.07,211.13 284.19,209.01 284.19,204.93 284.66,204.46 284.66,201.72 286.69,199.68 286.69,185.36 286.03,184.7 286.03,184.09 286.69,183.43 286.69,155.09 282.78,151.17 282.78,118.59 283.55,117.83 283.55,117.59 286.7,114.44 286.7,113.82 287.98,112.54 v1(288.73,112.54)
  IN4 w0.254: v1(243.64,217.9) 245.07,216.48 245.07,212.08 244.18,211.19 244.18,210.23 243.59,209.64 243.59,209.53 242.89,208.83 241.46,208.83 240.09,207.46 236.88,207.46 236.35,207.99 236.35,209.75 233.13,212.97 233.13,213.26 232.49,213.91 v1(231.35,213.91) ; v1(288.73,112.54) 288.73,112.42 293.29,107.86 296.33,107.86 297.73,106.46 297.73,105.47 300.92,102.28 300.92,100.48 301.34,100.05 302.53,100.05 302.9,100.42 304.02,100.42 304.38,100.06 304.9,100.06 305.18,99.78 305.53,99.78 306.03,99.28 310.5,99.28 311.01,98.77 314.2,98.77 314.69,99.26 316.98,99.26 319.41,96.83 319.41,93.95 316.58,91.12 313.92,91.12 312.51,89.71 311.06,89.71 310.41,89.05 310.41,87.95 310.15,87.7 309.08,87.7 307.59,86.22 307.59,82.71 303.59,78.71 301.61,78.71 300.77,77.86 299.17,77.86 v1(298.35,77.05)
  BOTTOM w0.254: Q77.3 148.72,209.43 149.14,209.01 R710.2 151.41,209.01 151.49,208.93 R709.1 151.82,208.72 152.71,207.84 157.99,207.84 160.37,210.21 163.24,210.21 163.39,210.36 Q76.2 165.34,210.36 165.66,210.68 167.06,210.68 169.59,213.21 v1(169.59,213.38)
B_CTL_LOGO: length 118.4
  TOP w0.14: U1.30 150.41,205.79 151.77,207.15 151.77,207.66 150.35,209.08 150.35,210.3 v1(150.85,210.81) ; Q127.2 247.05,209.47 246.79,209.2 R1217.1 246.07,209.2 245.54,208.67 236.81,208.67 v1(236.17,208.04) 236.17,207.81 235.56,207.2 v1(235.38,207.2)
  IN3 w0.089: v1(150.85,210.81) 151.97,210.81 152.99,209.79 153.19,209.79 154,208.98 158.14,208.98 162.1,212.94 166.3,212.94 167.21,212.03 167.82,212.03 171.48,208.37 171.48,207.25 173,205.73 173,203.9 173.87,203.04 177.73,203.04 177.85,202.91 188.34,202.91 189.21,202.05 194.95,202.05 195.92,203.01 196.62,203.01 196.98,202.65 199.77,202.65 200.03,202.91 216.03,202.91 216.49,203.37 218.87,203.37 219.26,202.99 221.95,202.99 223.27,204.31 226.19,204.31 226.83,204.94 226.83,206.72 227.33,207.23 231.27,207.23 231.4,207.35 232.16,207.35 232.29,207.23 232.67,207.23 233.51,208.07 234.37,208.07 235.23,207.2 v1(235.38,207.2)
B_CTL_LOGO_C: length 26.9
  TOP w0.508: v1(251.59,207.43) 251.26,207.43 250.83,207.86 R1214.1
  IN3 w0.508: v1(265.18,197.57) 264.54,198.21 264.54,202.53 266.2,204.18 266.2,206.59 265,207.79 260.71,207.79 260.28,207.35 253.88,207.35 253.37,206.85 252.17,206.85 v1(251.59,207.43)
B_CTL_MCU: length 26
  TOP w0.203: U1.23 148.2,202.44 148.42,202.22
  TOP w0.254: 148.42,202.22 148.58,202.06 v1(149.43,202.06)
  BOTTOM w0.254: R712.2 148.82,207.64 149.31,208.13 Q77.2 150.13,208.13 150.55,208.56 R710.1 151.29,208.56 152.59,207.25 156.95,207.25 157.31,206.89 157.31,202.02 156.34,201.04 151.81,201.04 151.62,200.85 150.64,200.85 149.43,202.06 v1(149.43,202.06)
B_CTL_TURBO: length 2.8
  BOTTOM w0.254: v1(275.82,192.59) R734.1 274.57,192.59 273.72,191.74 Q86.2
B_CTL_TURBO_C: length 149.7
  TOP w0.203: U1.25 149.96,203.79
  TOP w0.254: 149.96,203.79 152.87,203.79 153.16,203.51 v1(159.57,203.51) ; CN1.13 265.44,195.55 264.54,194.65 264.54,194.04 v1(264.65,193.94)
  IN1 w0.254: v1(163.99,201.97) 164.09,202.08 164.09,205.15 164.64,205.69 166.05,205.69 166.45,206.09 166.93,206.09 167.38,205.65 168.2,205.65 169.27,204.58 170.04,204.58 172.34,202.28 172.34,200.34 175.66,197.02 176.64,197.02 179.24,194.42 180.87,194.42 181.28,194 181.38,193.91 185.4,193.91 190.46,188.85 200.4,188.85 201.47,189.93 206.2,189.93 208.13,188 211.74,188 212.8,189.06 219.77,189.06 220.21,189.5 222.58,189.5 223.21,188.86 237.71,188.86 237.98,189.13 241.51,189.13 242.19,189.8 249.87,189.8 250.51,189.16 261.49,189.16 264.65,192.32 v1(264.65,193.94) 264.57,194.02 264.57,194.38 264.95,194.76 266.17,194.76 266.78,194.15 266.78,193.4 267.41,192.77 271.62,192.77 v1(271.99,193.13)
  BOTTOM w0.254: v1(159.57,203.51) 161.61,203.51 163.15,201.97 v1(163.99,201.97) ; v1(271.99,193.13) 272.01,193.13 272.37,192.77 273.15,192.77 273.41,193.03 273.41,193.61 273.98,194.19 R729.1
B_CTRL_LEFT: length 54.7
  TOP w0.508: R330.1 292.51,77.59 291.62,76.7 v1(291.62,75.63)
  IN3 w0.508: v1(262.15,49.99) 262.34,49.99 263.96,51.61 265.64,51.61 266.5,52.47 267.62,52.47 267.91,52.17 270.12,52.17 270.37,51.92 273.17,51.92 273.53,52.28 277.62,52.28 278.39,53.05 281.8,53.05 284.49,55.75 284.49,57.4 285.35,58.26 285.35,59.63 285.09,59.89 285.09,63.39 283.6,64.88 283.6,67.21 284.6,68.21 284.6,68.48 288.22,72.1 289.26,72.1 291.47,74.3 291.47,75.48 v1(291.62,75.63)
  BOTTOM w0.508: v1(262.15,49.99) CN14.4
B_CTRL_RIGHT: length 4
  TOP w0.508: R650.1 39.42,37.41 v1(40.3,38.28) 40.65,38.64 v1(41,38.64)
  BOTTOM w0.508: CN22.4 40.5,38.13 v1(41,38.64)
B_DE: length 3.6
  BOTTOM w0.14: R1156.1 277.73,46.82 277.57,46.98 276.41,46.98 276.26,46.83 R1155.2 U55.8
B_EQ1: length 3.9
  BOTTOM w0.14: R1135.1 R1136.2 268.64,48.22 268.78,48.08 269.28,48.08 269.36,48.16 269.79,48.16 270.38,47.57 U55.20
B_EQ2: length 4
  BOTTOM w0.14: U55.17 269.35,46.07 R1165.2 269.09,45.6 268.87,45.38 268.33,45.38 268.32,45.37 267.91,45.37 267.56,45.72 R1164.1
BAT-V: length 20.1
  TOP w0.508: PD3.2 43.45,49.81 43.44,49.82 v1(43.44,49.84)
  BOTTOM w0.508: v1(43.44,49.84) 44.37,50.77 46.37,50.77 48.94,53.34 57.3,53.34 57.64,53.01 58.16,53.01 58.95,52.22 58.95,50.29
  vias: v1(68.71,45.61) v3(60.41,45.19) v3(60.53,44.01) v3(61.2,44.37) v3(62.15,46.04) v3(62.13,45.25) v3(62.15,44.4) v3(62.8,44.89) v3(63.47,44.49) v3(64.36,44.49) v3(64.54,45.27) v3(65.16,44.48) v3(65.91,44.89) v3(66.44,45.49) v3(66.75,44.54) v3(67.62,44.47) v3(68.5,44.45)
BATLED0#: length 258.5
  TOP w0.14: v1(170.46,61.95) 170.01,61.95 169.65,61.58 169.65,60.72 169.02,60.1 U23.29 ; v1(265.26,191.02) 265.26,191 265.7,190.55 CN1.23 266.95,190.55 268.01,189.49 D7.1
  IN3 w0.089: v1(170.46,61.95) 171.11,62.6 172.37,62.6 172.53,62.44 172.86,62.44 173.85,63.43 176.38,63.43 177.96,61.85 181.02,61.85 181.56,61.32 183.61,61.32 185.18,59.75 186.74,59.75 187.88,58.62 188.55,58.62 188.85,58.32 189.42,58.32 189.77,58.68 191.78,58.68 192.82,59.72 194.18,59.72 195,60.54 195,61.58 194.5,62.08 194.5,64.26 194.32,64.45 193.99,64.77 193.99,78.28 194.14,78.43 194.14,88.15 195.16,89.17 195.16,101.78 195.92,102.55 196.98,102.55 198.22,103.79 198.8,103.79 200.74,105.73 201.86,105.73 202.15,106.03 202.15,106.49 201.55,107.1 201.55,113.62 209.2,121.27 213.86,121.27 215.06,122.47 223.21,122.47 226.51,125.76 238.49,125.76 239.57,126.84 242.73,126.84 243.95,125.63 243.95,122.16 245.07,121.04 245.51,121.04 245.86,120.69 246.66,120.69 247.71,119.64 250.47,119.64 252.25,121.41 252.25,122.42 252.68,122.85 252.68,123.2 254.52,125.05 257.77,125.05 261.61,128.89 266.4,128.89 268.72,131.2 271.29,131.2 275.87,135.78 275.87,137.4 278.43,139.97 278.43,152.92 280.14,154.63 280.14,185.92 278.16,187.91 269.96,187.91 269.18,187.12 268.22,187.12 267.5,186.41 267.16,186.41 266.7,186.86 266.7,189.57 v1(265.26,191.02)
BATLED1#: length 260.7
  TOP w0.14: CN1.24 266.95,190.05 267.59,189.41 267.59,188.12 267.77,187.94 267.99,187.94 268.13,187.8 D8.1 267.88,187.42 267.73,187.42 267.34,187.03 v1(267.34,186.81) ; R538.2 162.21,60.63 162.21,61.93 v1(161.94,62.2)
  IN3 w0.089: v1(161.94,62.2) 162.54,62.8 168.35,62.8 168.72,62.43 169.41,62.43 170.3,61.54 170.7,61.54 171.57,62.41 172.29,62.41 172.45,62.25 172.94,62.25 173.93,63.24 176.3,63.24 177.88,61.66 180.94,61.66 181.48,61.13 183.53,61.13 185.1,59.56 186.66,59.56 187.8,58.42 188.47,58.42 188.77,58.13 189.5,58.13 189.85,58.49 191.85,58.49 192.9,59.53 194.26,59.53 195.19,60.46 195.19,61.66 194.69,62.16 194.69,64.34 194.19,64.85 194.19,78.2 194.33,78.35 194.33,88.07 195.35,89.09 195.35,101.71 196,102.36 197.06,102.36 198.3,103.59 198.99,103.59 200.93,105.54 201.94,105.54 202.34,105.95 202.34,106.57 201.74,107.18 201.74,113.54 209.28,121.08 213.94,121.08 215.14,122.28 223.34,122.28 226.63,125.57 237.33,125.57 241.05,121.86 243.15,121.86 244.16,120.85 245.43,120.85 245.78,120.5 246.58,120.5 247.63,119.44 250.55,119.44 252.44,121.33 252.44,122.34 252.87,122.77 252.87,123.12 254.6,124.85 259.6,124.85 260.4,125.65 260.4,126.41 261.3,127.31 261.3,128.19 261.8,128.7 266.48,128.7 268.8,131.01 271.37,131.01 276.06,135.7 276.06,137.23 278.68,139.86 278.68,152.91 280.33,154.56 280.33,186 278.24,188.1 269.88,188.1 269.29,187.5 268.04,187.5 v1(267.34,186.81)
BATLOW#: length 6
  BOTTOM w0.102: 214.36,53.25 214.36,53.78 214.18,53.96 214.18,54.76 214.02,54.92 214.02,55.87 214.32,56.17 214.32,57.46 U49.AG45
  BOTTOM w0.14: R1080.2 214.47,52.17 214.47,52.93 214.36,53.04 214.36,53.25
BATTERY_LEARN: length 159.6
  TOP w0.14: v1(191.89,64.89) 191.71,65.08 190.79,65.08 190.37,64.65 189.73,64.65 189.43,64.95 187.69,64.95 187.43,64.69 185.91,64.69 185.59,64.37 184.98,64.37 184.3,63.7 U23.77
  IN3 w0.089: v1(207.83,191.56) 207.83,186.72 207.62,186.51 207.62,186.1 207.05,185.53 205.47,185.53 203.67,187.33 200.62,187.33 195.77,182.48 195.77,179.35 192.54,176.12 192.54,173.57 188.83,169.86 187.59,169.86 187.08,169.35 187.08,164.84 188.31,163.61 188.31,152.9 189.18,152.02 189.18,111.38 192.82,107.74 192.82,105.45 193.5,104.77 193.5,89.86 192.48,88.84 192.48,79.12 192.28,78.92 192.28,72.72 191.08,71.52 191.08,70.62 190.21,69.75 190.21,66.72 191.89,65.03 v1(191.89,64.89)
  BOTTOM w0.14: v1(207.83,191.56) 208.95,192.68 PQ56.2 210.27,192.68 210.41,192.54 R735.2
BEEP1: length 6.1
  TOP w0.14: R394.1 321.09,73.21 v1(321.09,74.46) 321.27,74.64 321.27,75.58 321.08,75.76 D26.1 320.17,75.76 320.03,75.9 320.03,76.24 319.89,76.38 319.21,76.38 D25.1
BEEP3: length 5.8
  TOP w0.14: C423.2 320.5,69.28 318.98,67.77 316.35,67.77 316.28,67.83 U20.34
BFS: length 1.6
  BOTTOM w0.14: U36.27 274.4,210.95 274.5,210.85 274.5,209.81 v1(274.44,209.75)
BI: length 242.2
  TOP w0.14: v1(212.73,41.14) 212.28,41.58 212.28,42.25 216.44,46.41 219.02,46.41 219.98,47.37 233.66,47.37 235.55,49.26 235.55,51.87 234.81,52.61 234.81,54.34 236.59,56.12 244.85,56.12 246.94,54.03 248.84,54.03 250.46,52.41 R615.1 ; PR329.2 71.38,43.84 v1(71.6,44.06)
  IN1 w0.086: v1(212.73,41.14) 212.59,41.28 211.6,41.28 211.07,40.75 200.67,40.75 200.04,41.37 196.18,41.37 195.72,41.84 194.65,41.84 193.62,40.81 192.15,40.81 191.45,40.11 186.22,40.11 183.86,42.46 183.86,47.9 184.55,48.59 184.55,50.99 188.19,54.63 188.19,55.06 187.89,55.36 187.34,55.36 186.72,54.74 172.83,54.74 172.32,54.22 172.32,54.01 171.78,53.48 171.02,53.48 170.38,54.12 170.38,56.71 168.76,58.33 167.77,58.33 v1(167.33,57.89)
  IN3 w0.089: v1(71.6,44.06) 71.54,44 71.54,42.64 71.84,42.34 72.39,42.34 72.46,42.41 76.2,42.41 76.71,42.92 76.71,49.77 78.62,51.68 98.94,51.68 103.4,56.14 106.99,56.14 107.45,55.69 107.45,55.24 107.91,54.78 113.44,54.78 113.67,55.01 117.95,55.01 120.61,57.67 122.72,57.67 124.39,59.34 143.16,59.34 143.25,59.25 v1(143.25,59.12)
  IN4 w0.086: v1(143.25,59.12) 144.75,57.62 149.18,57.62 151.33,59.77 151.33,60.37 151.66,60.69 152.21,60.69 152.82,60.09 157.89,60.09 158.22,60.43 159.87,60.43 160.57,59.73 162.57,59.73 163.92,58.37 166.85,58.37 v1(167.33,57.89)
  BOTTOM w0.14: v1(71.6,44.06) 69.55,46.12 PJ19.7
BI_GATE:
  vias: v1(257.34,49.92) v1(257.75,50.73)
BIT_CLK_AUDIO: length 124.4
  TOP w0.14: v1(309.26,60.55) 309.34,60.63 R525.2
  IN2 w0.089: v1(232.88,57.03) 236.48,57.03 236.9,56.6 238.28,56.6 239.24,55.65 240,55.65 240.7,54.95 244.32,54.95 244.43,55.07 246.68,55.07 247.49,55.87 253.87,55.87 254.28,55.47 263.26,55.47 265.62,57.83 269.63,57.83 271.8,60 271.8,61.39 272.81,62.4 274.17,62.4 275.58,63.8 275.58,68.31 277.71,70.45 277.71,73.28 279.05,74.62 279.05,74.95 279.98,75.88 281.9,75.88 284.35,78.33 284.61,78.33 285.98,79.7 285.98,80.46 286.25,80.73 289.46,80.73 290.56,81.83 294.67,81.83 295.31,82.47 296.95,82.47 297.27,82.16 297.97,82.16 298.47,82.67 300.97,82.67 301.89,81.74 302.51,81.74 303.11,82.34 303.11,82.82 303.35,83.06 303.91,83.06 304.39,82.58 304.39,78.73 305.06,78.07 305.06,76.54 304.39,75.88 304.39,74.87 304.93,74.33 304.93,73.22 305.05,73.1 305.05,71.76 305.64,71.17 305.64,65.17 306.42,64.39 306.42,61.8 307.47,60.75 308.21,60.75 308.43,60.97 308.84,60.97 v1(309.26,60.55)
  BOTTOM w0.102: v1(232.88,57.03) 232.61,57.3 232.61,57.86 232.03,58.44 232.03,59.99 231.88,60.13 231.37,60.13 230.36,59.12 229.71,59.12 229.59,59.01 R1021.1
BIT_CLK_AUDIO_U: length 3.2
  TOP w0.14: C484.1 R525.1 309.65,61.81 309.65,62.19 309.86,62.4 310.16,62.4 310.55,62.78 U20.14
BKL_PWM_GFX: length 9.5
  TOP w0.14: U4.6 283.6,178.73 283.75,178.57 v1(285.04,178.57) 285.47,178.14 285.47,173.04 285.62,172.89 R87.2 285.42,172.32 QG2.6
BL_ON: length 20.3
  TOP w0.14: CN2.33 271.46,187.35 v1(271.79,187.02)
  IN2 w0.089: v1(272.6,195.85) 272.6,192.85 271.93,192.19 271.93,190.94 272.27,190.61 272.27,187.5 v1(271.79,187.02)
  BOTTOM w0.14: U40.4 272.85,201.35 272.65,201.15 271.6,201.15 270.72,200.27 v1(270.72,199.34) 270.72,196.81 271.1,196.43 272.01,196.43 v1(272.6,195.85)
BOARD_ID0_R: length 12.3
  TOP w0.14: CN2.31 271.79,188.35 272.6,187.54 272.6,186.41 273.24,185.76 276.99,185.76 v1(277.12,185.64) 277.24,185.51 278.56,185.51 278.84,185.8 C32.1 278.84,186.34 278.98,186.48 279.28,186.48 279.42,186.34 R72.2
BOARD_ID1_R: length 11.9
  TOP w0.14: R73.2 C33.1 278.84,184.74 278.47,184.37 v1(277.12,184.37) 276.23,184.37 275.11,185.48 273.13,185.48 272.26,186.35 272.26,187.48 272,187.75 271.07,187.75 270.97,187.85 CN2.32
BRD_ID0: length 236.5
  TOP w0.14: v1(278.05,135.32) 279.57,136.83 279.57,155.69 280.18,156.31 280.18,185.22 279.87,185.53 R72.1
  IN1 w0.086: v1(278.05,135.32) 280.47,132.9 280.47,119.21 282.76,116.92 283.1,116.92 285.25,114.76 286.13,114.76 286.56,114.33 286.56,113.87 288.07,112.36 288.07,112.06 288.96,111.17 288.96,110.47 293.62,105.81 293.62,95.23 v1(293.49,95.1)
  IN3 w0.089: v1(207.27,47.28) 207.5,47.52 209.07,47.52 209.18,47.4 212.32,47.4 212.58,47.14 217.99,47.14 218.13,47.28 219,47.28 219.42,47.69 219.42,47.94 220.57,49.09 221.84,49.09 222.87,50.12 223.09,50.12 224.75,51.79 227.48,51.79 227.72,51.55 229.44,51.55 230.19,52.29 234.93,52.29 235.31,51.92 236.39,51.92 237.18,52.71 238.2,52.71 238.97,53.48 240.63,53.48 240.77,53.62 240.77,54.01 241.5,54.73 246.19,54.73 246.84,55.39 250.73,55.39 251.39,54.73 257.39,54.73 257.7,54.42 260.05,54.42 262.51,56.88 263.85,56.88 265.21,58.23 271.38,58.23 272.16,57.46 273.1,57.46 273.97,58.33 275.51,58.33 276.03,58.85 276.03,59.15 275.52,59.66 275.52,74.18 275.87,74.52 275.87,78.43 276.3,78.86 278.18,78.86 280.4,81.08 281.09,81.08 284.2,84.2 288.18,84.2 289.93,85.94 289.93,86.56 290.41,87.04 290.95,87.04 293.42,89.51 293.42,89.95 293.75,90.29 293.75,94.73 293.49,94.99 v1(293.49,95.1)
  BOTTOM w0.102: 208.04,53.16 209.03,54.15 209.03,54.42 209.87,55.27 209.87,56.8 U49.V46
  BOTTOM w0.14: v1(207.27,47.28) 206.55,48 206.55,48.58 206.74,48.76 207.33,48.76 207.47,48.9 207.47,49.39 207.33,49.53 R1123.1 206.92,49.53 206.78,49.66 206.78,50.35 206.97,50.54 R1098.2 207.44,50.54 207.63,50.73 207.63,52.76 208.04,53.16
BRD_ID1: length 237.2
  TOP w0.14: v1(278.05,135.96) 279.26,137.17 279.26,155.78 279.87,156.39 R73.1
  IN1 w0.086: v1(294.14,95.09) 294.14,96.75 293.81,97.09 293.81,105.89 289.15,110.54 289.15,111.25 288.26,112.14 288.26,112.44 286.75,113.95 286.75,114.41 286.21,114.95 285.33,114.95 283.17,117.1 282.84,117.1 280.66,119.29 280.66,133.35 v1(278.05,135.96)
  IN3 w0.089: v1(294.14,95.09) 293.96,94.9 293.96,90.22 293.61,89.87 293.61,89.43 291.03,86.85 290.49,86.85 290.12,86.48 290.12,85.86 288.26,84.01 284.28,84.01 281.16,80.89 280.48,80.89 278.26,78.67 276.38,78.67 276.06,78.35 276.06,74.44 275.71,74.1 275.71,59.74 276.22,59.23 276.22,58.77 275.59,58.14 274.05,58.14 273.18,57.27 272.08,57.27 271.3,58.04 265.29,58.04 263.93,56.69 262.59,56.69 260.13,54.23 257.62,54.23 257.31,54.54 251.31,54.54 250.65,55.2 246.92,55.2 246.27,54.54 241.58,54.54 240.97,53.92 240.97,53.54 240.71,53.29 239.05,53.29 238.28,52.52 237.26,52.52 236.47,51.73 235.23,51.73 234.85,52.1 230.27,52.1 229.52,51.36 227.64,51.36 227.4,51.6 224.83,51.6 223.17,49.93 222.95,49.93 221.92,48.9 220.65,48.9 219.61,47.86 219.61,47.61 219.16,47.17 219.08,47.09 218.2,47.09 218.07,46.95 212.5,46.95 212.24,47.21 209.56,47.21 209.01,46.66 208.68,46.66 208.45,46.88 206.35,46.88 v1(205.95,47.28)
  BOTTOM w0.102: U49.U46 209.28,56.59 209.28,56.17 209.47,55.98 209.47,55.44 207.28,53.25 207.28,53.25
  BOTTOM w0.14: 207.28,53.25 206.07,52.04 205.78,52.04 205.27,51.53 205.27,50.68 205.41,50.54 R1096.2 205.67,49.64 R1121.1 205.34,49.53 205.14,49.32 205.14,48.9 205.32,48.72 205.32,47.63 205.67,47.28 v1(205.95,47.28)
BRD_ID2: length 8.8
  BOTTOM w0.102: 207.73,53.25 208.74,54.26 208.74,54.42 209.67,55.35 209.67,56.15 U49.U47
  BOTTOM w0.14: R1122.1 206.2,49.53 206.07,49.66 206.07,50.38 206.22,50.54 R1097.2 206.54,50.54 206.8,50.8 206.8,51.2 206.66,51.34 v1(206.66,51.92) 206.7,51.96 206.7,52.22 207.73,53.25
BRD_ID3: length 11.1
  BOTTOM w0.102: 206.89,53.25 207.09,53.46 207.2,53.46 209.26,55.52 209.26,55.9 209.06,56.1 209.06,56.99 209.11,57.04 209.11,57.63 U49.T45
  BOTTOM w0.14: 206.89,53.25 206.02,52.38 205.64,52.38 204.99,51.74 204.99,50.74 204.85,50.6 R1092.2 204.46,50.6 204.32,50.46 204.32,49.68 204.48,49.53 R1120.1
BRD_ID4: length 11.7
  BOTTOM w0.102: 205.32,53.25 205.45,53.38 205.88,53.38 206.67,54.16 207.02,54.16 207.69,54.83 207.69,55.73 208.57,56.61 208.57,56.88 U49.T46
  BOTTOM w0.14: 205.32,53.25 204.59,52.52 203.81,52.52 202.7,51.41 202.7,51.27 202.36,50.94 202.36,50.69 202.27,50.59 R1094.2 201.97,50.47 201.97,49.68 R1125.1
BRD_ID5: length 10
  BOTTOM w0.102: 206.47,53.25 206.89,53.68 207.11,53.68 208.1,54.66 208.1,55.56 208.72,56.18 U49.T48
  BOTTOM w0.14: 206.47,53.25 206.01,52.8 205.66,52.8 204.82,51.96 204.04,51.96 203.46,51.38 203.46,50.86 203.72,50.6 R1091.2 203.91,50.55 R1119.1
BRD_ID6: length 11
  BOTTOM w0.102: 206.07,53.25 206.75,53.93 207.08,53.93 207.9,54.75 207.9,55.65 208.8,56.55 U49.T47
  BOTTOM w0.14: R1118.1 202.87,49.53 202.64,49.75 202.64,50.82 202.86,51.04 R1095.2 203.18,51.17 203.18,51.5 203.92,52.24 204.71,52.24 205.55,53.09 205.91,53.09 206.07,53.25
BRD_ID7: length 14
  BOTTOM w0.102: U49.R46 208.29,56.84 207.83,56.63 207.54,56.35 207.54,56.17 207.29,55.91 207.29,55 206.89,54.61 206.54,54.61 205.71,53.78 205.06,53.78 204.53,53.25
  BOTTOM w0.14: 204.53,53.25 204.38,53.1 203.59,53.1 202.92,52.43 201.45,52.43 200.74,51.71 200.74,50.73 200.88,50.59 R1093.2 201.15,50.36 200.87,50.08 200.87,49.16 R1134.1
BRD_ID8: length 9
  TOP w0.14: v1(208.54,62.14) 208.51,62.12 v1(207.74,62.12) 207.4,62.12 206.87,62.65 206.45,62.65 206.28,62.82 205.01,62.82 203.7,61.51 203.2,61.51 203.06,61.65 R513.2 R512.1
  BOTTOM w0.102: U49.V35 209.47,62.12 208.56,62.12 v1(208.54,62.14)
BRD_ID9: length 10.9
  TOP w0.14: R529.1 203.11,61.07 R530.2 203.11,60.86 203.3,60.67 204.32,60.67 204.65,61 204.65,61.99 205.21,62.54 206.13,62.54 206.31,62.37 206.75,62.37 207,62.12 207,61.09 207.22,60.87 208.84,60.87 209.27,61.3 209.33,61.3 v1(209.36,61.33)
  BOTTOM w0.102: v1(209.36,61.33) 209.73,61.69 U49.V37
BRD_ID10: length 10.2
  TOP w0.14: v1(207.28,59.83) 206.93,60.18 204.84,60.18 v1(204.49,59.82) 204.25,59.59 203.4,59.59 203.12,59.87 R542.2 202.65,60.13 202.64,60.14 R541.1
  BOTTOM w0.102: v1(207.28,59.83) 207.28,59.84 207.28,59.85 207.31,59.88 207.31,59.9 207.96,60.56 208.26,60.64 208.46,60.64 208.49,60.61 209.34,60.61 209.36,60.62 209.72,60.62 209.78,60.59 209.8,60.59 209.96,60.43 209.96,60.26 210.19,60.03 210.6,60.03 U49.Y39
BRD_ID11: length 10.1
  TOP w0.14: R554.1 R555.2 203.14,58.67 203.41,58.41 204.57,58.41 205.02,58.85 205.02,58.87 v1(205.76,59.61) 206.45,59.61 206.7,59.36 207.46,59.36 207.87,59.77 208.47,59.77 v1(208.71,59.53)
  BOTTOM w0.102: U49.Y41 210.47,59.81 210.06,59.81 209.86,60.01 209.2,60.01 v1(208.71,59.53)
BRD_ID12: length 10.4
  TOP w0.14: v1(207.97,59.07) 207.95,59.08 207.65,59.08 207.65,59.08 206.33,59.08 206.08,58.82 206.08,58.56 205.68,58.17 205.68,57.9 205.54,57.76 205.05,57.76 v1(204.66,57.37) 203.95,57.37 203.9,57.42 203.13,57.42 202.99,57.28 R573.2 202.62,57.01 202.61,57.02 R572.1
  BOTTOM w0.102: v1(207.97,59.07) 207.98,59.08 208,59.08 208.01,59.09 208.33,59.09 208.36,59.12 208.87,59.12 208.92,59.17 209.63,59.17 209.84,59.38 210.27,59.38 210.51,59.14 U49.W42
BRIGHT: length 25.1
  TOP w0.14: CN2.34 271.01,186.85 271.07,186.79 v1(271.1,186.79) ; v1(282.93,177.47) 282.6,177.14 U4.1
  IN1 w0.086: v1(282.93,177.47) 282.52,177.89 282.52,179.8 283.27,180.55 283.27,182.91 279.72,186.46 271.43,186.46 v1(271.1,186.79)
  BOTTOM w0.14: v1(282.93,177.47) 283.26,177.14 R748.2 ; v1(271.1,186.79) 271.05,186.74 270.67,186.74 270.36,187.05 269.35,187.05 269.21,186.91 R736.1
BRIGHT_EC: length 476.8
  TOP w0.14: v1(166.37,60.01) 166.58,60.22 166.83,60.22 167.11,60.5 U23.28
  IN2 w0.089: v1(271.96,179.82) 272.06,179.82 273.74,181.49 273.74,184.22 273.04,184.92 270.26,184.92 269.26,185.92 267.69,185.92 266.48,184.71 264.5,184.71 261.7,187.52 231.21,187.52 231.17,187.48 223.61,187.48 223.12,187 220.71,187 219.67,188.04 214.81,188.04 214.06,187.29 v1(214.06,186.86) ; v1(196.78,109.16) 193.26,109.16 179.88,122.54 126.37,122.54 123.62,125.29 114.71,125.29 113.97,126.03 v1(113.92,126.03) ; v1(284.66,177.42) 283.92,176.67 281.59,176.67 v1(278.86,179.41)
  IN3 w0.089: v1(278.86,179.41) 278.03,179.41 276.29,181.15 273.39,181.15 272.06,179.82 v1(271.96,179.82) ; v1(214.06,186.86) 214.06,186.56 213.12,185.62 212.89,185.62 210.92,183.64 209.17,183.64 205.81,180.28 199.06,180.28 194.21,175.43 194.21,168.6 190.52,164.92 190.52,153.57 191.25,152.84 191.25,112.3 194.39,109.16 v1(196.78,109.16) ; v1(113.92,126.03) 113.87,126.03 113.54,125.71 113.54,125.45 113.25,125.16 113.25,123.95 111.36,122.07 111.36,117.38 114.53,114.22 114.53,111.18 111.43,108.08 107.53,108.08 106,106.55 106,104.37 104.71,103.08 104.71,99.43 99.16,93.88 99.16,90.59 98.3,89.73 97.05,89.73 95.71,88.38 91.32,88.38 90.41,87.47 87.8,87.47 87.26,88.01 85.53,88.01 85.27,87.74 78.81,87.74 v1(78.47,87.4)
  IN4 w0.086: v1(76.33,55.52) 77.05,54.8 94.26,54.8 95.56,53.5 102.35,53.5 106.79,49.06 109.71,49.06 110.46,48.32 110.93,48.32 111.6,48.98 111.83,48.98 112.88,50.03 113.77,50.03 114.43,50.69 119.17,50.69 122.26,53.78 124.51,53.78 126.41,55.68 130.88,55.68 131.86,56.66 135.12,56.66 135.48,57.03 139.71,57.03 142.81,60.13 143.85,60.13 144.63,59.36 149.64,59.36 150.36,60.08 150.36,60.74 151.11,61.49 152.42,61.49 153.2,62.27 157.55,62.27 158.22,61.59 163,61.59 163.95,60.63 165.75,60.63 v1(166.37,60.01)
  BOTTOM w0.14: v1(78.47,87.4) 78.44,87.37 78.44,86.33 78.34,86.22 78.34,82.98 77.3,81.94 77.3,63.6 75.96,62.25 75.96,55.9 v1(76.33,55.52) ; R748.1 283.51,176.27 v1(284.66,177.42)
