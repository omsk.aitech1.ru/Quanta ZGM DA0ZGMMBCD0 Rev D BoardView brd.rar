# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TPD_INT#: length 132.9
  TOP w0.14: R343.1 R353.1 166.83,75.5 166.57,75.24 166.57,74.74 169.35,71.96 169.74,71.96 170.71,70.99 v1(170.71,70.85) ; R636.1 197.21,42.56 196.36,41.71 Q63.3 195.94,40.86 195.55,41.24 v1(195.55,41.44)
  IN2 w0.089: v1(170.71,70.85) 170.88,71.02 174.32,71.02 174.81,71.51 180.63,71.51 181.15,71 185.22,71 185.55,71.34 186.48,71.34 187.14,70.67 188.09,70.67 189.52,69.25 191.86,69.25 193.31,67.79 196.25,67.79 197.62,66.42 201.81,66.42 203.3,64.92 203.3,64.15 203.67,63.79 204.35,63.79 205.42,62.71 208.65,62.71 208.87,62.49 209.5,62.49 210.99,61 213.99,61 214.71,60.28 216.44,60.28 216.88,59.84 217.69,59.84 217.82,59.71 218.37,59.71 218.64,59.98 218.64,60.26 219.28,60.91 219.98,60.91 220.99,61.92 220.99,62.89 221.55,63.46 222.26,63.46 223.38,62.34 225.73,62.34 226.04,62.65 226.04,63.07 226.13,63.15 v1(226.13,63.35)
  IN4 w0.086: v1(195.55,41.44) 193.11,43.88 192.44,43.88 191.9,44.43 187.48,48.85 186.46,48.85 185.87,49.44 185.87,50.45 184.78,51.54 180.6,51.54 177.18,54.96 177.18,58.42 176.59,59.02 172.92,59.02 172.66,59.28 172.29,59.65 172.29,60.2 171.82,60.67 171.1,60.67 v1(170.57,60.15)
  BOTTOM w0.102: R991.1 226.6,63.83 v1(226.13,63.35) 226.11,63.33 225.78,63.33 225.5,63.61 224.86,63.61 224.12,62.87 224.12,62.82 223.65,62.35 223.26,62.35 223.1,62.19 222.96,62.19 222.55,61.78 222.14,61.78 221.98,61.62 221.98,60.92 U49.BA39
  BOTTOM w0.14: v1(170.57,60.15) 170.57,60.81 169.65,61.74 169.5,61.74 168.55,62.68 168.55,63.51 168.86,63.82 169.07,63.82 169.57,64.33 169.57,69.72 v1(170.71,70.85)
TPM_MISO: length 3.2
  TOP w0.14: U18.24 237.13,72.03 236.8,72.35 236.59,72.35 v1(236.35,72.6) 236.31,72.64 R388.2 R379.2
TPM_PIRQ#: length 31.7
  TOP w0.14: v1(223.49,63.02) 224.1,63.02 225.19,64.12 226.77,64.12 v1(227.26,64.61) ; v1(243.83,72.78) 243.83,73.71 243.61,73.93 R382.1
  IN3 w0.089: v1(227.26,64.61) 227.5,64.85 228.84,64.85 229.38,65.39 229.38,66 230.18,66.81 231.17,66.81 232.77,65.21 241.39,65.21 242.57,66.39 242.57,69.58 244.04,71.04 244.04,72.57 v1(243.83,72.78)
  BOTTOM w0.102: U49.BD33 223.02,63.17 223.34,63.17 v1(223.49,63.02)
TPM_PIRQ#_C: length 5.2
  TOP w0.14: U18.18 240.12,72.4 240.67,72.95 v1(241.82,72.95) 242.57,73.7 R382.2 242.57,74.23 242.33,74.47 R368.2
TPM_SCS#: length 4
  TOP w0.14: R367.2 240.24,74.6 240.1,74.46 239.83,74.46 239.63,74.26 R385.2 239.63,73.21 v1(239.38,72.96) 239.12,72.71 U18.20
TPM_SPI1_CLK: length 18.4
  TOP w0.14: R386.1 241.44,74.13 241.58,74.27 v1(241.58,74.88) 241.58,74.99 241.84,75.25 v1(241.84,75.55)
  BOTTOM w0.14: v1(241.84,75.55) 242.94,74.45 242.94,66.62 243.48,66.09 243.48,64.08 244.33,63.23 R1015.1
TPM_SPI1_SI: length 19.1
  TOP w0.14: v1(239.04,74.63) 239.04,74.27 238.9,74.13 R384.1
  BOTTOM w0.14: v1(239.04,74.63) 242,74.63 242.42,74.21 242.42,66.41 242.96,65.87 242.96,63.86 243.61,63.2 R1014.1
TPM_SPI1_SO: length 27.1
  TOP w0.14: v1(234,72.57) 234.43,72.14 235.2,72.14 235.66,72.61 235.66,73.21 R388.1
  BOTTOM w0.14: R1110.1 236.05,50.84 236.58,51.37 236.58,52.21 236.79,52.42 236.79,54.47 234.1,57.16 234.1,60.22 233.33,61 233.33,63.9 233.74,64.31 233.74,67.41 233.85,67.52 233.85,72.42 v1(234,72.57)
TPM_VDD: length 11.3
  IN4 w0.381: v1(238.18,74.6) 238.18,74.44 242.49,70.12 v1(242.49,65.1)
  vias: v1(238.82,63.37)
TPS65994A_ADCIN1: length 3
  TOP w0.102: U11.G4 61.47,89.08 v2(61.47,88.79)
  BOTTOM w0.14: R846.1 61.63,90.82 61.41,90.6 R847.2 61.41,89.88 61.54,89.76 R852.2 61.54,88.86 v2(61.47,88.79)
TPS65994A_ADCIN2: length 4.7
  TOP w0.102: U11.G3 61.85,89.09 61.85,88.42 v2(61.69,88.26)
  BOTTOM w0.14: R851.2 63.22,89.38 62.83,88.99 62.49,88.99 62.26,88.76 R860.2 ; R863.1 R860.2 ; R860.2 61.72,88.23 v2(61.69,88.26)
TRI_EN: length 205.4
  TOP w0.14: R586.1 170.87,54.98 171.19,54.67 171.51,54.67 171.81,54.36 v1(171.81,54.14)
  TOP w0.203: v1(222.89,206.69) 222.89,207.25 222.98,207.35 R41.1 222.98,208.13 223.02,208.17 Q7.2
  IN1 w0.086: v1(171.81,54.14) 171.81,55.1 173.54,56.82 177.02,56.82 179.09,58.89 183.78,58.89 184.65,59.76 185.95,59.76 186.06,59.87 187.31,59.87 187.81,60.37 188.84,60.37 192.7,56.51 v1(193.66,56.51)
  IN3 w0.089: v1(193.84,61.08) 193.7,61.22 193.7,63.93 193.19,64.44 193.19,78.62 193.34,78.76 193.34,88.48 194.36,89.5 194.36,105.13 193.69,105.8 193.69,108.1 190.07,111.71 190.07,152.35 189.34,153.08 189.34,165.83 191.6,168.09 191.6,169.87 193.02,171.29 193.02,175.92 198.57,181.46 204.01,181.46 205.11,182.57 205.11,183.33 209.55,187.77 211.44,187.77 214.57,190.9 218.96,190.9 v1(220.4,192.34)
  IN4 w0.086: v1(222.89,206.69) 222.89,205.45 223.14,205.19 223.14,204.43 221.62,202.91 221.62,199.73 219.21,197.32 219.21,194.53 219.46,194.27 219.46,193.28 v1(220.4,192.34) ; v1(193.66,56.51) 194.09,56.93 194.09,60.84 v1(193.84,61.08)
TURBO_KEY: length 154.4
  TOP w0.14: v1(141.43,202.46) 141.83,202.85 142.47,202.85 143.15,203.53 143.15,203.95 R46.2 143.57,204.13 143.74,204.3 143.74,205.7 143.49,205.96 143.49,206.39 143.77,206.67 144.22,206.67 144.38,206.52 144.38,206.41 144.6,206.19 U1.10 ; v1(265.26,194.25) 265.45,194.05 CN1.16
  IN1 w0.086: v1(141.43,202.46) 141.43,200.56 142.81,199.18 146.55,199.18 147.22,199.86 149.91,199.86 150.59,199.17 153.58,199.17 154.17,199.76 158.31,199.76 v1(158.39,199.68) ; v1(265.26,194.25) 265.76,193.74 265.76,191.57 265.62,191.43 265.08,191.43 264.82,191.17 264.82,190.06 263.66,188.89 250.4,188.89 249.76,189.53 242.3,189.53 241.62,188.85 238.09,188.85 237.82,188.59 218.26,188.59 218.05,188.79 212.92,188.79 211.85,187.73 208.01,187.73 206.08,189.66 201.59,189.66 200.51,188.58 190.27,188.58 185.22,193.64 181.1,193.64 180.59,194.14 179.13,194.14 176.53,196.75 175.54,196.75 172.07,200.23 172.07,202.16 169.92,204.31 169.16,204.31 168.09,205.38 167.16,205.38 166.93,205.61 v1(166.73,205.61)
  IN2 w0.089: v1(158.39,199.68) 160.27,201.56 160.91,201.56 161.93,202.58 161.93,203.21 164.32,205.61 v1(166.73,205.61)
TX0_HDMI+: length 46.3
  TOP w0.14: v1(15.19,35.03) 15.48,35.33 16.08,35.33 16.12,35.28 U32.10 U32.1 17.9,35.28 17.94,35.33 18.67,35.33 22.67,39.32 24.18,42.98 24.28,43.13 28.07,47.74 29.54,49.22 31.76,50.14 33.68,51.42 35.4,51.94 38.43,51.94 39.81,52.52 41.11,53.81 41.11,54.43 R601.2
  IN1 w0.086: v1(15.19,35.03) 15.01,35.22 14.6,35.22 14.09,35.72 13.38,37.43 13.21,37.6 12.44,37.6 12.21,37.37 12.21,32.14 11.96,31.89 11.43,31.89 11.34,31.8 CN23.7
TX0_HDMI-: length 46.3
  TOP w0.14: R600.2 40.69,54.43 40.69,53.98 39.57,52.87 38.35,52.36 35.34,52.36 33.5,51.81 31.56,50.51 29.3,49.57 27.75,48.02 23.94,43.38 23.81,43.18 22.31,39.56 18.49,35.74 17.97,35.74 17.93,35.78 U32.2 U32.9 16.11,35.78 16.07,35.74 15.33,35.74 15.19,35.88 v1(15.19,36.04)
  IN1 w0.086: CN23.9 11.34,32.25 11.47,32.13 11.86,32.13 11.97,32.24 11.97,37.47 12.34,37.84 13.31,37.84 13.58,37.56 14.29,35.86 14.69,35.45 15.18,35.45 15.3,35.57 15.3,35.93 v1(15.19,36.04)
TX1_HDMI+: length 41.6
  TOP w0.14: R603.2 42.8,53.88 40.53,51.6 38.65,50.83 36.28,50.83 35.04,50.45 32.27,49.14 30.17,48.27 29,47.09 25.15,42.41 23.66,38.79 21.92,36.19 20.7,34.98 18.97,32.38 18.55,31.96 U33.4 U33.7 15.41,31.96 13.62,30.17 13.06,30.17 CN23.4
TX1_HDMI-: length 41.5
  TOP w0.14: CN23.6 12.89,30.73 13.03,30.59 13.45,30.59 15.24,32.38 16.11,32.38 16.19,32.46 U33.6 U33.5 17.85,32.46 17.93,32.38 18.37,32.38 18.64,32.65 20.38,35.24 21.59,36.46 23.28,38.99 24.79,42.63 28.69,47.38 29.94,48.63 32.1,49.52 34.89,50.84 36.22,51.25 38.57,51.25 40.29,51.96 42.38,54.05 42.38,54.46 42.24,54.6 R602.2
TX2_HDMI+: length 46.2
  TOP w0.14: R605.2 44.33,53.63 41.81,51.11 41.06,50.61 38.88,49.71 36.5,49.71 36.35,49.67 35.37,49.21 31.86,47.76 30.83,47.07 28.57,44.8 26.34,42.1 25.99,41.51 24.59,38.12 20.84,32.52 18.78,30.46 U33.1 U33.10 15.53,30.46 14.14,29.07 14.14,28.65 13.44,27.95 12.49,27.95 11.79,28.65 11.49,28.65 CN23.1
TX2_HDMI-: length 46.1
  TOP w0.14: CN23.3 11.34,29.23 11.48,29.09 11.94,29.09 12.66,28.37 13.27,28.37 13.72,28.82 13.72,29.24 15.36,30.88 16.03,30.88 16.11,30.96 U33.9 U33.2 17.9,30.96 17.98,30.88 18.61,30.88 20.52,32.78 22.37,35.55 24.22,38.32 25.62,41.7 26,42.34 28.25,45.09 30.56,47.4 31.66,48.13 35.2,49.59 36.21,50.07 36.45,50.13 38.79,50.13 40.86,50.98 41.54,51.44 43.91,53.81 43.91,54.46 43.77,54.6 R604.2
TXC_HDMI+: length 38.1
  TOP w0.14: R599.2 39.75,54.04 39.18,53.46 38.39,53.14 35.11,53.14 33.52,52.65 31.24,51.14 28.91,50.17 27.11,48.36 23.47,43.93 23.19,43.52 22.48,41.8 21.72,39.96 18.55,36.79 U32.4 U32.7 14.93,36.79 14.2,36.06 14.2,33.82 13.55,33.17 13.06,33.17 CN23.10
TXC_HDMI-: length 38
  TOP w0.14: R598.2 39.2,54.6 39.33,54.46 39.33,54.21 38.94,53.82 38.31,53.56 35.05,53.56 33.33,53.04 31.04,51.51 28.68,50.53 26.79,48.64 23.13,44.18 22.82,43.72 21.36,40.19 18.37,37.2 17.94,37.2 17.86,37.28 U32.5 U32.6 16.14,37.28 16.06,37.2 14.75,37.2 13.78,36.24 13.78,34 13.37,33.59 13.03,33.59 12.89,33.73 CN23.12
TYPEC1_USB0: length 8.3
  TOP w0.508: v1(57.66,89.75) 57.49,89.92 56.03,89.92 55.75,89.64 R187.2
  BOTTOM w0.152: CN5.B4 7.85,94.1 8.12,94.37 v2(8.2,94.37)
  BOTTOM w0.203: CN5.A4 8.54,91.85 8.26,91.58 v2(8.2,91.58)
  BOTTOM w0.254: v2(8.2,91.58) 8.18,91.6 CN5.B9 ; v1(10.09,91.52) 9.91,91.52 9.58,91.85 CN5.A4 ; v1(9.93,94.51) 9.77,94.35 CN5.A9 8.43,94.35 8.41,94.37 v2(8.2,94.37)
  vias: v1(13.59,100.29) v1(13.59,99.53) v1(13.59,98.77) v1(14.35,100.29) v1(14.35,99.53) v1(14.35,98.77) v1(57.66,88.99) v1(58.42,89.75) v1(58.42,88.99) v1(59.19,89.75) v1(59.19,88.99)
TYPEC2_USB0: length 6.7
  TOP w0.508: v1(56.03,87.14) 55.75,87.42 R196.2
  BOTTOM w0.152: v2(8.2,80.37) 8.12,80.37 7.85,80.1 CN9.B4
  BOTTOM w0.203: CN9.A4 8.63,77.85 8.36,77.58 v2(8.2,77.58)
  BOTTOM w0.254: CN9.B9 8.18,77.6 v2(8.2,77.58) ; v1(10.09,77.52) 9.95,77.52 9.62,77.85 CN9.A4 ; v2(8.2,80.37) 8.41,80.37 8.43,80.35 CN9.A9 9.77,80.35 v1(9.93,80.51)
  vias: v1(9.11,71.97) v1(9.66,73.11) v1(9.66,72.35) v1(9.66,71.59) v1(10.42,73.11) v1(10.42,72.35) v1(10.42,71.59) v1(57.61,87.34) v1(57.61,86.58) v1(58.37,87.34) v1(58.37,86.58) v1(59.13,87.34) v1(59.14,86.57)
U64009_A0: length 2.5
  TOP w0.14: U14.1 71.22,77.81 71.7,77.33 R331.1 R332.2
U64009_A1: length 2.4
  TOP w0.14: U14.2 71.2,79.08 71.42,79.31 R311.1 R312.2
U64009_A2: length 2.4
  TOP w0.14: R287.2 R286.1 71.86,80.35 U14.3
U64009_WP: length 2.9
  TOP w0.14: U14.7 63.81,79.08 63.46,79.44 R307.1 62.26,79.44 v1(62.11,79.59)
UART2_RXD: length 1.6
  TOP w0.14: TP62.1 220.7,66.69 v1(220.7,66.43)
  BOTTOM w0.102: v1(220.7,66.43) 220.7,66.61 U49.AY26
UART2_TXD: length 1.3
  TOP w0.14: v1(219.99,66.46) 220.07,66.38 TP63.1
  BOTTOM w0.102: U49.AW26 220.25,66.73 v1(219.99,66.46)
UART_WAKE_N: length 52.6
  IN3 w0.089: v1(230.5,66.33) 232.13,64.7 243.68,64.7 243.98,65 250.99,65 251.86,65.88 252.25,65.88 254.91,68.54 262.63,68.54 264.22,70.14 269.27,70.14 271.29,68.11 v1(271.29,65.9)
  BOTTOM w0.102: v1(230.5,66.33) 230.31,66.52 229.58,66.52 229.34,66.76 R979.1
  BOTTOM w0.14: v1(271.29,65.9) 271.46,65.74 CN12.20
ULT_EDP_HPD: length 99.7
  TOP w0.14: v1(282.82,191.19) 282.59,190.97 282.59,189.85 280.98,188.24 280.98,155.98 280.49,155.49 280.49,136.35 278.12,133.98 v1(277.64,133.98) 277.36,134.25 CG333.1 RG49.2
  IN2 w0.089: v1(282.82,191.19) 282.06,191.19 281.84,191.41 281.84,195.57 282.3,196.03 282.3,197.39 283.04,198.13 283.04,199.15 281.45,200.75 278.57,200.75 278.26,201.05 278.26,208.07 277.1,209.23 272.14,209.23 271.36,210.02 271.36,211.03 268.17,214.22 268.17,214.64 267.72,215.09 267.61,215.09 v1(267.07,215.64)
  BOTTOM w0.14: R691.1 266.29,214.93 267.01,215.64 v1(267.07,215.64)
ULT_EDP_HPD_R: length 3.5
  BOTTOM w0.14: R691.2 266.18,214.39 265.73,213.94 265.73,212.88 266.37,212.24 U37.3
USB2_COMP: length 4.1
  BOTTOM w0.102: R903.2 203.53,80.35 203.66,80.23 203.66,79.52 203.73,79.45 203.73,78.97 U49.E2
USB2_ID: length 4.8
  BOTTOM w0.102: R904.2 204.3,82.13 203.79,81.62 203.79,80.39 203.86,80.31 203.86,79.61 203.94,79.53 203.94,78.49 U49.F3
USB2_VBUSSENSE: length 3.8
  BOTTOM w0.102: U49.E1 203.46,79.33 203.46,80.14 203.25,80.34 203.25,82.31 R902.2
USB3_PCH_RX_WWAN_TX_C_N: length 4.3
  TOP w0.14: R204.1 304.43,86.38 303.76,86.38 303.5,86.13 302.99,86.13 v1(302.69,86.42)
  BOTTOM w0.14: v1(302.69,86.42) 302.4,86.13 302.1,86.13 301.97,86.25 CN7.29
USB3_PCH_RX_WWAN_TX_C_P: length 4.3
  TOP w0.14: R210.1 304.46,86.14 303.86,86.14 303.6,85.88 302.99,85.88 v1(302.69,85.59)
  BOTTOM w0.14: v1(302.69,85.59) 302.4,85.88 301.99,85.88 301.86,85.75 CN7.31
USB3_PCH_TX_WWAN_RX_C_N: length 4.3
  TOP w0.14: C288.1 304.43,84.86 303.52,84.86 303.26,84.6 303.03,84.6 v1(302.74,84.89)
  BOTTOM w0.14: CN7.35 301.82,84.75 301.95,84.63 302.47,84.63 v1(302.74,84.89)
USB3_PCH_TX_WWAN_RX_C_P: length 4.3
  TOP w0.14: v1(302.74,84.07) 303.03,84.36 303.36,84.36 303.62,84.62 304.46,84.62 C296.1
  BOTTOM w0.14: v1(302.74,84.07) 302.42,84.38 301.94,84.38 301.81,84.25 CN7.37
USB30_RX+_DB1: length 157.6
  IN1 w0.114: v1(317.76,72.73) 317.76,72.79 317.97,72.99 318.15,72.99 318.73,73.58 318.73,74.18 320.15,75.59 320.15,78.19 319.32,79.02 319.32,87.52 318.84,88 318.84,89.34 317.95,90.23 313.97,90.23 313.05,89.31 309.19,89.31 309.12,89.24 303.15,89.24 302.82,89.57 300.8,89.57 298.78,87.55 298.78,86.15 297.94,85.32 297.94,84.2 296.84,83.1 295.74,83.1 295.43,82.79 289.86,82.79 289.74,82.68 287.97,82.68 287.5,82.21 284.52,82.21 283.18,80.87 280.03,80.87 278.97,79.81 278.97,79.6 276.25,76.88 276.25,75.87 274.57,74.19 274.57,73.17 272.65,71.24 270.31,71.24 269.69,70.63 265.06,70.63 263.99,69.55 253.94,69.55 251.01,66.62 238.73,66.62 230.18,75.17 228.78,75.17 227.38,76.57 224.96,76.57 222.91,78.62 218.25,78.62 218.01,78.86 215.16,78.86 214.7,78.4 214.19,78.4 213.35,77.56 212.86,77.56 212.55,77.86 210.22,77.86 207.99,75.63 207.99,75.1 208.18,74.91 208.18,74.56 207.86,74.23 207.07,74.23 206.49,73.65 205.26,73.65 204.75,74.16 204.32,74.16 204.12,73.95 203.9,73.95 v1(203.85,73.9)
  BOTTOM w0.102: U49.E11 203.52,74.67 203.73,74.46 203.73,74.01 v1(203.85,73.9)
  BOTTOM w0.14: CN10.28 317.58,72.91 v1(317.76,72.73)
USB30_RX+_DB2: length 161.3
  IN1 w0.114: v1(200.46,73.47) 200.64,73.28 200.64,73.06 200.89,72.81 201.38,72.81 203.04,74.47 204.81,74.47 205.24,74.89 206.03,74.89 206.49,75.35 206.49,76.4 206.86,76.77 207.78,76.77 208.11,77.1 208.66,77.1 209.98,78.42 213.34,78.42 214.06,79.15 214.57,79.15 214.91,79.49 218.39,79.49 218.64,79.25 223.37,79.25 225.08,77.53 228.69,77.53 232.15,74.08 234.48,74.08 236.61,71.95 246.47,71.95 248.05,73.52 250.89,73.52 253.63,70.78 255.97,70.78 256.76,71.57 262.36,71.57 263.47,72.68 266.44,72.68 267.97,74.21 270.35,74.21 270.51,74.36 271.95,74.36 276.28,78.69 276.28,80.65 277.15,81.52 282.88,81.52 284.65,83.3 289.23,83.3 289.34,83.41 292.82,83.41 293.59,84.19 294.73,84.19 295.13,83.78 296.65,83.78 297.32,84.46 297.32,85.57 298.04,86.29 298.04,89.62 298.62,90.2 303.2,90.2 303.52,89.88 308.21,89.88 308.64,90.32 309.58,90.32 309.96,89.94 312.79,89.94 313.71,90.85 318.2,90.85 319.94,89.12 319.94,79.48 320.19,79.23 320.38,79.23 v1(320.67,78.94)
  BOTTOM w0.102: U49.D12 202.76,74.24 202.31,74.24 201.83,74.72 201.4,74.72 200.71,74.03 200.71,73.72 v1(200.46,73.47)
  BOTTOM w0.14: CN10.19 316.8,77.41 316.92,77.53 319.21,77.53 319.61,77.93 319.61,78.79 319.98,79.16 320.45,79.16 v1(320.67,78.94)
USB30_RX+_MB1: length 211.7
  TOP w0.14: C415.1 15.05,69.67 14.94,69.67 v1(14.66,69.96)
  IN4 w0.114: v1(14.66,69.96) 14.66,69.67 14.77,69.56 16.52,69.56 17.29,68.79 17.29,67.91 18.49,66.71 20.26,66.71 21.12,67.58 22.1,67.58 25,64.68 25.71,64.68 29.27,61.12 37.92,61.12 38.38,61.58 44.94,61.58 45.64,62.28 50.95,62.28 51.14,62.08 57.89,62.08 60.25,59.72 74.32,59.72 77.77,56.27 85.91,56.27 89.47,59.83 101.06,59.83 107.11,53.79 110.37,53.79 111.48,52.67 112.76,52.67 113.64,53.55 118.45,53.55 121.23,56.34 123.48,56.34 127.67,60.52 133.4,60.52 135.27,62.38 138.94,62.38 141.22,64.66 146.76,64.66 148.29,66.18 148.96,66.18 151.56,68.79 153.08,68.79 153.45,69.16 163.77,69.16 164.13,68.8 172.98,68.8 173.44,68.33 180.07,68.33 180.41,68.68 186.99,68.68 187.12,68.55 187.63,68.55 188.4,69.32 193.77,69.32 199.55,75.1 200.52,75.1 200.65,75.24 v1(200.65,75.36)
  BOTTOM w0.102: U49.C10 202.21,75.19 202.17,75.15 201.22,75.15 201.03,74.96 200.78,74.96 200.65,75.09 v1(200.65,75.36)
USB30_RX+_MB1_C: length 10.2
  TOP w0.14: L16.4 18.5,52.59 18.44,52.66 v1(18.44,53.15) ; v1(19.33,59.19) 19.33,59.63 R544.1
  IN4 w0.086: v1(19.33,59.19) 19.18,59.03 19.18,54.33 19.88,53.63 19.88,52.8 19.51,52.43 18.85,52.43 18.61,52.67 18.61,52.98 v1(18.44,53.15)
USB30_RX+_MB1_C_R: length 9.1
  TOP w0.14: L16.3 18.66,51.09 18.66,50.9 18.99,50.57 18.99,50.28 18.86,50.14 D48.1 18.86,49.72 19.04,49.54 19.04,49.11 18.6,48.67 17.99,48.67 17.74,48.91 17.74,49.35 16.71,50.38 15.84,50.38 15.12,49.66 14.85,49.66 14.71,49.8 14.71,50.49 CN15.6
USB30_RX+_MB1_RTI: length 2.7
  TOP w0.14: U24.21 18.21,61.34 18.55,61 18.92,61 19.28,60.64 19.28,60.39 R544.2
USB30_RX+_MB1_RTO: length 4.9
  TOP w0.14: U24.8 18.21,67.23 17.53,67.91 17.53,68.79 16.51,69.8 15.91,69.8 C415.2
USB30_RX+_WWAN: length 138.6
  TOP w0.14: v1(306.52,85.81) 306.18,86.16 305.42,86.16 R210.2
  IN1 w0.114: v1(205.41,71.89) 205.61,71.68 205.61,70.21 206.25,69.57 206.48,69.57 206.63,69.42 206.63,66.98 207.73,65.87 207.73,65.57 207.34,65.18 207.34,64.43 207.89,63.88 207.89,63.42 210.39,60.92 210.63,60.92 210.85,60.7 210.85,58.19 211.4,57.64 213.92,57.64 215.46,56.1 217.26,56.1 220.21,53.15 226.92,53.15 227.36,53.58 229.2,53.58 230.02,52.76 234.68,52.76 235.27,52.17 238.61,52.17 239.6,53.17 242.38,53.17 244.75,55.54 248.18,55.54 248.52,55.88 257.16,55.88 258.1,56.82 259.56,56.82 260.06,56.33 262.89,56.33 263.44,56.88 266.17,56.88 267.18,57.89 269.76,57.89 271.91,60.05 271.91,61.63 273.08,62.8 273.08,64.68 274.86,66.46 274.86,68.84 278.12,72.1 278.12,73.16 278.48,73.51 279.12,73.51 279.93,72.71 281.51,72.71 282.22,73.42 282.22,74.69 283.85,76.32 284.67,76.32 286.85,78.5 290.55,78.5 291.64,79.59 296.92,79.59 297.09,79.76 300.09,79.76 301.64,81.31 303.68,81.31 304.17,81.8 304.17,82.04 304.54,82.4 304.54,84.49 306.14,86.08 306.34,86.08 306.52,85.9 v1(306.52,85.81)
  BOTTOM w0.102: v1(205.41,71.89) 205.45,71.93 U49.J15
USB30_RX-_DB1: length 157.6
  IN1 w0.114: v1(204.4,73.54) 204.31,73.64 204.31,73.81 204.42,73.93 204.66,73.93 205.17,73.42 206.58,73.42 207.17,74 207.95,74 208.41,74.46 208.41,75.01 208.22,75.2 208.22,75.54 210.32,77.64 212.46,77.64 212.76,77.33 213.44,77.33 214.29,78.17 214.8,78.17 215.25,78.63 217.92,78.63 218.16,78.39 222.81,78.39 224.86,76.34 227.28,76.34 228.69,74.94 230.09,74.94 238.63,66.39 251.11,66.39 254.04,69.33 264.08,69.33 265.16,70.4 269.79,70.4 270.4,71.02 272.74,71.02 274.8,73.07 274.8,74.1 276.48,75.78 276.48,76.79 279.2,79.5 279.2,79.71 280.13,80.64 283.28,80.64 284.62,81.98 287.59,81.98 288.06,82.45 289.84,82.45 289.95,82.56 295.53,82.56 295.83,82.87 296.94,82.87 298.17,84.1 298.17,85.22 299,86.05 299,87.45 300.9,89.34 302.73,89.34 303.06,89.02 309.22,89.02 309.29,89.09 313.14,89.09 314.06,90 317.85,90 318.61,89.24 318.61,87.91 319.09,87.43 319.09,78.93 319.92,78.1 319.92,75.69 318.5,74.27 318.5,73.67 318.05,73.22 317.93,73.22 317.76,73.39 v1(317.76,73.56)
  BOTTOM w0.102: U49.G11 204.11,74.5 204.22,74.61 204.38,74.61 204.49,74.5 204.49,74.18 204.42,74.11 204.42,73.56 v1(204.4,73.54)
  BOTTOM w0.14: CN10.27 316.77,73.41 317.03,73.15 317.58,73.15 317.76,73.33 v1(317.76,73.56)
USB30_RX-_DB2: length 161.3
  IN1 w0.114: v1(201.12,73.47) 200.99,73.47 200.87,73.34 200.87,73.15 200.98,73.04 201.29,73.04 202.94,74.69 204.71,74.69 205.14,75.12 205.93,75.12 206.26,75.44 206.26,76.5 206.76,77 207.69,77 208.01,77.33 208.56,77.33 209.89,78.65 213.24,78.65 213.97,79.37 214.47,79.37 214.82,79.72 218.49,79.72 218.74,79.47 223.47,79.47 225.18,77.76 228.79,77.76 232.25,74.3 234.57,74.3 236.7,72.18 246.38,72.18 247.96,73.75 250.99,73.75 253.72,71.01 255.88,71.01 256.67,71.8 262.27,71.8 263.37,72.91 266.34,72.91 267.87,74.44 270.26,74.44 270.41,74.59 271.86,74.59 276.05,78.78 276.05,80.75 277.05,81.75 282.78,81.75 284.56,83.53 289.13,83.53 289.25,83.64 292.73,83.64 293.5,84.42 294.82,84.42 295.23,84.01 296.56,84.01 297.09,84.55 297.09,85.67 297.81,86.38 297.81,89.72 298.52,90.43 303.3,90.43 303.62,90.11 308.11,90.11 308.55,90.55 309.67,90.55 310.05,90.16 312.69,90.16 313.61,91.08 318.3,91.08 320.17,89.21 320.17,79.57 320.28,79.46 320.37,79.46 v1(320.67,79.76)
  BOTTOM w0.102: v1(201.12,73.47) 200.91,73.67 200.91,73.94 201.48,74.51 201.75,74.51 202.23,74.03 203.17,74.03 U49.E12
  BOTTOM w0.14: CN10.18 316.81,77.91 316.95,77.77 319.11,77.77 319.37,78.03 319.37,78.89 319.88,79.4 320.31,79.4 v1(320.67,79.76)
USB30_RX-_MB1: length 211.7
  TOP w0.14: v1(14.66,69.13) 14.96,69.43 15.07,69.43 C429.1
  IN4 w0.114: v1(14.66,69.13) 14.86,69.33 16.43,69.33 17.06,68.69 17.06,67.82 18.4,66.49 20.35,66.49 21.22,67.35 22.01,67.35 24.9,64.45 25.61,64.45 29.17,60.89 38.01,60.89 38.47,61.35 45.04,61.35 45.73,62.05 50.85,62.05 51.04,61.86 57.8,61.86 60.16,59.49 74.23,59.49 77.68,56.04 86,56.04 89.57,59.61 100.96,59.61 107.01,53.56 110.27,53.56 111.39,52.44 112.86,52.44 113.74,53.32 118.54,53.32 121.33,56.11 123.58,56.11 127.76,60.29 133.5,60.29 135.36,62.16 139.04,62.16 141.31,64.43 146.85,64.43 148.38,65.95 149.05,65.95 151.66,68.56 153.17,68.56 153.55,68.93 163.68,68.93 164.04,68.57 172.88,68.57 173.35,68.11 180.17,68.11 180.51,68.45 186.9,68.45 187.02,68.32 187.72,68.32 188.5,69.09 193.87,69.09 199.65,74.87 200.35,74.87 v1(200.65,74.58)
  BOTTOM w0.102: U49.D10 202.63,75.3 202.57,75.26 202.26,74.95 201.3,74.95 201.11,74.76 200.83,74.76 v1(200.65,74.58)
USB30_RX-_MB1_C: length 10.2
  TOP w0.14: v1(18.69,59.21) 18.73,59.21 18.91,59.4 18.91,59.62 18.77,59.76 R543.1 ; v1(19.11,53.15) 19,53.15 18.86,53.01 18.86,52.83 19.08,52.61 L16.1
  IN4 w0.086: v1(18.69,59.21) 18.72,59.24 18.84,59.24 18.94,59.14 18.94,54.23 19.64,53.53 19.64,52.9 19.41,52.67 18.95,52.67 18.85,52.77 18.85,53.11 18.93,53.19 19.07,53.19 v1(19.11,53.15)
USB30_RX-_MB1_C_R: length 9.1
  TOP w0.14: CN15.5 15.12,48.9 15.12,49.07 16.01,49.96 16.54,49.96 17.32,49.17 17.32,48.74 17.81,48.25 18.78,48.25 19.46,48.93 D49.1 19.46,50.15 19.41,50.2 19.41,50.75 19.08,51.08 L16.2
USB30_RX-_MB1_RTI: length 2.7
  TOP w0.14: R543.2 18.86,60.37 18.86,60.47 18.75,60.58 18.37,60.58 17.79,61.16 17.79,61.8 17.81,61.82 U24.20
USB30_RX-_MB1_RTO: length 4.9
  TOP w0.14: C429.2 15.72,69.23 15.72,69.43 15.85,69.56 16.41,69.56 17.29,68.69 17.29,67.81 17.96,67.13 17.96,66.95 17.81,66.79 U24.9
USB30_RX-_WWAN: length 138.7
  TOP w0.14: v1(306.52,86.64) 306.28,86.4 305.41,86.4 R204.2
  IN1 w0.114: v1(306.52,86.64) 306.52,86.49 306.34,86.31 306.04,86.31 304.31,84.58 304.31,82.5 303.95,82.13 303.95,81.9 303.59,81.54 301.55,81.54 300,79.99 297,79.99 296.83,79.82 291.55,79.82 290.45,78.73 286.76,78.73 284.57,76.54 283.75,76.54 281.99,74.79 281.99,73.51 281.41,72.93 280.02,72.93 279.22,73.74 278.38,73.74 277.9,73.25 277.9,72.2 274.63,68.93 274.63,66.55 272.85,64.77 272.85,62.9 271.68,61.73 271.68,60.14 269.66,58.12 267.08,58.12 266.07,57.11 263.35,57.11 262.79,56.55 260.15,56.55 259.66,57.05 258,57.05 257.06,56.11 248.42,56.11 248.08,55.77 244.66,55.77 242.29,53.4 239.51,53.4 238.51,52.4 235.36,52.4 234.78,52.99 230.12,52.99 229.29,53.81 227.26,53.81 226.83,53.38 220.31,53.38 217.36,56.33 215.55,56.33 214.01,57.87 211.49,57.87 211.08,58.28 211.08,60.8 210.72,61.15 210.48,61.15 208.12,63.51 208.12,63.98 207.57,64.52 207.57,65.09 207.96,65.48 207.96,65.97 206.86,67.07 206.86,69.51 206.57,69.8 206.34,69.8 205.84,70.3 205.84,71.53 205.95,71.65 v1(206.12,71.65)
  BOTTOM w0.102: U49.L16 205.94,72.16 205.84,72.05 205.84,71.75 205.94,71.65 v1(206.12,71.65)
USB30_TX+_DB1: length 160.8
  IN1 w0.114: v1(203.64,76.6) 203.46,76.78 203.46,77.02 203.58,77.13 204.12,77.13 204.5,77.51 204.5,77.97 205.18,78.65 206.59,78.65 207.09,79.15 207.09,81.1 207.47,81.48 207.8,81.48 208.03,81.25 211.36,81.25 212.73,82.61 214.96,82.61 215.3,82.95 218.48,82.95 218.57,83.05 223.83,83.05 224.54,82.34 226.77,82.34 228.15,80.96 230.66,80.96 232.91,78.72 232.91,78.36 234.14,77.13 235.5,77.13 236.51,76.12 246.01,76.12 247.15,77.27 248.02,77.27 251.51,80.76 251.51,83.52 253.16,85.17 264.56,85.17 264.87,84.86 269.62,84.86 269.76,85.01 272.14,85.01 272.24,84.91 275.02,84.91 275.12,85.01 279.89,85.01 280.2,85.31 281.21,85.31 282.98,87.09 291.37,87.09 294.72,90.44 297.4,90.44 298.02,91.05 303.77,91.05 304.08,90.74 307.87,90.74 308.38,91.26 312.79,91.26 313.36,91.84 318.08,91.84 319.17,92.93 320.33,92.93 320.85,92.41 320.85,80.87 321.08,80.63 321.08,75.7 319.68,74.3 319.68,73.04 319.21,72.57 318.68,72.57 318.32,72.21 318.32,71.42 318.21,71.31 v1(318.07,71.31)
  BOTTOM w0.102: v1(203.64,76.6) 203.76,76.6 203.86,76.7 203.86,77.03 203.76,77.13 U49.F6
  BOTTOM w0.14: CN10.31 316.79,71.41 317.05,71.67 317.46,71.67 317.71,71.92 318.02,71.92 318.28,71.66 318.28,71.45 318.14,71.31 v1(318.07,71.31)
USB30_TX+_DB2: length 158.2
  IN1 w0.114: v1(207.39,72.95) 207.24,72.8 207.24,72.58 207.39,72.43 207.88,72.43 208.01,72.56 208.63,72.56 209.38,73.3 209.38,75.25 209.25,75.38 209.25,76.02 209.74,76.51 211.21,76.51 211.61,76.11 213.14,76.11 214.28,77.26 214.79,77.26 215.47,77.94 217.31,77.94 217.5,77.74 219.77,77.74 220.16,77.36 220.16,77.13 220.34,76.95 221.23,76.95 221.45,76.74 222.08,76.74 223.91,74.91 227.26,74.91 227.85,74.32 229.83,74.32 242.11,62.04 248.28,62.04 248.76,61.56 252.22,61.56 253.88,59.89 260.26,59.89 261.04,60.67 264.7,60.67 265.99,61.96 268.12,61.96 268.91,62.76 268.91,64.52 272.47,68.08 272.47,69.77 275.78,73.08 275.78,74.14 278.94,77.3 278.94,78.36 279.45,78.88 282.27,78.88 283.22,79.83 284.53,79.83 284.76,80.06 284.76,80.51 285.22,80.96 289.65,80.96 290.62,81.94 295.8,81.94 295.99,82.13 297.7,82.13 297.97,82.4 297.97,82.89 298.68,83.61 300.21,83.61 300.46,83.85 300.46,87.44 301.74,88.72 302.47,88.72 302.81,88.38 308.23,88.38 308.66,87.95 311.53,87.95 312.05,88.46 313.48,88.46 313.9,88.89 316.38,88.89 317.26,88 317.37,88 318.47,86.9 318.47,81.01 317.5,80.05 317.5,79.05 319.13,77.43 319.13,76.59 318.49,75.96 317.88,75.96 317.71,75.79 v1(317.71,75.79)
  BOTTOM w0.102: U49.M13 v1(207.39,72.95)
  BOTTOM w0.14: v1(317.71,75.79) 317.48,76.02 316.92,76.02 316.81,75.91 CN10.22
USB30_TX+_MB1: length 205.3
  TOP w0.14: C435.1 23.37,68.62 23.95,68.62 24.01,68.55 24.1,68.55 24.21,68.44 v1(24.21,68.19)
  IN1 w0.114: v1(203.29,78.44) 203.29,78.25 203.17,78.14 203,78.14 202.57,77.72 202.57,77.36 201.21,76 200.39,76 197.93,73.54 197.93,72.09 192.14,66.3 190.25,66.3 186.77,62.82 183.11,62.82 182.84,62.55 181.18,62.55 180.07,63.66 177.9,63.66 177.55,63.31 173.75,63.31 172.87,62.43 172.3,62.43 172.14,62.59 167.77,62.59 165.75,60.57 161.28,60.57 160.35,61.5 157.87,61.5 157.51,61.86 149.94,61.86 148.92,60.84 144.37,60.84 143.66,60.13 133.86,60.13 133.54,59.81 123.63,59.81 123,59.18 118.74,59.18 118.02,58.46 112.63,58.46 111.9,57.73 107.05,57.73 106.31,58.47 97,58.47 96.52,58.94 92.64,58.94 92.17,58.47 90.34,58.47 89.74,59.07 80.67,59.07 80.21,58.61 80.21,57.88 80.1,57.77 v1(79.8,57.77)
  IN4 w0.114: v1(24.21,68.19) 24.21,68.48 24.09,68.59 23.17,68.59 22.94,68.37 22.94,67.9 24.84,66 26.67,66 27.21,65.47 27.21,65.11 28.57,63.74 34.27,63.74 35.46,62.55 43.87,62.55 44.53,63.21 59.13,63.21 60.65,61.68 74.25,61.68 78.74,57.19 79.98,57.19 80.22,57.42 80.22,57.71 80.09,57.84 79.87,57.84 v1(79.8,57.77)
  BOTTOM w0.102: U49.C3 202.65,78.3 203.02,78.3 203.08,78.24 203.19,78.24 203.29,78.34 v1(203.29,78.44)
USB30_TX+_MB1_C: length 10.2
  TOP w0.14: v1(17.65,57.54) 17.34,57.86 17.34,58.05 17.48,58.19 18.71,58.19 18.87,58.03 18.87,57.89 18.79,57.82 L15.4 ; C496.2 21.11,59.5 v1(21.37,59.24)
  IN1 w0.086: v1(17.65,57.54) 17.65,57.23 17.53,57.11 17.23,57.11 17.09,57.25 17.09,58.02 17.59,58.51 20.82,58.51 21.05,58.74 21.05,59.1 21.2,59.24 v1(21.37,59.24)
USB30_TX+_MB1_C_R: length 8.2
  TOP w0.14: L15.3 18.79,56.11 18.95,55.95 18.95,55.43 18.8,55.28 D47.1 18.8,54.86 18.95,54.71 18.95,54.19 18.75,53.99 18.22,53.99 18.05,54.16 17.58,54.16 16.61,55.14 15.99,55.14 15.61,55.52 15,55.52 14.77,55.75 CN15.9
USB30_TX+_MB1_RTI: length 4.2
  TOP w0.14: U24.2 20.61,66.78 20.54,66.84 20.54,66.95 20.82,67.22 21.15,67.22 21.24,67.31 21.44,67.31 21.96,67.84 21.96,68.55 22.14,68.73 22.48,68.73 22.62,68.59 22.62,68.33 C435.2
USB30_TX+_MB1_RTO: length 2.2
  TOP w0.14: U24.27 20.61,61.81 20.94,61.48 20.94,60.38 C496.1
USB30_TX+_WWAN: length 148.8
  TOP w0.14: v1(306.61,84.34) 306.33,84.62 305.4,84.62 C296.2
  IN1 w0.114: v1(201,70.96) 201,71 201.12,71.12 201.69,71.12 201.79,71.21 203.64,71.21 204.67,70.18 204.67,68.97 204.75,68.89 204.75,66.84 204.79,66.81 204.79,66.35 204.21,65.78 203.65,65.78 203.09,65.22 203.09,63.86 204.9,62.05 207.49,62.05 207.89,61.66 207.89,60.9 208.15,60.63 209.08,60.63 209.25,60.46 209.25,58.32 210.11,57.46 210.11,56.89 210.5,56.5 211.52,56.5 212.43,55.59 214.83,55.59 216.11,54.31 216.11,53.47 216.76,52.82 218.87,52.82 219.34,52.34 227.3,52.34 227.71,52.76 228.2,52.76 229,51.96 234.35,51.96 234.94,51.37 239.19,51.37 240.08,52.26 242.61,52.26 244.92,54.58 248.34,54.58 248.66,54.89 263.07,54.89 263.98,55.79 266.5,55.79 267.8,57.09 270.24,57.09 270.74,57.6 271.25,57.6 272.39,58.74 272.39,59.4 272.85,59.86 274.3,59.86 274.57,60.13 274.57,61.98 275.75,63.16 275.75,68.59 277.8,70.65 278.59,70.65 279.27,71.33 282.52,71.33 283.11,71.92 283.11,74.43 284.18,75.5 284.98,75.5 287.17,77.69 290.95,77.69 291.05,77.79 296.34,77.79 297.51,78.96 303.64,78.96 304.97,80.29 304.97,81.62 305.38,82.03 305.38,84 305.96,84.58 306.37,84.58 v1(306.61,84.34)
  BOTTOM w0.102: U49.C17 202.46,71.48 202.46,71.34 202.26,71.14 202.06,71.14 201.87,70.94 201.36,70.94 201.26,71.04 201.18,71.04 201.1,70.96 v1(201,70.96)
USB30_TX-_DB1: length 160.8
  IN1 w0.114: v1(318.77,71.31) 318.55,71.53 318.55,72.11 318.78,72.34 319.3,72.34 319.91,72.95 319.91,74.2 321.31,75.6 321.31,80.73 321.08,80.96 321.08,92.5 320.42,93.16 319.08,93.16 317.99,92.06 313.27,92.06 312.69,91.49 308.29,91.49 307.77,90.97 304.18,90.97 303.87,91.28 297.92,91.28 297.31,90.67 294.62,90.67 291.27,87.32 282.89,87.32 281.11,85.54 280.1,85.54 279.8,85.24 275.03,85.24 274.93,85.14 272.33,85.14 272.23,85.24 269.67,85.24 269.53,85.09 264.96,85.09 264.65,85.4 253.07,85.4 251.28,83.62 251.28,80.85 247.93,77.5 247.06,77.5 245.91,76.35 236.6,76.35 235.59,77.36 234.23,77.36 233.13,78.46 233.13,78.81 230.76,81.19 228.24,81.19 226.87,82.56 224.63,82.56 223.92,83.27 218.48,83.27 218.38,83.18 215.21,83.18 214.87,82.84 212.63,82.84 211.27,81.48 208.13,81.48 207.9,81.71 207.38,81.71 206.86,81.19 206.86,79.24 206.5,78.88 205.09,78.88 204.27,78.06 204.27,77.6 204.03,77.36 203.4,77.36 v1(203.26,77.5)
  BOTTOM w0.102: v1(203.26,77.5) 203.25,77.49 202.71,77.49 U49.D5
  BOTTOM w0.14: v1(318.77,71.31) 318.52,71.56 318.52,71.76 318.12,72.16 317.61,72.16 317.36,71.91 CN10.30
USB30_TX-_DB2: length 158.2
  IN1 w0.114: v1(317.7,76.5) 317.7,76.31 317.82,76.19 318.4,76.19 318.9,76.69 318.9,77.33 317.27,78.96 317.27,80.14 318.24,81.11 318.24,86.8 317.27,87.77 317.17,87.77 316.28,88.66 314,88.66 313.57,88.23 312.14,88.23 311.63,87.72 308.57,87.72 308.13,88.15 302.72,88.15 302.37,88.49 301.83,88.49 300.68,87.35 300.68,83.76 300.3,83.38 298.78,83.38 298.2,82.8 298.2,82.31 297.79,81.9 296.08,81.9 295.89,81.71 290.72,81.71 289.74,80.73 285.31,80.73 284.99,80.41 284.99,79.97 284.62,79.6 283.31,79.6 282.37,78.65 279.55,78.65 279.17,78.27 279.17,77.2 276.01,74.04 276.01,72.98 272.7,69.67 272.7,67.98 269.14,64.43 269.14,62.66 268.22,61.74 266.09,61.74 264.79,60.44 261.13,60.44 260.36,59.66 253.79,59.66 252.12,61.33 248.67,61.33 248.19,61.81 242.01,61.81 229.74,74.09 227.76,74.09 227.17,74.68 223.81,74.68 221.98,76.51 221.35,76.51 221.14,76.72 220.24,76.72 219.93,77.03 219.93,77.26 219.68,77.51 217.41,77.51 217.21,77.71 215.57,77.71 214.88,77.03 214.38,77.03 213.24,75.88 211.52,75.88 211.12,76.28 209.83,76.28 209.48,75.93 209.48,75.48 209.61,75.35 209.61,73.2 208.73,72.33 208.11,72.33 207.98,72.2 207.3,72.2 207.02,72.48 207.02,72.78 206.89,72.91 v1(206.66,72.91)
  BOTTOM w0.102: U49.M15 v1(206.66,72.91)
  BOTTOM w0.14: CN10.21 316.79,76.41 316.93,76.26 317.46,76.26 v1(317.7,76.5)
USB30_TX-_MB1: length 205.3
  TOP w0.14: C428.1 23.25,68.89 23.26,68.89 23.29,68.86 24.05,68.86 v1(24.21,69.02)
  IN1 w0.114: v1(80.63,57.77) 80.44,57.95 80.44,58.51 80.76,58.84 89.64,58.84 90.24,58.24 92.26,58.24 92.74,58.71 96.43,58.71 96.9,58.24 106.22,58.24 106.95,57.5 111.99,57.5 112.72,58.23 118.12,58.23 118.84,58.95 123.1,58.95 123.72,59.58 133.64,59.58 133.96,59.9 143.76,59.9 144.46,60.61 149.01,60.61 150.04,61.63 157.41,61.63 157.78,61.27 160.25,61.27 161.18,60.34 165.85,60.34 167.87,62.36 172.04,62.36 172.21,62.2 172.96,62.2 173.85,63.08 177.65,63.08 178,63.43 179.97,63.43 181.08,62.32 182.94,62.32 183.2,62.59 186.86,62.59 190.35,66.07 192.23,66.07 198.16,72 198.16,73.45 200.48,75.77 201.31,75.77 202.8,77.26 202.8,77.62 203.09,77.91 203.74,77.91 v1(203.81,77.84)
  IN4 w0.114: v1(24.21,69.02) 24.01,68.82 23.07,68.82 22.71,68.46 22.71,67.81 24.74,65.77 26.58,65.77 26.98,65.37 26.98,65.01 28.48,63.51 34.17,63.51 35.37,62.32 43.96,62.32 44.62,62.98 59.03,62.98 60.56,61.46 74.15,61.46 78.64,56.96 80.08,56.96 80.44,57.33 80.44,57.59 v1(80.63,57.77)
  BOTTOM w0.102: U49.D4 202.98,78.03 203.62,78.03 v1(203.81,77.84)
USB30_TX-_MB1_C: length 10.2
  TOP w0.14: v1(16.65,57.54) 16.92,57.82 16.92,58.23 17.3,58.61 18.88,58.61 19.29,58.21 19.29,57.97 19.37,57.89 L15.1 ; C495.2 20.68,59.43 v1(20.68,59.25)
  IN1 w0.086: v1(20.68,59.25) 20.81,59.11 20.81,58.84 20.72,58.75 17.49,58.75 16.85,58.12 16.85,57.75 v1(16.65,57.54)
USB30_TX-_MB1_C_R: length 8.2
  TOP w0.14: CN15.8 14.77,54.77 15.1,55.1 15.43,55.1 15.81,54.72 16.43,54.72 17.41,53.75 17.87,53.75 18.04,53.58 18.93,53.58 19.37,54.01 19.37,54.78 19.4,54.82 D46.1 19.4,55.32 19.37,55.35 L15.2
USB30_TX-_MB1_RTI: length 4.2
  TOP w0.14: C428.2 22.4,68.97 22.04,68.97 21.72,68.65 21.72,67.94 21.34,67.55 21.14,67.55 21.05,67.46 20.72,67.46 20.3,67.05 20.3,66.88 20.21,66.78 U24.3
USB30_TX-_MB1_RTO: length 2.2
  TOP w0.14: C495.1 20.52,60.38 20.52,61.3 20.21,61.62 U24.26
USB30_TX-_WWAN: length 148.8
  TOP w0.14: C288.2 305.43,84.86 306.3,84.86 v1(306.61,85.16)
  IN1 w0.114: v1(306.61,85.16) 306.61,85.07 306.34,84.81 305.87,84.81 305.15,84.09 305.15,82.13 304.74,81.71 304.74,80.39 303.54,79.19 297.42,79.19 296.24,78.02 290.96,78.02 290.86,77.92 287.07,77.92 284.89,75.73 284.09,75.73 282.88,74.52 282.88,72.01 282.43,71.56 279.18,71.56 278.49,70.87 277.7,70.87 275.52,68.69 275.52,63.25 274.34,62.08 274.34,60.22 274.2,60.08 272.76,60.08 272.16,59.49 272.16,58.83 271.15,57.82 270.65,57.82 270.15,57.32 267.71,57.32 266.41,56.02 263.88,56.02 262.98,55.12 248.56,55.12 248.25,54.8 244.83,54.8 242.51,52.49 239.99,52.49 239.1,51.6 235.03,51.6 234.45,52.19 229.09,52.19 228.3,52.98 227.62,52.98 227.2,52.57 219.44,52.57 218.96,53.05 216.86,53.05 216.34,53.57 216.34,54.41 214.92,55.82 212.52,55.82 211.62,56.73 210.6,56.73 210.34,56.99 210.34,57.56 209.48,58.41 209.48,60.55 209.17,60.86 208.25,60.86 208.12,61 208.12,61.75 207.59,62.28 204.99,62.28 203.32,63.96 203.32,65.13 203.74,65.55 204.31,65.55 205.01,66.26 205.01,66.91 204.98,66.94 204.98,68.98 204.9,69.07 204.9,70.27 203.73,71.44 201.69,71.44 201.6,71.35 201.25,71.35 v1(200.98,71.62)
  BOTTOM w0.102: U49.B17 202.19,71.57 202.26,71.49 202.26,71.43 202.18,71.34 201.97,71.34 201.78,71.15 201.44,71.15 200.98,71.61 v1(200.98,71.62)
USB_BC_ON: length 389.4
  TOP w0.14: U6.4 309.64,95.22 309.29,94.88 308.2,94.88 307.98,95.1 307.5,95.1 306.9,95.69 306.05,95.69 v1(305.75,95.99) ; v1(316.43,94.62) 316.67,94.85 U7.4 ; U23.97 181.91,73.74 182.06,73.89 182.6,73.89 183.12,73.37 v1(183.12,73.35)
  IN1 w0.086: v1(305.75,95.99) 307.83,95.99 308.94,94.88 309.3,94.88 309.63,95.21 310.72,95.21 311.31,94.62 v1(316.43,94.62)
  IN3 w0.089: v1(183.12,73.35) 183.03,73.26 183.03,72.69 184.23,71.49 185.81,71.49 186.4,70.89 186.4,70.26 186.05,69.91 184.69,69.91 184.05,69.27 180.85,69.27 179.22,70.89 178.53,70.89 177.8,70.16 165.84,70.16 165.49,70.51 159.26,70.51 158.21,69.45 155.48,69.45 154.45,70.48 140.56,70.48 139.54,69.46 133.94,69.46 132.7,68.22 131.13,68.22 129.77,66.86 124.37,66.86 122.99,65.48 110.4,65.48 109.1,64.18 94.89,64.18 94.52,64.55 66.31,64.55 62.19,60.43 61.27,60.43 57,56.17 53.7,56.17 53.09,55.56 47.81,55.56 46.75,54.5 38.17,54.5 37.66,55.01 30.73,55.01 v1(28.6,52.88) ; v1(183.25,49.47) 183.25,49.47 183.26,49.49 183.6,49.49 184.42,48.67 187.44,48.67 190.9,45.21 194.04,45.21 194.7,44.54 197.54,44.54 198.63,43.45 200.04,43.45 200.29,43.7 208.58,43.7 210.3,45.42 211.5,45.42 211.76,45.16 218.81,45.16 218.95,45.3 220.54,45.3 221.32,46.08 221.32,46.8 221.6,47.07 222.84,47.07 224.78,49.02 229.71,49.02 230.39,49.69 232.99,49.69 233.15,49.85 237.21,49.85 238.09,50.72 241.45,50.72 243.47,52.75 247.01,52.75 247.67,53.41 249.54,53.41 250.54,52.41 252.09,52.41 252.62,52.94 256.65,52.94 256.96,52.63 260.79,52.63 263.25,55.09 264.6,55.09 265.95,56.44 270.64,56.44 271.42,55.67 273.84,55.67 274.71,56.54 275.42,56.54 276,55.96 276.73,55.96 279.35,58.58 279.35,59.29 279.5,59.45 280.09,59.45 280.23,59.31 280.66,59.31 280.88,59.53 280.88,62.37 280.53,62.71 280.53,66.6 280.05,67.08 280.05,69.29 281.03,70.27 281.99,70.27 283.47,71.74 283.47,74.26 284.48,75.27 284.84,75.27 290.66,81.09 290.66,81.56 294.64,85.54 296.14,85.54 296.26,85.65 297,85.65 298.27,86.92 298.27,87.64 301.44,90.81 301.44,92.71 304.52,95.78 305.54,95.78 v1(305.75,95.99)
  BOTTOM w0.14: v1(183.12,73.35) 183.12,73.37 182.43,74.05 182.24,74.05 180.78,72.6 180.78,68.84 179.95,68.01 179.95,67.5 180.3,67.14 180.3,65.05 181.33,64.02 182.34,64.02 182.52,63.84 182.52,62.83 182.91,62.44 182.91,59.1 182.56,58.75 182.56,57.92 183.6,56.87 183.6,54.11 183.85,53.86 183.85,52.02 183.08,51.26 183.08,50.46 183.37,50.17 183.37,49.59 v1(183.25,49.47) ; U52.4 24.66,52.6 24.82,52.44 24.82,51.9 25.43,51.3 26.32,51.3 27.03,52.01 27.73,52.01 v1(28.6,52.88)
USB_CHARGE_ON: length 368.8
  TOP w0.14: v1(180.5,67.85) 180.58,67.93 180.58,68.22 180.59,68.23 180.59,70.47 181.41,71.3 U23.96 ; R171.2 317.5,93.22 v1(317.3,93.43) 317.51,93.64 U7.5 ; U6.5 311.16,93.95 310.65,93.43 R169.2 310.17,93.02 v1(310.06,92.92)
  IN2 w0.089: v1(303.71,82.59) 303.92,82.39 303.92,81.62 303.36,81.06 303.36,80.51 302.95,80.1 301.86,80.1 300.92,81.04 298.94,81.04 297.8,79.9 296.12,79.9 295.57,80.46 293.09,80.46 292.85,80.7 291.03,80.7 289.93,79.6 289.09,79.6 288.55,79.06 287.27,79.06 282.56,74.36 282.56,71.89 282.08,71.41 281.69,71.41 281.53,71.25 281.47,71.25 280.28,70.06 280.28,69.38 279.44,68.54 279.44,66.28 279.96,65.75 279.96,63.27 279.21,62.52 279.21,58.42 278.36,57.58 278.29,57.58 277.33,56.62 277.33,55.48 276.51,54.66 276.51,54.59 274.02,52.09 270.85,52.09 270.11,52.84 267.2,52.84 265.29,50.92 254.94,50.92 253.84,49.82 249.27,49.82 248.7,50.39 245.53,50.39 245.17,50.03 238.65,50.03 238.32,50.36 231.38,50.36 231.28,50.27 220.29,50.27 220.17,50.39 216.33,50.39 214.98,49.03 214.98,48.3 214.6,47.93 208.48,47.93 207.2,46.65 204.89,46.65 204.86,46.62 201.48,46.62 200.87,47.23 195.22,47.23 194.51,47.93 193.75,47.93 192.11,49.57 192.11,50.85 189.73,53.23 189.73,54.94 189.47,55.2 187.29,55.2 185.94,56.55 185.28,56.55 183.67,58.17 v1(183.35,58.17) ; v1(310.06,92.92) 310.75,93.61 315.26,93.61 315.65,93.22 317.09,93.22 v1(317.3,93.43)
  IN3 w0.089: v1(303.71,82.59) 303.41,82.9 303.41,89.97 305.6,92.17 305.6,92.75 305.84,92.99 308.48,92.99 308.75,92.72 309.86,92.72 v1(310.06,92.92) ; v1(180.5,67.85) 179.32,67.85 177.58,69.59 165.6,69.59 165.26,69.93 159.5,69.93 158.44,68.88 155.25,68.88 154.22,69.91 140.8,69.91 139.78,68.89 134.18,68.89 132.94,67.65 131.36,67.65 130,66.29 124.61,66.29 123.23,64.91 110.65,64.91 109.35,63.61 94.65,63.61 94.28,63.98 66.59,63.98 66.06,63.45 62.47,59.86 61.51,59.86 56.63,54.99 48.05,54.99 46.36,53.3 38.51,53.3 35.72,50.51 25.61,50.51 25.46,50.36 v1(24.76,50.36)
  BOTTOM w0.14: v1(24.76,50.36) 24.6,50.2 R1115.1 24,50.24 24,50.75 23.66,51.09 23.39,51.09 23.2,51.27 U52.5 ; v1(183.35,58.17) 183.33,58.17 183.19,58.31 183.19,62.56 182.8,62.95 182.8,63.95 182.45,64.3 181.44,64.3 180.58,65.16 180.58,67.77 v1(180.5,67.85)
USB_CLT1: length 365
  TOP w0.14: U6.6 311.67,93.53 v1(311.25,93.12) ; v1(181.15,67.85) 181.17,67.85 181.31,67.71 181.31,63.25 v1(181.59,62.96) 181.89,62.96 182.15,63.22 182.15,63.92 182.72,64.5 U23.79 ; v1(318.01,93.23) 318.02,93.24 U7.6
  IN2 w0.089: v1(303.43,82) 303.43,81.52 303.16,81.26 303.16,80.59 302.87,80.29 301.95,80.29 301.01,81.23 298.86,81.23 297.72,80.09 296.2,80.09 295.67,80.63 293.17,80.63 292.91,80.89 290.95,80.89 289.85,79.79 289.01,79.79 288.48,79.25 287.19,79.25 282.37,74.44 282.37,71.97 282,71.6 281.61,71.6 281.45,71.44 281.39,71.44 280.09,70.14 280.09,69.46 279.25,68.62 279.25,66.2 279.77,65.67 279.77,63.35 279,62.58 279,59.77 278.29,59.06 278.29,57.84 277.14,56.7 277.14,55.56 273.87,52.28 270.93,52.28 270.19,53.03 267.12,53.03 265.29,51.2 254.95,51.2 254.73,50.98 249.73,50.98 249.33,50.58 244.6,50.58 244.24,50.22 238.73,50.22 238.4,50.55 231.3,50.55 231.21,50.46 220.37,50.46 220.25,50.58 216.25,50.58 214.7,49.02 214.67,48.99 212.72,48.99 211.93,48.2 208.9,48.2 207.9,49.19 201.64,49.19 201.1,48.65 196.85,48.65 191.65,53.85 191.65,54.16 189.83,55.97 187.82,55.97 185.73,58.07 184.87,58.07 183.29,59.65 183.29,61.16 181.59,62.86 v1(181.59,62.96) ; v1(318.01,93.23) 317.8,93.03 315.57,93.03 315.18,93.42 311.55,93.42 v1(311.25,93.12)
  IN3 w0.089: v1(23.4,50.56) 23.84,51 35.94,51 38.43,53.49 46.28,53.49 47.97,55.18 56.55,55.18 61.43,60.05 62.35,60.05 66.21,63.91 66.25,63.91 66.51,64.17 94.36,64.17 94.73,63.8 109.27,63.8 110.58,65.1 123.15,65.1 124.53,66.48 129.93,66.48 131.29,67.84 132.86,67.84 134.1,69.08 139.7,69.08 140.72,70.1 154.3,70.1 155.32,69.07 158.36,69.07 159.42,70.12 165.34,70.12 165.68,69.78 177.66,69.78 179.19,68.25 180.86,68.25 181.15,67.96 v1(181.15,67.85) ; v1(303.43,82) 303.22,82.22 303.22,90.05 305.41,92.24 305.41,92.93 304.55,93.79 304.55,94.74 304.83,95.02 307.33,95.02 308.38,93.96 308.38,93.4 308.88,92.91 309.49,92.91 309.89,93.32 311.09,93.32 311.25,93.15 v1(311.25,93.12)
  BOTTOM w0.14: v1(23.4,50.56) 22.7,51.26 U52.6
USB_DB1_OC#: length 154.7
  TOP w0.14: U7.13 319.02,98.6 v1(319.31,98.89) ; R329.1 217.12,77.28 v1(217.12,76.8) 217.12,76.52 216.94,76.35 v1(216.94,75.67)
  IN4 w0.086: v1(216.94,75.67) 216.94,76.16 217.17,76.39 217.17,77.33 217.79,77.95 219.64,77.95 220.04,78.36 221.97,78.36 223.78,80.17 223.78,82.43 225.3,83.95 230.37,83.95 230.79,83.53 230.79,82.49 231.7,81.57 231.87,81.57 236.7,76.75 241.47,76.75 245.14,73.08 245.14,68.85 245.83,68.15 245.83,67.32 246.98,66.17 251.46,66.17 253.93,68.63 264.9,68.63 267.57,65.96 270.2,65.96 271.39,67.16 271.39,68.37 274.9,71.88 274.9,73.87 276.31,75.29 276.31,76.66 279.13,79.47 279.13,79.68 279.76,80.32 279.76,80.34 279.91,80.48 280.24,80.82 280.73,80.82 281.42,80.13 282.1,80.13 282.62,79.61 284.08,79.61 285.85,77.84 288.01,77.84 288.39,78.22 293.3,78.22 293.68,77.84 294.8,77.84 295.32,77.31 297.41,77.31 298.2,76.52 301.33,76.52 301.78,76.97 302.18,76.97 302.85,77.64 306.78,77.64 308.16,79.02 308.16,81.75 308.58,82.17 308.58,83 309.29,83.71 310.65,83.71 310.8,83.86 310.8,85.85 311.89,86.93 311.89,87.8 312.73,88.64 312.92,88.64 314.42,90.14 317.05,90.14 320.4,93.48 320.4,97.63 319.31,98.72 v1(319.31,98.89)
  BOTTOM w0.102: v1(216.94,75.67) 216.94,75.46 U49.AK11
USB_DB2_OC#: length 166.7
  TOP w0.14: R345.1 217.58,76.44 217.44,76.3 v1(217.44,76.09) ; U6.13 312.67,98.11 313.14,98.59 v1(313.14,100.67) 313.14,101.59 v1(313.2,101.65)
  IN4 w0.086: v1(313.2,101.65) 314.51,100.34 318.69,100.34 319.71,99.32 319.71,98.69 320.59,97.82 320.59,93.41 317.13,89.95 314.5,89.95 313,88.45 312.81,88.45 312.08,87.72 312.08,86.86 310.99,85.77 310.99,83.79 310.58,83.38 309.22,83.38 308.76,82.92 308.76,82.09 308.34,81.67 308.34,78.94 306.86,77.46 302.93,77.46 302.26,76.78 301.86,76.78 301.41,76.33 298.03,76.33 297.26,77.1 295.02,77.1 294.52,77.61 293.5,77.61 293.09,78.02 288.7,78.02 288.01,77.33 285.07,77.33 283.98,78.42 283.98,79.29 283.89,79.38 282.58,79.38 282.02,79.94 281.34,79.94 280.65,80.63 280.32,80.63 279.95,80.26 279.95,80.24 279.31,79.61 279.31,79.39 276.5,76.58 276.5,75.21 275.09,73.8 275.09,71.8 271.58,68.3 271.58,67.08 270.28,65.77 267.49,65.77 264.82,68.44 254,68.44 251.54,65.98 246.9,65.98 245.64,67.24 245.64,68.06 244.95,68.76 244.95,73 241.39,76.56 236.62,76.56 235.3,77.88 234.37,77.88 233.01,79.24 233.01,80.17 231.8,81.39 231.63,81.39 230.6,82.41 230.6,83.45 230.29,83.76 225.38,83.76 223.97,82.35 223.97,80.09 222.05,78.17 220.12,78.17 219.71,77.76 217.87,77.76 217.36,77.25 217.36,76.16 v1(217.44,76.09)
  BOTTOM w0.102: v1(217.44,76.09) 217.5,76.02 217.5,75.3 218.04,74.77 218.04,73.63 U49.AP13
USB_OC_MB_TYPEA#: length 229.7
  IN1 w0.086: v1(27.4,51.52) 25.15,51.52 24.72,51.95 24.72,52.95 22.52,55.15 v1(22.52,57.18)
  IN2 w0.089: v1(217.25,73.7) 217.05,73.7 216.49,74.26 214.66,74.26 214.58,74.17 213.12,74.17 212.22,73.27 211.84,73.27 211.57,73 211.57,72.42 211.66,72.33 211.66,71.94 211.49,71.77 210.98,71.77 210.35,71.15 209.96,71.15 209.51,70.7 208.09,70.7 207.39,71.4 207.02,71.4 205.72,70.1 203.14,70.1 202.13,69.09 200.31,69.09 198.6,70.8 194.83,70.8 192.15,73.48 191.06,73.48 190.8,73.21 188.2,73.21 187.2,74.21 181.84,74.21 180.76,75.29 173.7,75.29 173.18,74.77 173.18,74.38 172.84,74.05 168.55,74.05 167.99,74.6 166.37,74.6 165.91,75.07 165.1,75.07 164.47,74.44 161.59,74.44 160.9,75.13 159.5,75.13 158.74,75.89 158.74,76.35 157.7,77.39 153.95,77.39 153.24,76.68 151.92,76.68 151.42,76.18 150.62,76.18 149.32,74.88 145.68,74.88 145.29,74.49 143.01,74.49 142.62,74.88 138.38,74.88 137,76.26 131.89,76.26 131.13,75.5 119.54,75.5 116.33,75.5 114.51,77.32 112.11,77.32 111.61,77.82 110.83,77.82 109.42,79.23 105.12,79.23 105.06,79.17 103.24,79.17 101.72,77.65 94.46,77.65 92.04,80.07 89.6,80.07 87.85,78.32 87.48,78.32 86.71,79.1 69.82,79.1 63.27,72.54 62.83,72.54 60.03,69.74 58.82,69.74 51.38,62.31 51.38,61.85 45.05,55.52 39.54,55.52 37.51,53.49 33.09,53.49 31.12,51.52 v1(27.4,51.52)
  BOTTOM w0.102: U49.AM13 217.24,73.7 v1(217.25,73.7)
  BOTTOM w0.14: U52.13 21.7,56.06 R1053.1 22.11,56.2 22.25,56.34 22.25,56.92 v1(22.52,57.18)
USBP+_CCD: length 222.7
  TOP w0.14: R65.1 280.32,189.82 280.82,189.82 281.36,190.36 281.36,192.54 281.66,192.84 282.15,192.84 282.29,192.98 v1(282.29,193.06)
  IN4 w0.086: v1(282.29,193.06) 282.54,192.81 283.18,192.81 283.74,192.25 283.74,190.57 282.3,189.12 282.3,152.94 281.37,152 281.37,140.4 281.58,140.19 281.58,117.85 275.71,111.98 262.68,111.98 262.32,111.63 251.55,111.63 250.43,112.75 247.77,112.75 247.16,112.14 205.38,112.14 204.03,110.8 200.47,110.8 199.57,109.89 199.57,108.45 200.73,107.29 201.6,107.29 202.12,106.77 202.12,104.52 203.27,103.36 203.27,101.9 203.76,101.41 205.79,101.41 207.73,99.47 209.68,99.47 211.66,97.49 211.66,96.84 211.29,96.47 210.69,96.47 210.56,96.6 209.44,96.6 208.85,97.19 206.65,97.19 203,93.53 203,90.08 202.37,89.45 202.37,88.87 205.23,86.01 205.23,83.43 205.6,83.06 205.6,78.74 206.8,77.55 206.8,76.88 206.49,76.57 206.49,75.24 206.72,75.01 207.29,75.01 207.41,75.12 v1(207.41,75.28)
  BOTTOM w0.102: v1(207.41,75.28) 206.62,75.28 U49.L9
USBP+_CCD_R: length 10.3
  TOP w0.14: R65.2 279.32,190.37 278.18,190.37 277.74,189.93 D6.2 277.01,189.93 276.95,189.88 276.54,189.88 276.31,190.11 272.57,190.11 272.12,189.66 271.1,189.66 270.91,189.85 CN2.28
USBP+_DB1: length 148.1
  TOP w0.14: v1(316.25,92.48) 316,92.72 316,93.99 315.75,94.25 315.75,95.63 315.89,95.77 316.11,95.77 316.15,95.72 U7.3
  IN4 w0.086: v1(206.91,75.69) 206.91,75.85 207,75.94 207.46,75.94 207.69,75.7 208.35,75.7 210.03,77.38 211.03,77.38 211.36,77.71 212.24,77.71 212.53,77.42 215.28,77.42 217.92,80.06 217.92,80.64 218.91,81.64 220.57,81.64 220.76,81.44 222.7,81.44 223.17,81.91 223.17,82.77 223.95,83.55 223.95,84.16 224.32,84.53 224.77,84.53 224.96,84.34 230.53,84.34 231.75,83.12 231.75,82.25 236.71,77.29 242.08,77.29 245.82,73.55 245.82,68.82 247.89,66.75 251.09,66.75 253.55,69.21 262.99,69.21 264.31,70.53 269.26,70.53 269.86,69.93 271.87,69.93 274.32,72.38 274.32,74.11 275.66,75.45 275.66,76.82 276.33,77.49 276.33,80.6 277.23,81.51 280.85,81.51 281.64,80.73 294.74,80.73 297.76,83.76 297.76,84.97 299.15,86.36 299.15,87.38 301.84,90.07 307.08,90.07 308.18,91.16 312.79,91.16 313.42,91.78 315.77,91.78 315.95,91.97 315.95,92.19 v1(316.25,92.48)
  BOTTOM w0.102: U49.L8 206.14,76.24 206.26,76.37 206.41,76.37 206.91,75.86 v1(206.91,75.69)
USBP+_DB1_C: length 23.8
  TOP w0.14: U7.10 320.37,95.72 320.49,95.84 320.61,95.96 320.78,95.96 321,95.74 321,91.33 320.73,91.06 320.53,91.06 320.39,91.21 v1(320.39,91.47)
  IN4 w0.086: v1(320.39,91.47) 320.39,91.22 320.26,91.09 319.9,91.09 319.67,90.86 319.67,88.01 320.49,87.19 320.49,81.13 319.87,80.51 319.87,79.87 319.26,79.26 318.7,79.26 318.6,79.36 v1(318.6,79.7)
  BOTTOM w0.14: v1(318.6,79.7) 318.6,79.52 318.38,79.3 316.89,79.3 316.78,79.41 CN10.15
USBP+_DB2: length 139.2
  TOP w0.14: v1(306.89,96.67) 307.11,96.46 307.11,96.12 307.68,95.54 308.64,95.54 308.94,95.84 309.67,95.84 309.79,95.72 U6.3
  IN4 w0.086: v1(206.33,79.98) 206.33,80.15 206.44,80.25 206.63,80.25 206.83,80.05 206.83,78.8 207.43,78.21 210.59,78.21 210.71,78.33 214.96,78.33 216.51,79.88 216.51,80.43 217.21,81.13 217.21,81.76 218.47,83.02 222.64,83.02 223.31,83.7 223.31,84.31 224.1,85.09 225.13,85.09 225.33,84.9 230.76,84.9 232.31,83.35 232.31,82.48 236.11,78.68 247.12,78.68 252.33,73.47 253.31,73.47 253.95,72.83 253.95,72.51 254.06,72.4 254.06,71.84 255.03,70.87 256.74,70.87 257.18,71.3 262.95,71.3 263.17,71.08 266.77,71.08 267.19,71.51 268.16,71.51 268.21,71.56 270.86,71.56 271.13,71.83 271.13,72.51 271.53,72.91 272.15,72.91 274.64,75.4 274.64,76.99 275.77,78.12 275.77,80.84 277,82.07 281.08,82.07 281.87,81.28 287.88,81.28 288.39,81.8 294.83,81.8 297.21,84.18 297.21,85.2 298.59,86.59 298.59,87.71 301.68,90.79 301.68,91.74 304.25,94.31 304.25,95.86 305.66,97.28 307.06,97.28 307.24,97.1 307.24,96.78 307.13,96.67 v1(306.89,96.67)
  BOTTOM w0.102: v1(206.33,79.98) 206.17,80.14 206.02,80.14 205.92,80.04 205.92,79.19 206.21,78.9 206.21,78.42 206.37,78.26 206.37,78.04 206.36,78.01 206.25,77.64 U49.L5
USBP+_DB2_C: length 29.1
  TOP w0.14: U6.10 314.06,95.72 314.21,95.88 314.32,95.88 314.65,95.55 314.65,94.28 314.16,93.79 314.16,92.36 315.8,90.73 315.8,89.65 315.64,89.49 v1(315.38,89.49)
  IN4 w0.086: v1(317.78,75.08) 317.78,74.87 317.97,74.67 318.29,74.67 318.75,75.13 318.75,77 318.6,77.15 317.49,77.15 315.56,79.09 315.56,81 316.28,81.73 316.28,86.6 316.74,87.06 316.74,87.8 315.81,88.72 315.81,89.4 315.73,89.49 v1(315.38,89.49)
  BOTTOM w0.14: v1(317.78,75.08) 317.5,74.8 316.92,74.8 316.81,74.91 CN10.24
