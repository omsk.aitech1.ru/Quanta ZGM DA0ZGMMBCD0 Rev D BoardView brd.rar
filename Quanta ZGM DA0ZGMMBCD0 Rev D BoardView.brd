# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SMB1_DAT_D: length 8.4
  TOP w0.079: U11.D2 62.32,87.83 62.95,87.83 63.16,87.62 v1(63.5,87.62)
  BOTTOM w0.14: v1(63.5,87.62) 63.5,87.6 TP134.1 64.42,86.96 R862.1 64.8,87.6 64.99,87.79 65.8,87.79 66.38,87.21 66.67,87.21 67.04,87.58 Q106.4 67.65,87.58 67.79,87.44 67.79,86.35 R871.2
SMB_PCH_CLK: length 25.7
  IN3 w0.089: v1(226.32,68.11) 226.32,66.77 227.77,65.32 228.65,65.32 228.91,65.58 228.91,66.34 231.87,69.31 231.87,72.21 230.81,73.27 230.81,77.51 230.26,78.06 230.26,79.03 v1(230.35,79.12)
  BOTTOM w0.102: v1(230.35,79.12) 230.13,79.34 Q108.6 ; U49.BE26 224.37,66.97 224.72,67.32 225.16,67.32 225.94,68.11 v1(226.32,68.11) 226.37,68.11 226.64,68.38 R970.1
SMB_PCH_DAT: length 23.1
  BOTTOM w0.102: U49.BD25 223.5,67.2 224.31,67.2 224.64,67.53 225.07,67.53 225.38,67.83 225.38,68.16 225.74,68.52 226.5,68.52 226.56,68.59 227.17,68.59 227.31,68.73 228.09,68.73 228.43,68.38 229.06,68.38 R969.1 229.16,68.69 229.37,68.9 230.12,68.9 230.58,69.36 230.64,69.36
  BOTTOM w0.14: Q108.3 231.43,81.27 231.78,80.92 231.78,78.43 230.96,77.61 230.96,72.35 231.79,71.52 231.79,69.69 231.47,69.36 v1(230.91,69.36) 230.64,69.36
SMB_RUN_CLK: length 80.2
  IN2 w0.089: v1(229.79,82.72) 229.79,83.48 228.92,84.35 226.25,84.35 225.6,85 223.7,85 223.02,84.32 223.02,81.7 221.86,80.55 221.32,80.55 220.72,81.16 220.72,81.29 220.04,81.96 219.28,81.96 219.06,81.74 218.68,81.74 218.53,81.59 217.78,81.59 216.15,83.21 215,83.21 214.23,82.44 212.41,82.44 211.72,81.75 209.86,81.75 209.44,82.18 208.97,82.18 207.18,83.96 206.18,83.96 201.15,88.99 197.09,88.99 194.98,86.89 188.46,86.89 188.1,86.53 187.06,86.53 v1(186.75,86.83) 187.18,87.26 187.18,99.38 186.54,100.01 186.54,101.15 187.15,101.75 v1(187.16,101.75)
  BOTTOM w0.14: JDIM1.253 186.33,102.27 186.84,101.75 v1(187.16,101.75) ; R912.1 230.3,82.46 230.13,82.28 Q108.1 230.13,81.06 229.99,80.92 229.66,80.92 229.52,81.06 229.52,82.44 v1(229.79,82.72) ; JDIM2.253 186.28,88.6 186.07,88.39 186.07,87.3 186.54,86.83 v1(186.75,86.83)
SMB_RUN_DAT: length 80.1
  IN2 w0.089: v1(229.3,83.2) 229.3,83.3 228.81,83.8 226.14,83.8 225.4,84.53 223.9,84.53 223.48,84.12 223.48,81.51 222.06,80.08 221.13,80.08 220.25,80.96 220.25,81.09 219.85,81.49 219.48,81.49 219.26,81.27 218.88,81.27 218.72,81.12 217.58,81.12 215.96,82.74 215.19,82.74 214.03,81.58 212.67,81.58 212.37,81.28 209.67,81.28 209.24,81.71 208.3,81.71 207.49,82.51 207.49,82.99 206.99,83.49 205.99,83.49 200.96,88.52 197.28,88.52 195.17,86.42 188.65,86.42 186.57,84.33 186.57,84.33 186.57,83.81 v1(186.97,83.4) 186.41,83.4 186.03,83.78 186.03,87.11 186.31,87.39 186.31,88.48 186.71,88.88 186.71,97.2 v1(186.41,97.5)
  BOTTOM w0.14: JDIM1.254 186.58,97.36 186.44,97.5 v1(186.41,97.5) ; v1(186.97,83.4) 186.53,82.96 JDIM2.254 ; R923.1 231.39,79.37 231.43,79.41 Q108.4 231.43,80.54 231.29,80.67 229.47,80.67 229.28,80.87 229.28,83.18 v1(229.3,83.2)
SMB_SML0_CLK: length 237.7
  IN2 w0.089: v1(37.85,75.27) 37.85,75.78 38.36,76.29 38.36,82 39.12,82.77 39.12,83.02 38.61,83.53 38.48,83.53 37.65,84.37 v1(37.65,84.42) ; v1(225.05,64.76) 225.03,64.74 223.85,64.74 223.21,65.38 221.73,65.38 221.52,65.16 220.75,65.16 220.34,64.75 220.34,63.58 219.32,62.56 219.13,62.56 218.39,61.82 218.02,61.82 217.75,62.09 217.75,62.23 217.47,62.51 212.23,62.51 211.56,63.18 210.91,63.18 210.33,63.76 208.64,63.76 207.65,64.74 207.65,65.85 206.6,66.91 202.99,66.91 202.54,67.36 199.65,67.36 198.61,68.4 197.69,68.4 197.36,68.73 193.7,68.73 192.25,70.19 189.91,70.19 188.48,71.61 187.53,71.61 186.54,72.61 185.5,72.61 184.83,71.94 181.54,71.94 180.85,72.62 174.59,72.62 173.93,71.96 167.68,71.96 167.34,72.3 164.59,72.3 163.99,71.71 162.13,71.71 161.49,72.35 159.87,72.35 159.57,72.65 157.39,72.65 156.96,73.08 155.38,73.08 155.14,72.84 146.57,72.84 146.23,72.5 142.17,72.5 141.84,72.84 136.91,72.84 136.01,73.74 133.01,73.74 132.58,73.31 123.36,73.31 118.37,68.31 110.9,68.31 106.31,72.9 106.31,75.64 105.18,76.77 103.37,76.77 102.11,75.5 102.11,75.37 101.16,74.43 v1(101.16,73.63)
  IN4 w0.086: v1(37.85,75.27) 37.98,75.15 37.98,70.91 39.02,69.86 39.02,68.9 40.66,67.25 46.31,67.25 48.45,65.11 83.72,65.11 84.38,65.77 87.29,65.77 93.73,72.22 98.27,72.22 99.57,73.52 101.05,73.52 v1(101.16,73.63)
  BOTTOM w0.102: U49.BE32 223.59,64.19 224.15,64.76 v1(225.05,64.76) 225.28,64.99 225.55,64.99 225.86,65.29 227.72,65.29 227.9,65.11 228.58,65.11 R986.1
  BOTTOM w0.14: v1(37.65,84.42) 37.65,84.54 37.34,84.85 R1222.2 ; R1224.2 38.23,74.89 v1(37.85,75.27)
SMB_SML0_CLK_R1: length 3.9
  TOP w0.079: U9.A7 38.63,86.94 38.3,86.6 38.03,86.6 37.85,86.42
  TOP w0.14: R219.1 v1(37.37,85.94) 37.85,86.42
  BOTTOM w0.14: R1222.1 37.34,85.91 v1(37.37,85.94)
SMB_SML0_CLK_R2: length 11.3
  TOP w0.079: 33.28,69.15 33.39,69.26 33.71,69.26 34.06,69.62 U16.A7
  TOP w0.14: R445.1 v1(33.01,68.89) 33.28,69.15
  IN1 w0.086: v1(33.01,68.89) 32.9,69 32.9,70.19 33.4,70.7 37.19,70.7 v1(37.47,70.42)
  BOTTOM w0.14: v1(37.47,70.42) 38.23,71.18 R1224.1
SMB_SML0_DAT: length 240.2
  IN2 w0.089: v1(38.61,75.4) 38.87,75.65 38.87,81.62 39.63,82.39 39.63,83.4 38.61,84.42 v1(38.33,84.42) ; v1(102.54,73.59) 102.54,74.63 104.21,76.3 104.99,76.3 105.84,75.45 105.84,72.7 110.7,67.84 118.56,67.84 123.05,72.33 133.23,72.33 134.15,73.26 135.82,73.26 136.72,72.37 141.64,72.37 141.98,72.03 146.43,72.03 146.76,72.37 155.33,72.37 155.58,72.61 156.77,72.61 157.2,72.18 159.37,72.18 159.67,71.88 161.29,71.88 161.94,71.24 164.21,71.24 164.8,71.83 167.15,71.83 167.49,71.49 174.12,71.49 174.61,71.98 180.83,71.98 181.34,71.47 185.02,71.47 185.7,72.14 186.34,72.14 187.34,71.14 188.29,71.14 189.72,69.72 192.05,69.72 193.51,68.26 196.44,68.26 197.81,66.89 202.34,66.89 204.02,65.21 206.52,65.21 208.44,63.29 209.56,63.29 210.53,62.31 210.53,62.12 211.11,61.54 214.12,61.54 214.84,60.81 218.43,60.81 219,61.38 219.75,61.38 220.52,62.14 220.52,63.09 220.81,63.38 220.81,64.07 221.43,64.69 221.71,64.69 221.87,64.85 222.43,64.85 222.56,64.73 223.2,64.73 224.2,63.73 224.7,63.73 225.55,64.58 v1(225.68,64.58)
  IN4 w0.086: v1(102.54,73.59) 102.02,74.1 99.5,74.1 98.08,72.68 93.54,72.68 87.14,66.29 84.23,66.29 83.52,65.58 48.65,65.58 46.5,67.72 40.96,67.72 39.5,69.18 39.5,70.07 38.48,71.08 38.48,75.27 v1(38.61,75.4)
  BOTTOM w0.102: U49.BC33 222.27,63.71 222.63,63.71 222.76,63.84 223.7,63.84 223.87,64.01 223.87,64.16 224.24,64.54 224.66,64.54 224.87,64.33 225.43,64.33 v1(225.68,64.58) 226.19,65.09 227.64,65.09 227.82,64.91 228.49,64.91 228.66,64.74 228.66,64.53 228.91,64.27 R989.1
  BOTTOM w0.14: R1225.2 38.99,75.02 v1(38.61,75.4) ; v1(38.33,84.42) 38.33,84.57 38.1,84.8 R1223.2
SMB_SML0_DAT_R1: length 4.1
  TOP w0.079: 38.43,86.42 38.87,86.86 38.87,88.09 U9.B7
  TOP w0.14: 38.43,86.42 38.06,86.06 v1(38.06,85.9) 37.96,85.9 37.72,85.66 R220.1
  BOTTOM w0.14: R1223.1 38.1,85.87 v1(38.06,85.9)
SMB_SML0_DAT_R2: length 12.4
  TOP w0.079: 34.01,69.15 34.29,69.43 34.29,70.81 U16.B7
  TOP w0.14: 34.01,69.15 33.73,68.87 v1(33.68,68.87) 33.15,68.34 R446.1
  IN1 w0.086: v1(33.68,68.87) 33.15,69.4 33.15,70.07 33.53,70.45 36.71,70.45 37.34,69.81 v1(37.77,69.81)
  BOTTOM w0.14: R1225.1 38.99,71.03 v1(38.65,70.69) v1(37.77,69.81)
SML0ALERT#: length 6.9
  BOTTOM w0.102: U49.BD27 223.31,66.08 223.73,66.08 223.99,66.33 224.36,66.33 224.36,66.33 224.59,66.33 224.97,66.71 227.46,66.71 R980.1 227.48,66.98 227.58,67.08 228.25,67.08 228.88,66.44 R982.2
SML1ALERT#_R: length 7.3
  BOTTOM w0.102: R1019.1 228.9,59.31 227.72,59.31 227.54,59.49 R1017.2 227.42,59.66 227.06,59.3 225.45,59.3 225.12,59.63 224.76,59.63 224.56,59.43 224.07,59.43 223.91,59.28 222.9,59.28 U49.BD42
SML2ALERT#: length 6.6
  BOTTOM w0.102: R924.1 229.24,78.73 229.24,77.95 v1(229.1,77.82) 228.89,77.6 227.71,77.6 227.62,77.7 R927.2 227.16,77.94 226.67,77.46 U49.BG5
SML3ALERT#: length 10.4
  BOTTOM w0.102: R937.1 229.14,76.09 229.34,75.89 229.42,75.89 229.59,75.73 R941.2 229.59,75.16 229.44,75.01 228.69,75.01 228.04,75.65 227.61,75.65 227.28,75.99 225.41,75.99 224.92,75.5 223.77,75.5 223.71,75.56 222.96,75.56 221.76,74.37 U49.BA11
SMLALERT#: length 8.8
  BOTTOM w0.102: U49.BD26 223.23,66.54 223.98,66.54 224.51,66.54 224.89,66.92 227.13,66.92 227.5,67.28 228.55,67.28 R979.2
  BOTTOM w0.14: R979.2 228.88,67.61 229.05,67.77 R974.1 229.26,67.67 229.26,67.51 229.4,67.37 R976.2
SNDW_RCOMP: length 5.7
  BOTTOM w0.102: R965.2 228.51,69.31 228.13,68.93 227.23,68.93 227.09,68.79 226.48,68.79 226.41,68.73 226.05,68.73 225.47,69.3 224.73,69.3 224.63,69.41 223.75,69.41 U49.BF21
SNN_FBA_RFU_G5: length 1.4
  TOP w0.14: TPG31.1 205.64,148.17 v2(205.44,148.38)
  BOTTOM w0.102: VRAM6.G5 205.38,148.44 v2(205.44,148.38)
SNN_FBA_RFU_G5_1: length 3.6
  TOP w0.14: v2(208.75,130.35) 208.81,130.41 208.81,131.07 207.99,131.89 TPG48.1
  BOTTOM w0.102: v2(208.75,130.35) 209.1,130.7 VRAM8.G5
SNN_FBA_RFU_M5: length 1.6
  TOP w0.14: TPG35.1 208.66,148.17 v2(208.86,148.37)
  BOTTOM w0.102: VRAM6.M5 209.13,148.63 v2(208.86,148.37)
SNN_FBA_RFU_M5_1: length 1.6
  TOP w0.14: v2(205.56,131.25) 205,131.8 TPG47.1
  BOTTOM w0.102: v2(205.56,131.25) 205.56,130.88 VRAM8.M5
SNN_FBA_TCK0: length 1.5
  TOP w0.14: TPG34.1 209.97,148.06 v2(209.67,148.37)
  BOTTOM w0.102: VRAM6.N5 209.67,148.74 v2(209.67,148.37)
SNN_FBA_TCK1: length 1.6
  TOP w0.14: v2(204.29,131.28) 203.73,131.84 TPG46.1
  BOTTOM w0.102: VRAM8.N5 204.63,130.94 v2(204.29,131.28)
SNN_FBA_TDI0: length 1.3
  TOP w0.14: TPG41.1 204.19,144.9 v2(204.25,144.84)
  BOTTOM w0.102: VRAM6.F10 204.6,145.2 v2(204.25,144.84)
SNN_FBA_TDI1: length 2.1
  TOP w0.14: TPG44.1 209.68,133.11 210.19,133.62 v2(210.19,133.99)
  BOTTOM w0.102: VRAM8.F10 209.88,134.44 210.19,134.13 v2(210.19,133.99)
SNN_FBA_TDO0: length 1.6
  TOP w0.14: TPG39.1 208.78,145.47 209.4,144.85 v2(209.5,144.85)
  BOTTOM w0.102: v2(209.5,144.85) 209.85,145.2 VRAM6.N10
SNN_FBA_TDO1: length 1.3
  TOP w0.14: TPG43.1 204.67,133.82 v2(204.8,133.95)
  BOTTOM w0.102: v2(204.8,133.95) 204.63,134.13 VRAM8.N10
SNN_FBA_TMS0: length 1.3
  TOP w0.14: TPG33.1 204.72,147.86 v2(204.72,148.4)
  BOTTOM w0.102: VRAM6.F5 204.63,148.49 v2(204.72,148.4)
SNN_FBA_TMS1: length 2.8
  TOP w0.14: v2(209.77,131.22) 209.77,131.29 208.64,132.42 TPG45.1
  BOTTOM w0.102: VRAM8.F5 209.88,131.09 209.77,131.2 v2(209.77,131.22)
SNN_FBB_RFU_G5: length 1.7
  TOP w0.14: v2(224.87,178.28) 224.41,177.83 TPG7.1
  BOTTOM w0.102: VRAM1.G5 225.28,178.7 v2(224.87,178.28)
SNN_FBB_RFU_G5_1: length 2.3
  TOP w0.102: TPG23.1 207.98,160.95
  TOP w0.14: 207.98,160.95 208.84,160.95 209.13,160.66 v1(209.13,160.23)
  BOTTOM w0.102: VRAM4.G5 v1(209.13,160.23)
SNN_FBB_RFU_M5: length 1.8
  TOP w0.14: v2(224.88,175.11) 224.19,175.8 TPG11.1
  BOTTOM w0.102: VRAM1.M5 225.04,174.95 v2(224.88,175.11)
SNN_FBB_RFU_M5_1: length 1.3
  TOP w0.14: TPG26.1 205.55,160.9 v2(205.55,160.25)
  BOTTOM w0.102: v2(205.55,160.25) 205.38,160.07 VRAM4.M5
SNN_FBB_TCK1: length 1.4
  TOP w0.14: v1(204.63,160.23) 204.63,160.41 TPG27.1
  BOTTOM w0.102: VRAM4.N5 v1(204.63,160.23)
SNN_FBB_TDI1: length 5.7
  TOP w0.102: TPG19.1 206.35,162.07
  TOP w0.14: v2(209.5,163.8) 209.39,163.8 208.93,163.34 208.46,163.34 208.36,163.44 207.65,163.44 207.57,163.35 206.65,163.35 206.63,163.37 206.27,163.37 206.01,163.11 206.01,162.66 206.35,162.32 206.35,162.07
  BOTTOM w0.102: v2(209.5,163.8) 209.52,163.8 209.87,163.45 VRAM4.F10
SNN_FBB_TDO1: length 2
  TOP w0.14: v2(204.75,162.88) 204.75,162.78 204.12,162.15 TPG20.1
  BOTTOM w0.102: VRAM4.N10 204.63,163.01 v2(204.75,162.88)
SNN_FBB_TMS1: length 1.5
  TOP w0.14: v1(209.8,160.25) 209.8,160.03 209.53,159.75 TPG24.1
  BOTTOM w0.102: v1(209.8,160.25) 209.88,160.17 VRAM4.F5
SNN_FBC_RFU_G5: length 1.4
  TOP w0.203: TPG8.1 254.16,177.76 v2(254.72,178.32)
  BOTTOM w0.102: v2(254.72,178.32) 254.38,178.67 VRAM3.G5
SNN_FBC_RFU_G5_1: length 1.3
  TOP w0.203: v2(236.64,175.07) 237.26,175.07 TPG14.1
  BOTTOM w0.102: VRAM2.G5 236.51,174.95 v2(236.64,175.07)
SNN_FBC_RFU_M5: length 1.3
  TOP w0.203: v2(254.73,175.33) 254.63,175.42 TPG13.1
  BOTTOM w0.102: VRAM3.M5 254.73,175.3 v2(254.73,175.33)
SNN_FBC_RFU_M5_1: length 1.7
  TOP w0.14: v2(236.91,178.4) 236.44,177.93 TPG6.1
  BOTTOM w0.102: VRAM2.M5 236.42,178.4 v2(236.91,178.4)
SNN_FBC_TCK0: length 3
  TOP w0.203: v2(254.72,174.57) 254.46,174.82 253.3,174.82 TPG12.1
  BOTTOM w0.102: v2(254.72,174.57) 254.72,174.54 VRAM3.N5
SNN_FBC_TCK1: length 1.6
  TOP w0.14: v2(236.66,178.95) 237.39,178.95 TPG2.1
  BOTTOM w0.102: VRAM2.N5 236.62,178.95 v2(236.66,178.95)
SNN_FBC_TDI0: length 2.1
  TOP w0.14: TPG5.1 251.25,178.1 v2(250.28,179.07)
  BOTTOM w0.102: v2(250.28,179.07) 250.63,179.42 VRAM3.F10
SNN_FBC_TDI1: length 1.7
  TOP w0.203: v2(239.37,173.84) 239.37,173.82 TPG18.1
  BOTTOM w0.102: v2(239.37,173.84) 239.72,174.2 VRAM2.F10
SNN_FBC_TDO0: length 2.3
  TOP w0.14: v2(250.27,174.56) 250.73,175.02 250.73,175.6 250.4,175.93 TPG10.1
  BOTTOM w0.102: v2(250.27,174.56) 250.63,174.2 VRAM3.N10
SNN_FBC_TDO1: length 2.3
  TOP w0.203: TPG9.1 239.72,177.89 239.72,178.55 v2(240.24,179.06)
  BOTTOM w0.102: VRAM2.N10 240.24,179.08 v2(240.24,179.06)
SNN_FBC_TMS0: length 1.7
  TOP w0.203: v2(253.61,179.05) 253.35,179.05 TPG4.1
  BOTTOM w0.102: VRAM3.F5 254.17,179.45 253.78,179.05 v2(253.61,179.05)
SNN_FBC_TMS1: length 1.7
  TOP w0.203: v2(236.61,174.47) 236.61,174.46 TPG16.1
  BOTTOM w0.102: VRAM2.F5 236.34,174.2 v2(236.61,174.47)
SNN_FBD_RFU_G5: length 2.4
  TOP w0.14: TPG42.1 270.44,144.31 269.71,144.31 v2(269.25,143.85)
  BOTTOM w0.102: v2(269.25,143.85) 269.28,143.85 VRAM7.G5
SNN_FBD_RFU_G5_1: length 7.6
  TOP w0.14: TPG21.1 271.3,160.44 269.29,160.44 269.14,160.29 268.4,160.29 268.05,160.64 268.05,161.05 267.64,161.46 266.51,161.46 266.27,161.7 v2(266.27,162.8)
  BOTTOM w0.102: v2(266.27,162.8) 266.27,162.8 265.91,162.45 VRAM5.G5
SNN_FBD_RFU_M5: length 1.8
  TOP w0.203: TPG40.1 266.89,145.41 v2(266.2,144.72)
  BOTTOM w0.203: VRAM7.M5 265.88,144.4 v2(266.2,144.72)
SNN_FBD_RFU_M5_1: length 2.1
  TOP w0.14: TPG28.1 269.45,161.66 v2(269.45,161.9)
  BOTTOM w0.102: VRAM5.M5 269.63,162.07 v2(269.45,161.9)
SNN_FBD_TCK0: length 1.6
  TOP w0.203: TPG38.1 265.59,145.37 v2(265.59,144.79)
  BOTTOM w0.203: VRAM7.N5 265.59,144.66 v2(265.59,144.79)
SNN_FBD_TCK1: length 1.7
  TOP w0.14: v2(270.06,161.84) 270.06,161.14 TPG25.1
  BOTTOM w0.102: v2(270.06,161.84) 270.06,162.13 VRAM5.N5
SNN_FBD_TDI0: length 3
  TOP w0.14: v2(270.77,148.31) 270.27,147.82 268.9,147.82 TPG36.1
  BOTTOM w0.254: v2(270.77,148.31) 270.4,147.95 VRAM7.F10
SNN_FBD_TDI1: length 2.4
  TOP w0.203: v1(264.95,159.28) 264.95,159.76 265.09,159.91 TPG29.1
  BOTTOM w0.102: v1(264.95,159.28) 265.13,159.1 VRAM5.F10
SNN_FBD_TDO0: length 2.4
  TOP w0.14: TPG32.1 264.17,147.82 264.65,147.82 265.18,147.28 v2(265.3,147.28)
  BOTTOM w0.254: VRAM7.N10 265.13,147.46 v2(265.3,147.28)
SNN_FBD_TDO1: length 1.8
  TOP w0.14: TPG30.1 270.13,158.48 v2(270,158.34)
  BOTTOM w0.102: v2(270,158.34) 270.35,158.7 VRAM5.N10
SNN_FBD_TMS0: length 1.9
  TOP w0.14: TPG37.1 269.75,145.61 v2(269.75,144.76)
  BOTTOM w0.203: v2(269.75,144.76) 270.32,144.2 VRAM7.F5
SNN_FBD_TMS1: length 3.1
  TOP w0.14: TPG22.1 266.83,160.92 266.33,160.92 v2(265.33,161.92)
  BOTTOM w0.102: v2(265.33,161.92) 265.13,162.13 VRAM5.F5
SPI1_CLK_R: length 4.6
  BOTTOM w0.14: U53.6 242.98,56.27 243.3,56.59 243.96,56.59 244.36,56.99 C795.1 245.45,56.99 245.61,57.15 245.61,57.66 R1029.2
SPI1_SI_R: length 3.7
  BOTTOM w0.14: U53.5 241.71,56.15 241.96,56.4 242.37,56.4 242.8,56.83 243.77,56.83 244.31,57.37 R1043.2
SPI1_SO_R: length 10.8
  BOTTOM w0.14: U53.2 244.25,48.9 243.83,49.32 240.21,49.32 v1(239.15,48.26) 238.47,47.59 236.91,47.59 236.05,48.45 R1131.2
SPI_CS0#_R: length 9.6
  BOTTOM w0.14: R1129.2 237.95,48.68 v1(238.99,49.72) 244.51,49.72 245.52,48.71 U53.1
SPI_CS0#_UR_ME: length 105.3
  TOP w0.14: U23.101 180.31,72.09 180.74,71.65 180.74,71.22 180.07,70.54 180.07,68.57 180.04,68.54 180.04,67.4 180.78,66.65 180.78,62.91 180.48,62.61 v1(180.48,60.68)
  IN2 w0.089: v1(180.48,60.68) 180.57,60.68 181.18,60.08 181.18,59.95 181,59.77 181,59.65 181.3,59.35 181.43,59.35 181.93,59.85 182.22,59.85 182.31,59.76 182.31,59.56 181.76,59.01 181.76,58.89 181.97,58.68 182.09,58.68 182.4,58.99 182.52,58.99 182.72,58.79 182.72,58.64 182.43,58.35 182.43,58.22 182.95,57.7 183.47,57.7 185.9,55.27 186.03,55.27 186.23,55.47 186.35,55.47 186.56,55.27 186.56,55.14 186.36,54.94 186.36,54.81 186.78,54.39 187.77,54.39 188.1,54.73 188.62,54.73 188.72,54.63 188.72,53.31 191.32,50.7 191.32,50.19 190.56,49.42 190.56,49.18 191.31,48.43 191.44,48.43 191.79,48.77 191.98,48.77 192.21,48.54 192.21,48.42 192.07,48.28 192.07,48.11 192.27,47.9 192.4,47.9 192.55,48.05 192.7,48.05 192.9,47.85 192.9,47.64 192.46,47.2 192.46,47.08 192.67,46.87 192.79,46.87 193.19,47.27 194.24,47.27 194.94,46.57 200.6,46.57 201.2,45.96 205.26,45.96 205.41,45.81 205.41,45.09 205.5,45 205.79,45 205.88,45.09 205.88,45.87 205.97,45.96 206.32,45.96 206.42,45.87 206.42,45.61 206.55,45.48 207.85,45.48 207.96,45.59 207.96,46.48 208.14,46.66 208.94,46.66 209.1,46.5 209.1,45.59 209.19,45.5 209.46,45.5 209.57,45.61 209.57,47.17 209.66,47.26 209.95,47.26 210.04,47.17 210.04,45.95 210.15,45.84 210.42,45.84 210.51,45.93 210.51,47.18 210.6,47.27 210.97,47.27 211.06,47.18 211.06,46.67 211.15,46.58 211.44,46.58 211.53,46.67 211.53,47.18 211.62,47.27 211.91,47.27 212,47.18 212,46.67 212.09,46.58 212.38,46.58 212.47,46.67 212.47,47.18 212.56,47.27 212.85,47.27 212.94,47.18 212.94,46.68 213.03,46.59 213.32,46.59 213.41,46.68 213.41,47.18 213.5,47.27 213.79,47.27 213.88,47.18 213.88,46.67 213.97,46.58 214.29,46.58 214.37,46.67 214.37,47.11 214.46,47.19 214.59,47.19 214.84,46.94 214.84,46.67 214.93,46.58 219.13,46.58 220.73,48.18 220.73,48.31 220.35,48.68 220.35,48.84 220.54,49.03 220.67,49.03 221.06,48.64 221.19,48.64 221.39,48.85 221.39,48.97 221.17,49.19 221.17,49.32 221.33,49.48 221.55,49.48 221.73,49.3 221.85,49.3 222.03,49.48 223.67,49.48 223.76,49.39 223.76,48.82 223.87,48.72 224.14,48.72 224.23,48.81 224.23,49.39 224.32,49.48 231.44,49.48 231.65,49.7 237.95,49.7 v1(238.06,49.59)
  BOTTOM w0.14: v1(238.06,49.59) 238.18,49.71 238.18,50.14 237.91,50.4 R1108.2
SPI_IO2_R: length 10.2
  BOTTOM w0.14: U53.3 242.98,48.76 242.84,48.9 240.53,48.9 238.69,47.07 v1(238.08,47.07) 236.7,47.07 235.34,48.43 R1130.2
SPI_IO3_R: length 2.7
  BOTTOM w0.14: R1047.2 245.73,56.72 244.61,56.72 244.25,56.35 U53.7
SPI_TPM_CS#: length 54.5
  TOP w0.14: R545.1 217.73,59.72 217.87,59.58 v1(217.87,59.07) ; v1(241.09,75.6) 240.78,75.3 240.78,74.65 240.41,74.28 R385.1
  IN2 w0.089: v1(233.18,58.66) 233.15,58.63 232.37,58.63 231.78,58.04 229.68,58.04 228.61,59.11 226.45,59.11 225.12,57.78 222.92,57.78 222.08,56.94 221.51,56.94 220.75,57.69 219.13,57.69 217.87,58.95 v1(217.87,59.07)
  BOTTOM w0.14: v1(241.09,75.6) 240.68,75.2 238.34,75.2 233.59,79.95 233.17,79.95 232.95,79.73 232.95,77.94 232.39,77.38 232.39,76.58 233.74,75.22 233.74,73.11 233.33,72.7 233.33,67.73 231.92,66.32 231.92,62.05 232.81,61.16 232.81,60.78 233.48,60.11 233.48,58.96 v1(233.18,58.66)
SPI_TPM_CS#_R: length 1.3
  TOP w0.14: v1(218.15,60.15) 218.12,60.17 R545.2
  BOTTOM w0.102: v1(218.15,60.15) 217.87,59.87 U49.AP41
SPK_LED_ON_OFF: length 153.9
  TOP w0.14: v1(304.48,74.13) R390.1
  IN1 w0.086: v1(193.37,50.12) 196.05,47.45 200.68,47.45 201.17,46.95 203.97,46.95 204.78,47.77 207.65,47.77 208.28,47.13 208.28,47.05 208.69,46.65 209.42,46.65 210.05,46.02 212.75,46.02 214.09,44.68 218.78,44.68 219.17,44.29 222.55,44.29 223.79,45.54 237.18,45.54 237.51,45.21 241.16,45.21 241.28,45.33 242.21,45.33 242.55,45 243.36,45 243.72,45.35 244.78,45.35 245.94,44.18 247.77,44.18 248.8,45.21 248.8,45.72 251.07,47.99 256.09,47.99 256.53,47.55 266.44,47.55 271.54,52.64 276.27,52.64 282.75,59.12 282.75,61.97 285.8,65.03 285.8,65.5 288.64,68.34 294.31,68.34 295.18,69.21 307.19,69.21 309.08,71.1 309.08,73.13 309.65,73.7 309.65,74.59 311.41,76.35 v1(311.41,77.86)
  IN3 w0.089: v1(311.41,77.86) 310.95,77.86 308.61,75.52 308.61,73.93 307.79,73.11 307.17,73.11 306.73,72.68 305.67,72.68 304.48,73.87 v1(304.48,74.13)
  BOTTOM w0.14: Q114.2 193.32,50.07 v1(193.37,50.12)
SPKLN_L: length 20
  TOP w0.203: U21.39 302.62,70.03 302.93,70.34
  TOP w0.762: 302.93,70.34 v1(303.58,70.99) v1(303.58,72.45)
  IN1 w0.762: v1(303.58,72.45) 303.58,72 302.9,71.33 298.46,71.33 297.56,72.23 290.29,72.23 289.18,71.12 v3(289.18,70.83)
SPKLP_L: length 19.7
  TOP w0.203: U21.40 302.22,71
  TOP w0.762: v1(302.43,72.48) v1(302.43,71.72) 302.43,71.21 302.22,71
  IN1 w0.762: v1(302.43,72.48) 299.14,72.48 298.12,73.5 289.94,73.5 289.05,72.61 288.29,72.61 287.79,73.11 v3(287.79,73.75)
SPKRN_L: length 4.6
  TOP w0.203: U21.46 299.82,69.68 299.12,70.38
  TOP w0.762: 299.12,70.38 299.12,70.71 v1(298.22,71.61) 297.53,72.3 L9.1
SPKRP_L: length 5.2
  TOP w0.203: U21.45 300.22,69.79 300.05,69.96 300.05,70.44
  TOP w0.762: 300.05,70.44 v1(300.05,71.16) 298.45,72.76 L10.1
SRCCLKREQ5#: length 7.9
  TOP w0.14: TP75.1 227.46,60.85 226.79,60.85 v1(226.37,61.26)
  BOTTOM w0.102: U49.BD38 223.2,60.74 223.27,60.81 223.73,60.81 223.9,60.64 225.75,60.64 v1(226.37,61.26) 226.87,61.76 228.42,61.76 228.53,61.86 R1000.1
SRTC_RST#: length 25.1
  TOP w0.14: v1(217.59,53.65) 217.59,53.34 218.21,52.72 218.88,52.72 219.78,51.82 225.39,51.82 v1(226.23,50.97)
  BOTTOM w0.102: U49.AM47 217,56.59 216.74,56.33 216.74,56.03 216.53,55.82 216.53,55.07 217.59,54.01 217.59,53.65 v1(217.59,53.65)
  BOTTOM w0.14: R1116.2 233.18,50 Q113.3 231.09,48.8 231.18,48.71 231.18,47.87 J5.1 230.7,47.84 230.13,48.41 C834.1 229.84,49.65 229.11,50.38 226.83,50.38 v1(226.23,50.97)
SSD1_DET: length 11.6
  BOTTOM w0.102: 204.93,53.25 205.25,53.58 205.8,53.58 206.6,54.39 206.96,54.39 207.49,54.92 207.49,55.83 207.75,56.08 207.75,56.26 207.88,56.4 U49.P47
  BOTTOM w0.14: R1128.1 201.37,49.35 TP171.1 201.55,50.11 201.55,51.22 201.7,51.37 201.7,51.95 201.91,52.15 203.04,52.15 203.69,52.8 204.48,52.8 204.93,53.25
STRAP0: length 23.6
  TOP w0.14: RG82.2 262.6,117.98 RG77.1 263.6,117.98 264.72,119.11 v1(264.72,120.67)
  IN4 w0.086: v2(253.51,130.32) 253.6,130.32 254.43,129.49 254.43,128.14 254.81,127.76 254.81,126.89 256.78,124.92 258.22,124.92 258.62,124.52 259.21,124.52 260.58,123.15 261.2,123.15 261.8,122.56 261.8,120.35 262.14,120 262.96,120 263.92,120.96 264.44,120.96 v1(264.72,120.67)
  BOTTOM w0.102: v2(253.51,130.32) 253.6,130.32 253.8,130.12 UG6.BM5
STRAP1: length 22
  TOP w0.14: RG81.2 261.65,117.94 261.58,118.02 RG72.1 262.36,118.37 262.66,118.67 262.66,119.32 263.26,119.91 263.59,119.91 264.09,120.41 v1(264.09,120.56)
  IN4 w0.086: v2(253.61,129.76) 254.09,129.27 254.09,128.08 254.43,127.75 254.62,127.55 254.62,126.81 256.7,124.73 258.14,124.73 258.54,124.33 259.13,124.33 260.82,122.64 260.82,121.05 262.06,119.81 263.34,119.81 v1(264.09,120.56)
  BOTTOM w0.102: v2(253.61,129.76) 253.95,129.42 UG6.BN5
STRAP2: length 16.4
  TOP w0.14: v1(262.58,121.58) 262.17,121.58 261.27,120.68 261.27,119.29 260.95,118.97 RG71.1 260.95,118.24 260.92,118.21 RG80.2
  IN4 w0.086: v1(262.58,121.58) 262.58,122.31 261.36,123.53 260.73,123.53 259.37,124.9 258.77,124.9 257.15,126.52 256.31,126.52 256.09,126.74 256.09,127.28 v2(255,128.36)
  BOTTOM w0.102: UG6.BP4 254.98,128.39 254.98,128.38 v2(255,128.36)
STRAP3: length 14.7
  IN4 w0.086: v2(255.7,128.37) 256.1,127.97 256.64,127.97 256.84,128.18 257.67,128.18 258.75,127.1 258.75,126.11 260.09,124.76 260.09,124.44 260.81,123.72 261.44,123.72 262.98,122.18 262.98,121.1 v1(262.88,121)
  BOTTOM w0.102: UG6.BP3 v2(255.7,128.37)
  BOTTOM w0.14: v1(262.88,121) 262.83,121.06 262.35,121.06 262.19,121.21 RG153.1 261.83,121.04 261.83,120.18 RG162.2
STRAP4: length 10.8
  BOTTOM w0.102: 258.95,124.35 256.82,126.48 256.35,126.48 255.75,127.09 255.75,127.63 UG6.BR3
  BOTTOM w0.14: 258.95,124.35 259.34,124.35 260.86,122.83 260.86,121.47 261.12,121.21 RG152.1 261.32,121.15 261.32,120.69 RG161.2
STRAP5: length 11.1
  BOTTOM w0.102: 258.68,124.08 256.48,126.28 255.35,126.28 255.05,126.58 255.05,127.36 254.65,127.75 UG6.BR4
  BOTTOM w0.14: 258.68,124.08 258.69,124.07 259.23,124.07 259.71,123.59 259.71,122.43 260,122.14 260,121.2 260.14,121.06 RG151.1 260.4,120.68 260.35,120.62 RG160.2
STRP1: length 1.5
  TOP w0.14: U1.6 146.6,208.2 146.92,208.53 R39.2
STRP2: length 1.4
  TOP w0.14: U1.7 146.2,208.39 146.06,208.53 R38.2
SUSB#: length 440
  TOP w0.14: R69.1 205.84,186.69 v1(205.93,186.6) ; R587.1 172.22,54.88 172.74,54.35 v1(172.74,54.08) ; v1(123.48,207.71) 123.48,208 125.2,209.73 PU3.2 ; v1(106.79,55.5) 109.57,58.27 109.57,64.56 109.83,64.82 109.83,67.42 108.07,69.18 108.07,70.82 107.6,71.3 107.6,72.59 108.07,73.07 108.07,74.72 108.91,75.56 108.91,76.5 109.23,76.81 109.23,83.66 109.49,83.93 109.49,95.92 110.99,97.41 110.99,103.27 111.91,104.19 111.91,113.33 111.41,113.82 111.41,116.16 110.1,117.48 110.1,123.06 111.86,124.82 112.78,124.82 112.82,124.78 114.18,124.78 114.38,124.98 114.38,128.11 113.96,128.53 113.96,138.82 v1(113.22,139.56) 112.9,139.88 112.9,147.4 117.98,152.48 117.98,158.48 115.63,160.83 v1(114.94,160.83)
  IN2 w0.089: v1(123.48,207.71) 124.36,208.59 124.36,215.86 122.69,217.53 117.06,217.53 114.44,214.91 114.44,211.79 111.92,209.27 111.92,205.8 109.77,203.65 109.77,197.71 110.07,197.42 110.07,196.27 109.27,195.47 109.27,180.79 115.38,174.68 115.38,170.33 114.56,169.5 114.56,162.88 115.57,161.87 115.57,161.34 115.06,160.83 v1(114.94,160.83)
  IN3 w0.089: v1(208.44,46.04) 208.07,46.4 205.5,46.4 205.04,45.95 198.4,45.95 198.2,46.15 195.36,46.15 194.24,47.27 193.07,47.27 192.41,47.92 190.45,47.92 187.98,50.4 187.56,50.4 187.23,50.72 185.52,50.72 184.18,52.06 182.64,52.06 182.48,52.23 179.72,52.23 177.58,54.37 177.25,54.37 176.89,54.73 176.15,54.73 175.5,54.08 v1(172.74,54.08) 172.44,54.08 169.82,56.7 165.11,56.7 164.9,56.91 164.26,56.91 163.44,56.09 157.05,56.09 155.91,54.95 151.46,54.95 149.01,57.4 138.56,57.4 137.13,58.83 125.91,58.83 123.78,56.71 120.07,56.71 118.07,54.71 113.79,54.71 113.56,54.49 107.79,54.49 106.79,55.49 v1(106.79,55.5)
  IN4 w0.086: v1(205.93,186.6) 205.39,186.06 205.39,182.83 203.63,181.06 197.3,181.06 191.62,175.38 182.98,175.38 182.16,174.56 175.98,174.56 175.89,174.47 173.29,174.47 171.05,172.24 154.42,172.24 153.75,171.57 120.35,171.57 118.23,169.45 118.23,164.75 115.62,162.14 114.94,162.14 114.51,161.72 114.51,161.26 v1(114.94,160.83)
  BOTTOM w0.102: 214.01,53.25 214.01,53.62 213.98,53.65 213.98,54.68 213.82,54.84 213.82,56.04 U49.AF47
  BOTTOM w0.14: 214.01,53.25 TP159.1 214.01,51.88 214.1,51.79 214.1,51.47 214.25,51.32 R1099.1 214.07,50.99 213.85,50.77 213.85,50.19 213.72,50.05 213.72,49.89 212.01,48.18 209.21,48.18 208.33,47.31 208.33,46.14 v1(208.44,46.04) ; v1(113.22,139.56) 113.47,139.56 114.05,140.13 U41.2
SUSC#: length 53.4
  TOP w0.14: v1(183.13,55.44) 181.96,54.27 177.58,54.27 177.4,54.45 176.07,54.45 175.16,55.36 175.16,55.84 174.81,56.2 173.6,56.2 173.3,55.9 R583.1
  IN4 w0.086: v1(183.13,55.44) 184.2,55.44 186.51,53.13 187.49,53.13 188.88,51.73 190.93,51.73 192.09,50.57 200.26,50.57 200.35,50.48 202.57,50.48 202.81,50.72 206.75,50.72 207.04,50.43 211.49,50.43 211.93,49.99 211.93,48.78 v1(211.94,48.77)
  BOTTOM w0.102: U49.AE46 213.2,56.55 213.2,54.59 213.37,54.43 213.37,53.99 212.86,53.48 212.86,53.25
  BOTTOM w0.14: 212.86,53.25 212.86,52.75 212.78,52.67 212.78,51.47 212.55,51.25 212.29,51.25 R1087.1 212.06,49.61 TP174.1 211.94,49.43 v1(211.94,48.77)
SUSCLK: length 6.1
  TOP w0.14: v1(215.6,54.24) 216.08,54.24 216.22,54.38 216.93,54.38 217.18,54.63 217.5,54.63 217.81,54.94 R595.2
  BOTTOM w0.102: U49.AJ45 215.5,57.08 215.5,56.66 215.41,56.57 215.41,55.79 215.52,55.68 215.52,54.54 215.6,54.46 215.6,54.27 215.57,54.25 215.57,54.24 v1(215.6,54.24)
SUSCLK_32K: length 83
  IN2 w0.14: v1(220.58,54) 221.05,53.53 224.7,53.53 225.6,54.43 227.5,54.43 228.15,53.78 229.68,53.78 230.46,53 230.95,53 231.25,53.3 233.04,53.3 233.05,53.31 234.02,53.31 235.29,52.04 244.77,52.04 245.42,52.69 251.68,52.69 252.04,53.05 264.83,53.05 266.78,55 272.68,55 273.83,53.85 274.4,53.85 274.76,54.21 274.76,54.47 274.5,54.73 274.5,56.74 276.06,58.3 276.06,58.88 275.26,59.68 275.26,62.05 276.54,63.33 276.54,67.91 278.69,70.06 278.69,70.91 279.19,71.41 279.19,72.73 278.97,72.95 v1(278.74,72.95)
  BOTTOM w0.14: CN12.50 278.37,73.24 278.37,73.23 278.65,72.95 v1(278.74,72.95)
SUSD: length 0.9
  TOP w0.14: 53.34,53.81 v1(52.45,53.81)
SUSON: length 443.5
  TOP w0.14: v1(61.74,51.71) 60.81,51.71 PQ34.2 ; PR347.1 242.09,37.17 v1(241.42,36.51) ; PR46.1 166.79,211.91 166.52,211.64 166.52,210.26 v1(166.33,210.07) ; R355.1 172.6,74.57 v1(172.7,74.47) 172.71,74.46 U23.120 172.71,70.22 172.06,69.57 172.06,67.2 172.63,66.63 172.63,65.38 173.94,64.08 173.94,63.52 173.91,63.49 173.91,62.85 172.83,61.76 172.83,60.69 172.18,60.05 172.18,59.73 v1(171.93,59.48)
  IN1 w0.086: v1(138.69,58.26) 138.11,57.68 125.81,57.68 121.02,52.89 115.62,52.89 111.68,48.95 v1(110.7,48.95) 108.77,50.88 63.68,50.88 62.89,51.67 61.79,51.67 v1(61.74,51.71) ; v1(184.6,169.22) 182.88,170.93 169.23,170.93 166.62,173.54 166.62,174.44 v1(166.56,174.49)
  IN3 w0.089: v1(184.6,169.22) 184.6,168.2 185.25,167.55 185.25,163.55 186.95,161.86 186.95,152.33 187.82,151.46 187.82,110 189.32,108.5 189.32,105.63 192.14,102.82 192.14,97.28 191.12,96.27 191.12,79.69 187.43,75.99 186.05,75.99 v1(185.65,76.39) 185.48,76.39 184.76,77.11 183.94,77.11 183.03,78.02 174.21,78.02 173.26,77.07 173.26,75.9 172.81,75.44 172.81,74.58 v1(172.7,74.47) ; v1(166.56,174.49) 166.56,174.64 166.9,174.98 166.9,179.82 165.43,181.3 165.43,184.71 165.53,184.81 165.53,190.54 167.54,192.54 167.54,193.8 167.18,194.15 167.18,199.3 165.57,200.91 165.57,203.55 166.46,204.43 166.46,205.1 166.15,205.4 166.15,209.89 v1(166.33,210.07)
  IN4 w0.086: v1(197.74,96.33) 197.59,96.33 197.29,96.03 197.29,79.4 190.39,72.5 188.62,72.5 188.35,72.23 187.58,72.23 187.07,71.72 186.19,71.72 v1(186.18,71.74) ; v1(138.69,58.26) 139.17,57.77 139.92,57.77 142.66,60.52 144.55,60.52 144.82,60.25 147.23,60.25 147.8,59.69 149.44,59.69 149.84,60.09 149.84,60.86 151.35,62.37 152.6,62.37 153.8,63.56 160.9,63.56 161.53,62.93 166.25,62.93 169.76,59.42 171.87,59.42 v1(171.93,59.48) 171.93,58.41 173.43,56.91 173.43,55.42 175.3,53.55 178.18,53.55 181.08,50.66 181.08,49.18 182.61,47.66 187.84,47.66 192.2,43.3 192.76,43.3 194.13,41.93 194.13,41.09 194.7,40.52 197.75,40.52 198.79,39.48 208.7,39.48 209.6,38.57 219.87,38.57 221.24,39.94 224.53,39.94 226.32,38.16 226.32,36.28 226.53,36.08 240.99,36.08 v1(241.42,36.51)
  BOTTOM w0.14: PR540.1 197.24,96.33 v1(197.74,96.33) ; v1(110.7,48.95) 110.7,47.77 PR632.1 ; v1(186.18,71.74) 186.18,71.76 186.34,71.92 186.34,74.54 186.08,74.8 186.08,75.27 185.65,75.71 v1(185.65,76.39)
SX9310_GND1: length 18.1
  TOP w0.508: v1(272.51,53.31) 272.55,53.26 278.61,53.26 v1(279.01,53.67) 279.01,54.31 v1(280.45,55.74)
  BOTTOM w0.102: U50.B2 U50.A3
  BOTTOM w0.254: U50.A3 276.71,55.05 275.07,55.05 274.85,55.27 273.13,55.27 272.07,54.21 ; C810.2 C805.2 280.45,55.91 v1(280.45,55.74)
  BOTTOM w0.381: R1065.2 279.13,53.79 v1(279.01,53.67)
SX9310_GND2: length 6.5
  TOP w0.381: v1(285.78,52.49) 287.66,54.37 v1(287.66,55.67)
  BOTTOM w0.102: U51.B2 283.7,55.31
  BOTTOM w0.14: 283.7,55.31 U51.A3
  BOTTOM w0.254: v1(287.66,55.67) 287.58,55.74 C809.2 C813.2
SYS_HWPG: length 51.7
  TOP w0.14: v1(148.34,60.08) 148.34,60.86 148.73,61.25 PR289.2 ; U23.124 171.11,71.62 171.78,70.95 171.78,69.99 171.72,69.93 171.72,67.06 172.29,66.49 172.29,65.24 173.41,64.13 v1(173.41,63.67) ; v1(161.29,62.21) 161,61.92 161,60.1 160.86,59.96 160.07,59.96 159.82,60.21 159.82,61.04 D43.1
  IN3 w0.089: v1(161.29,62.21) 162.18,63.1 167.8,63.1 168.77,64.07 173.01,64.07 v1(173.41,63.67)
  BOTTOM w0.14: v1(148.34,60.08) 148.8,59.62 152.04,59.62 152.75,60.33 156.75,60.33 157.22,59.87 157.22,59.01 158.54,57.69 160.68,57.69 162.32,59.34 162.32,61.32 161.94,61.7 161.48,61.7 161.29,61.89 v1(161.29,62.21)
SYS_PWROK: length 78.9
  TOP w0.14: R627.1 209.72,44.61 209.06,44.61 208.74,44.28 208.74,43.79 208.98,43.55 R633.1 209.17,43.4 209.69,42.88 TP82.1 210.93,42.51 211.25,42.51 212.6,43.85 212.6,44.82 212.81,45.03 U30.4 213.39,45.45 213.13,45.71 212.58,45.71 212.35,45.94 212.35,46.39 211.79,46.95 210.63,46.95 210.22,46.54 R624.1 209.93,46.67 209.93,48.98 210.19,49.24 210.81,49.24 v1(211.29,48.76) 211.29,49.26 209.69,50.86 209.69,51.94 210.15,52.39 210.15,53.12 207.47,55.8 207.47,56.5 206.96,57.01 206.96,57.54 207.08,57.65 207.08,58.24 207.33,58.49 v1(207.66,58.49)
  IN3 w0.089: v1(207.66,58.49) 208.08,58.49 208.27,58.31 208.72,58.31 209.57,59.16 209.57,60.21 210.73,61.36 214.63,61.36 215.16,60.83 217.19,60.83 217.29,60.73 218.5,60.73 219.14,61.37 220.32,61.37 220.87,61.92 220.87,63.3 220.28,63.89 220.28,65.31 219.52,66.07 219.52,67 219.89,67.36 221.67,67.36 222.91,68.6 222.91,69.74 222.63,70.02 222.63,74.31 223.51,75.19 223.51,84.43 v1(222.08,85.87)
  BOTTOM w0.14: v1(222.08,85.87) 222,85.94 TP136.1 221.36,85.92 R876.1 ; v1(211.29,48.76) 210.39,49.66 210.39,49.84 210.07,50.16 210.07,50.92 210.19,51.05 R1085.2
SYS_PWROK_R: length 65.4
  TOP w0.14: R622.1 208.25,48.17 209.35,49.26 209.35,52.08 209.81,52.53 209.81,52.98 207.13,55.66 207.13,56.36 206.62,56.87 206.62,57.68 206.73,57.8 206.73,58.43 206.59,58.58 v1(206.54,58.58)
  IN3 w0.089: v1(219.04,80.87) 218.44,80.27 218.44,75.99 218.17,75.71 218.17,73.16 219.54,71.79 220.44,71.79 222.62,69.62 222.62,68.72 221.55,67.65 219.76,67.65 219.23,67.12 219.23,65.95 219.99,65.19 219.99,63.77 220.58,63.18 220.58,62.04 220.2,61.66 216.59,61.66 216.57,61.64 216,61.64 215.95,61.68 214.19,61.68 214.16,61.65 210.26,61.65 209.19,60.59 207.47,60.59 206.54,59.66 v1(206.54,58.58)
  BOTTOM w0.102: 222.04,83.31 222.04,82.49 221.82,82.27 221.82,81.82 221.68,81.69 220.82,81.69 220.62,81.5 219.51,81.5 219.13,81.11 219.13,81.01 219.04,80.93 v1(219.04,80.87) 219.04,80.82 218.35,80.13 218.35,79.62 218.06,79.32 218.06,78.46 217.96,78.36 217.89,78.32 217.75,78.32 217.69,78.26 217.69,77.92 U49.AN5
  BOTTOM w0.14: R876.2 R877.1 222.13,84.77 221.9,84.55 221.9,83.45 222.04,83.31
SYS_RESET#: length 8.2
  BOTTOM w0.102: U49.AP3 217.83,78.61 217.83,79.38 218.15,79.7 218.15,80.52 218.55,80.93 218.55,81.09 218.73,81.27 219,81.27 219.5,81.77 220.61,81.77 220.97,82.13 220.97,82.25 221.19,82.47 221.19,82.84
  BOTTOM w0.14: TP140.1 221.54,84.02 221.54,83.38 221.66,83.26 R910.1 221.48,82.92 221.27,82.92 221.19,82.84
SYS_SHDN#: length 199.5
  TOP w0.14: v1(113.45,133.78) 113.01,133.34 113.01,128.6 108.32,123.91 108.32,116.74 109.61,115.44 109.61,113.11 110.13,112.59 110.13,104.96 109.21,104.04 109.21,98.15 107.69,96.64 107.69,84.65 106.77,83.72 106.77,76.93 106.3,76.46 106.3,73.81 105.82,73.33 105.82,70.56 106.3,70.09 106.3,68.55 103.7,65.95 103.7,59.9 100.48,56.68 v1(100.48,56.33) ; U23.85 182.51,66.9 182.1,66.49 v1(182.1,64.85)
  TOP w0.203: PR294.1 157.33,61.12 v1(157.34,61.13) ; PR275.2 152.86,66.3 v1(152.67,66.5) ; v1(151.79,60.08) 151.71,60.01 151.71,59.64 151.92,59.44 PU15.6
  IN3 w0.089: v1(182.1,64.85) 179,64.85 177.42,66.43 170.6,66.43 170.18,66.85 165.75,66.85 165.42,66.52 164.08,66.52 163.23,65.67 162.53,65.67 162.44,65.77 159.43,65.77 158.9,66.29 154.1,66.29 153.5,66.89 153.06,66.89 v1(152.67,66.5) 148.11,66.5 146.59,64.98 143.34,64.98 139.5,61.13 123.23,61.13 122.31,60.21 118.71,60.21 117.82,59.32 113.28,59.32 111.7,57.74 101.89,57.74 v1(100.48,56.33)
  BOTTOM w0.14: PR512.2 111.33,135.7 111.34,135.71 113.15,135.71 Q97.3 113.24,133.99 v1(113.45,133.78)
  BOTTOM w0.203: v1(157.34,61.13) 156.6,61.86 155.47,61.86 154.32,60.71 152.59,60.71 151.97,60.08 v1(151.79,60.08) 151.79,65.62 v1(152.67,66.5)
SYSTEM_AGND: length 9.5
  TOP w0.203: v1(155.92,63.05) 156.01,62.96 PR277.2 155.55,62.47 155.27,62.19 PR283.1 ; PR278.2 150.78,62.85 151.48,63.55 PR274.1 151.62,63.82 v1(152.38,63.06)
  TOP w0.254: PR278.2 PR279.2
  BOTTOM w0.203: v1(155.92,63.05) 155.41,63.55 152.87,63.55 v1(152.38,63.06)
TBT1_CC1: length 65.9
  TOP w0.203: v1(59.87,91.44) 60.15,91.72 C230.2
  TOP w0.254: U11.G5 60.92,88.59 v2(60.92,88.58)
  IN3 w0.254: 8.8,93.81 v2(8.2,93.81)
  IN3 w0.508: 8.8,93.81 9.58,93.04 11.44,93.04 v1(12.14,92.33) ; v1(12.93,91.79) 13.87,91.79 14.96,92.88 20.27,92.88 20.96,92.19 27.66,92.19 28.83,91.02 29.47,91.02 30.1,90.39 30.1,86.22 31.37,84.95 32.95,84.95 33.28,85.29 52.32,85.29 58.48,91.44 v1(59.87,91.44) 60.07,91.25 60.07,89.43 v2(60.92,88.58)
  BOTTOM w0.178: CN5.B5 7.94,93.6 8.15,93.81 v2(8.2,93.81)
TBT1_CC2: length 67.2
  TOP w0.152: U11.H5 60.92,90.32
  TOP w0.254: 60.92,90.32 60.92,90.56 61.75,91.4 C237.2 61.88,91.98 v1(61.98,92.08)
  IN3 w0.508: v1(61.98,92.08) 61.6,91.7 61.6,89.79 62.43,88.96 62.43,87.27 61.9,86.74 60.34,86.74 59.56,85.96 57.19,85.96 56.9,86.25 55.05,86.25 52.53,83.73 33.51,83.73 32.9,84.34 31.12,84.34 29.11,86.35 29.11,87.19 24.72,91.58 20.71,91.58 20.02,92.27 15.22,92.27 14.1,91.15 12.81,91.15 v1(12.53,90.88)
  BOTTOM w0.254: CN5.A5 9.67,92.35 10.02,92.01 10.36,92.01 10.59,91.78 10.59,91.63 10.76,91.47
  BOTTOM w0.508: 10.76,91.47 11.06,91.16 11.08,91.16 11.16,91.08
TBT2_CC1: length 82.4
  TOP w0.079: 61.92,85.35 61.89,85.35 61.39,85.85 61.39,86.22 61.12,86.5 61.12,87.03 U11.B5
  TOP w0.14: v1(62.66,83.52) 62.8,83.66 C294.2 62.8,84.47 61.92,85.35
  IN3 w0.254: 8.59,79.81 v2(8.2,79.81)
  IN3 w0.508: 8.59,79.81 8.91,79.81 9.49,79.23 10.96,79.23 v1(11.76,78.43) ; v1(62.66,83.52) 62.66,84 62.21,84.45 59.37,84.45 58.46,85.35 56.94,85.35 56.65,85.64 55.3,85.64 53.15,83.49 53.15,81.81 47.15,75.8 47.15,73.9 41.24,68 29.88,68 29.37,68.51 29.37,75.8 26.95,78.23 21.44,78.23 19.81,79.86 18.79,79.86 17.67,78.74 17.67,77.11 17.25,76.7 16.52,76.7 15.93,77.29 13.59,77.29 v1(12.51,78.37)
  BOTTOM w0.178: CN9.B5 7.94,79.6 8.15,79.81 v2(8.2,79.81)
TBT2_CC2: length 77.4
  TOP w0.14: v1(62,83.8) 62.25,84.06 C293.2 62.25,84.61 61.72,85.15 61.72,85.26 61.2,85.77 61.2,86.15 60.92,86.44 U11.A5
  IN3 w0.508: v1(12.68,77.01) 13,76.68 15.67,76.68 16.27,76.09 17.5,76.09 19.04,77.62 21.71,77.62 21.74,77.59 24.94,77.59 25.54,76.99 25.54,70.44 26.42,69.56 28.07,69.56 28.45,69.18 28.45,67.02 29.19,66.28 40.39,66.28 47.76,73.65 47.76,75.53 53.76,81.53 53.76,83.24 55.55,85.03 56.34,85.03 56.63,84.75 58.21,84.75 59.15,83.8 v1(62,83.8)
  BOTTOM w0.254: 10.83,77.26 10.68,77.41 10.68,77.69 10.37,78 10.02,78 9.68,78.35 CN9.A5
  BOTTOM w0.508: 11.56,77 11.09,77 10.83,77.26
TBT_FORCE_PWR: length 284.7
  TOP w0.079: 31.03,69.75 31.88,69.75 32.44,70.31 32.44,70.81 U16.B10 ; U9.B10 37.02,88.08 37.02,87.58 36.49,87.06 35.58,87.06 35.57,87.05
  TOP w0.14: v1(28.25,62.85) 28.83,63.44 v1(28.83,64.28) 28.83,66.28 29.05,66.5 29.23,66.5 R467.1 29.24,66.71 29.06,66.71 28.88,66.9 28.88,67.88 29.13,68.13 R442.2 29.35,68.13 v1(29.98,68.76) 30.97,69.75 31.03,69.75 ; R240.1 34.4,84.13 34.4,85.25 34.25,85.4 R216.2 33.91,85.72 34.23,86.04 v1(34.56,86.04) 35.57,87.05
  IN1 w0.086: v1(56.72,87.44) 56.72,87.08 55.93,86.29 44.3,86.29 43.55,87.04 40.23,87.04 39.74,86.55 35.07,86.55 v1(34.56,86.04)
  IN2 w0.089: v1(34.56,86.04) 34.42,85.9 34.42,83.53 34.8,83.15 34.8,82.26 35.37,81.69 35.37,78.48 33.24,76.35 32.52,76.35 31.3,75.12 31.3,74.54 31.03,74.28 30.73,74.28 30.54,74.09 30.54,71.21 29.98,70.66 v1(29.98,68.76)
  IN3 w0.089: v1(192.47,62.55) 192.45,62.55 191.93,63.07 191.75,63.07 190.27,64.55 190.01,64.55 188.82,65.74 188.82,67.44 188.5,67.77 185.44,67.77 184.73,68.47 179.25,68.47 177.74,69.97 165.76,69.97 165.42,70.31 159.34,70.31 158.28,69.26 155.4,69.26 154.38,70.29 140.64,70.29 139.62,69.27 134.02,69.27 132.78,68.03 131.21,68.03 129.85,66.67 124.45,66.67 123.07,65.29 110.48,65.29 109.18,63.99 94.81,63.99 94.44,64.36 66.39,64.36 62.27,60.24 61.35,60.24 57.08,55.98 53.77,55.98 53.17,55.37 47.89,55.37 46.2,53.68 38.35,53.68 36.45,51.78 28.43,51.78 27.97,52.24 27.97,56.49 29.25,57.77 29.25,60.72 28.83,61.14 28.83,61.94 28.25,62.52 v1(28.25,62.85)
  IN4 w0.086: v1(208.71,53.26) 207.74,54.23 200.76,54.23 199.37,52.84 195.67,52.84 194.85,53.66 194.85,56.04 194.36,56.52 194.36,61.13 193.1,62.39 192.63,62.39 v1(192.47,62.55)
  BOTTOM w0.102: U49.W46 210.53,56.64 210.4,56.51 210.4,56.09 210.08,55.77 210.08,55.18 209.23,54.34 209.23,53.78 v1(208.71,53.26)
  BOTTOM w0.14: v1(56.72,87.44) 57.51,88.23 R859.1
TBT_FORCE_PWR_C: length 2.3
  TOP w0.102: v2(60.57,88.09) 60.52,88.14 U11.F6
  BOTTOM w0.14: v2(60.57,88.09) 60.43,88.23 R859.2 v1(60.05,89.21)
TBT_LSX0_RXD: length 241.2
  TOP w0.14: v1(220.01,70.21) 220.01,70.56 220.12,70.68 R411.2 220.04,70.99 R415.1 ; v1(98.79,57.5) 99.07,57.78 99.07,58.93 102.08,61.94 102.08,66.61 102.19,66.72 102.19,70.47 103.31,71.59 103.89,71.59 104.09,71.8 104.09,72.53 103.02,73.6 103.02,75.02 103.57,75.57 103.57,76.01 105.16,77.6 105.16,81.2 104.57,81.79 99.66,81.79 99.49,81.97 98.82,81.97 98.64,81.79 87.26,81.79 68.45,100.6 42.27,100.6 40.49,98.82 40.49,97.24 R146.1
  IN4 w0.086: v1(220.01,70.21) 220.21,70.21 220.36,70.06 220.36,69.89 220.16,69.69 219,69.69 218.87,69.81 214.1,69.81 213.92,69.99 211.51,69.99 211.45,70.05 210.7,70.05 210.14,69.49 210.14,67.76 209.79,67.42 207.1,67.42 206.39,68.12 201.36,68.12 199.43,66.19 189.71,66.19 188.98,65.46 187.4,65.46 186.89,65.98 183.37,65.98 183.11,66.23 170.26,66.23 169.8,66.69 163.22,66.69 163.08,66.83 157.24,66.83 157.13,66.72 155.68,66.72 155.23,66.28 153.71,66.28 152.92,65.49 151.24,65.49 149.83,64.08 149.16,64.08 147.63,62.55 142.08,62.55 139.82,60.28 136.14,60.28 134.28,58.42 131.22,58.42 130.19,57.39 125.72,57.39 123.83,55.5 121.58,55.5 118.59,52.51 113.85,52.51 113.16,51.82 110.68,51.82 110.32,52.17 107.38,52.17 101.16,58.4 99.34,58.4 99,58.05 99,57.71 v1(98.79,57.5)
  BOTTOM w0.102: U49.AU19 219.58,70.63 v1(220.01,70.21)
TBT_LSX0_RXD_C: length 4.9
  TOP w0.079: U9.L7 38.65,92.47 38.83,92.74 38.85,92.8 38.85,93.57 40.19,94.91
  TOP w0.14: R146.2 40.77,96.32 40.29,95.84 R156.1 40.19,95.24 40.19,94.91
TBT_LSX0_TXD: length 241.2
  TOP w0.14: R145.1 40.22,97.18 40.22,98.93 42.16,100.87 68.56,100.87 87.37,82.06 98.53,82.06 98.71,82.23 99.6,82.23 99.77,82.06 104.68,82.06 105.42,81.31 105.42,77.49 103.84,75.9 103.84,75.46 103.29,74.91 103.29,73.71 104.36,72.64 104.36,71.69 104,71.33 103.42,71.33 102.45,70.36 102.45,66.61 102.35,66.5 102.35,61.83 99.34,58.82 99.34,57.81 v1(99.64,57.5)
  IN4 w0.086: v1(220.64,70.55) 220.52,70.55 220.41,70.43 220.41,70.24 220.53,70.12 220.53,69.82 220.23,69.52 218.93,69.52 218.81,69.65 214.03,69.65 213.85,69.83 211.44,69.83 211.38,69.89 210.77,69.89 210.3,69.42 210.3,67.69 209.86,67.25 207.03,67.25 206.32,67.96 201.43,67.96 199.5,66.03 189.77,66.03 189.04,65.3 187.33,65.3 186.82,65.81 183.3,65.81 183.04,66.06 170.19,66.06 169.73,66.52 163.15,66.52 163.02,66.66 157.31,66.66 157.2,66.56 155.75,66.56 155.3,66.11 153.78,66.11 152.99,65.32 151.31,65.32 149.9,63.91 149.23,63.91 147.7,62.38 142.15,62.38 139.89,60.12 136.21,60.12 134.35,58.25 131.29,58.25 130.26,57.23 125.79,57.23 123.9,55.34 121.65,55.34 118.66,52.35 113.92,52.35 113.23,51.65 110.61,51.65 110.25,52.01 107.31,52.01 101.09,58.23 99.41,58.23 99.16,57.98 99.16,57.68 99.35,57.5 v1(99.64,57.5)
  BOTTOM w0.102: U49.AW18 220.31,70.65 220.42,70.55 v1(220.64,70.55)
TBT_LSX0_TXD_C: length 4.9
  TOP w0.079: 39.96,95.03 39.96,94.92 38.68,93.64 38.68,92.97 U9.M7
  TOP w0.14: 39.96,95.03 39.96,95.14 39.75,95.34 R155.1 40.06,95.68 40.06,95.94 40.41,96.28 40.41,96.46 40.36,96.51 R145.2
TBT_LSX2_RXD: length 241.5
  TOP w0.14: v1(53.69,60.65) 53.95,60.92 53.95,61.29 53.57,61.67 52.67,61.67 47.98,66.36 47.98,67.83 43.76,72.06 43.76,81.27 43.08,81.95 36.3,81.95 35.99,81.64 35.99,79.9 R306.1
  IN4 w0.086: v1(224.67,70.24) 224.42,70 224.42,69.81 223.93,69.32 223.33,69.32 221.81,67.79 215.95,67.79 215.56,67.41 215.56,66.19 215.08,65.71 213.03,65.71 211.9,64.58 211.9,63.46 211.58,63.13 210.78,63.13 210.35,62.71 210.35,61.32 209.68,60.65 207.32,60.65 206.52,59.85 204.12,59.85 202.13,61.84 202.13,62.99 201.63,63.49 200.92,63.49 200.53,63.11 198.89,63.11 198.43,62.65 195.48,62.65 194.4,63.73 192.38,63.73 191.93,63.28 191.93,63.05 190.85,61.98 188.22,61.98 187.82,62.38 187.82,62.81 186.4,64.24 184.59,64.24 183.91,64.92 182.87,64.92 182.28,65.51 169.61,65.51 169.33,65.79 165.79,65.79 165.55,65.55 163.54,65.55 163.4,65.69 162.49,65.69 162.3,65.88 161.41,65.88 161.14,65.61 159.59,65.61 159.19,66 156.4,66 155.82,65.43 154.05,65.43 153.28,64.67 151.89,64.67 148.6,61.38 146.92,61.38 146.51,61.8 142.44,61.8 140.1,59.46 136.52,59.46 134.69,57.63 131.46,57.63 130.48,56.65 126.01,56.65 124.13,54.78 121.88,54.78 118.84,51.74 114.1,51.74 113.36,51 110.76,51 110.5,50.74 106.99,50.74 100.87,56.86 95.91,56.86 94.84,57.93 89.97,57.93 87.31,55.27 77.36,55.27 73.91,58.72 59.63,58.72 57.33,61.02 56.21,61.02 55.19,60 54.18,60 54,60.19 54,60.34 v1(53.69,60.65)
  BOTTOM w0.102: R955.1 228.46,71.49 228.05,71.08 227.59,71.08 227.46,71.21 R954.2 225.92,71.5 v1(224.67,70.24) 224.61,70.24 223.73,71.12 222.44,71.12 U49.BC17
TBT_LSX2_RXD_C: length 5.1
  TOP w0.079: U16.L7 34.28,75.4 34.28,76.28 35.56,77.57 35.56,77.69
  TOP w0.14: 35.56,77.69 35.56,77.91 R327.1 35.66,78.12 35.66,78.68 35.87,78.88 35.87,79.05 36.06,79.24 R306.2
TBT_LSX2_TXD: length 234.5
  TOP w0.14: v1(54.48,60.65) 54.22,60.92 54.22,61.4 53.68,61.93 52.79,61.93 48.25,66.47 48.25,67.94 44.03,72.17 44.03,81.38 43.19,82.22 36.19,82.22 35.72,81.75 35.72,79.97 R305.1
  IN4 w0.086: v1(54.48,60.65) 54.17,60.34 54.17,60.26 54.25,60.17 55.12,60.17 56.14,61.18 57.4,61.18 59.7,58.88 73.98,58.88 77.42,55.43 87.24,55.43 89.9,58.09 94.91,58.09 95.98,57.02 100.94,57.02 107.06,50.9 110.43,50.9 110.69,51.16 113.29,51.16 114.04,51.91 118.77,51.91 121.81,54.94 124.06,54.94 125.94,56.82 130.41,56.82 131.39,57.8 134.62,57.8 136.45,59.63 140.03,59.63 142.37,61.96 146.57,61.96 146.99,61.55 148.53,61.55 151.82,64.83 153.22,64.83 153.98,65.6 155.76,65.6 156.33,66.17 159.26,66.17 159.66,65.77 161.07,65.77 161.34,66.05 162.37,66.05 162.56,65.85 163.47,65.85 163.6,65.72 165.48,65.72 165.72,65.95 169.4,65.95 169.67,65.67 182.35,65.67 182.93,65.09 183.98,65.09 184.66,64.4 186.46,64.4 187.99,62.88 187.99,62.45 188.29,62.14 190.78,62.14 191.76,63.12 191.76,63.35 192.31,63.89 194.47,63.89 195.55,62.82 198.36,62.82 198.82,63.27 200.46,63.27 200.85,63.66 201.7,63.66 202.3,63.06 202.3,61.9 204.19,60.01 206.45,60.01 207.25,60.81 209.62,60.81 210.19,61.39 210.19,62.78 210.71,63.3 211.51,63.3 211.73,63.52 211.73,64.65 212.96,65.88 215.01,65.88 215.4,66.26 215.4,67.48 215.88,67.96 221.74,67.96 223.26,69.48 223.86,69.48 224.25,69.87 224.25,70 v1(224.01,70.24)
  BOTTOM w0.102: U49.BE18 224.01,70.47 v1(224.01,70.24)
TBT_LSX2_TXD_C: length 4.4
  TOP w0.079: U16.M7 34.11,75.69 34.11,76.35 35.3,77.54 35.3,77.69
  TOP w0.14: R305.2 35.6,79.07 35.6,78.99 35.4,78.79 35.4,78.31 R326.1 35.3,77.92 35.3,77.69
TBT_RST_EC#: length 421.5
  TOP w0.14: R84.1 283.69,173.36 284.54,173.36 v1(284.63,173.45) ; v1(27.79,93.88) 29.38,95.47 R152.2 ; v1(24.45,78.86) 25.11,78.19 R323.2
  IN2 w0.089: v1(278.83,178.42) 279.04,178.42 281.17,176.29 282.96,176.29 283.52,175.74 283.52,173.77 283.84,173.45 v1(284.63,173.45) ; v1(196.8,107.85) 194.03,107.85 179.72,122.16 126.22,122.16 123.46,124.91 114.44,124.91 114.31,124.78 113.58,124.78 113.14,125.22 v1(113.14,125.62) ; v1(212.76,186.35) 212.76,186.53 214.65,188.42 219.83,188.42 220.87,187.38 222.96,187.38 223.45,187.86 231.01,187.86 231.05,187.9 261.85,187.9 264.66,185.09 266.32,185.09 267.53,186.3 269.42,186.3 270.42,185.3 273.2,185.3 274.12,184.38 274.12,180.63 v1(273.36,179.87)
  IN3 w0.089: v1(278.83,178.42) 278.04,178.42 275.77,180.69 274.18,180.69 v1(273.36,179.87) ; v1(27.79,93.88) 28.31,94.4 28.31,96.5 30.09,98.28 32.07,98.28 33.74,96.62 35.15,96.62 35.86,95.91 37.68,95.91 38.05,96.28 38.05,98.8 39.02,99.77 44.59,99.77 45.1,99.25 48.58,99.25 49.78,100.45 56.38,100.45 56.71,100.12 81.76,100.12 82.47,99.42 95.51,99.42 97.2,97.73 97.2,96.62 97.83,95.99 101,95.99 104.52,99.51 104.52,103.16 105.81,104.45 105.81,106.63 107.45,108.27 111.35,108.27 114.33,111.25 114.33,114.14 111.17,117.3 111.17,122.14 113.06,124.03 113.06,125.53 v1(113.14,125.62) ; v1(196.8,107.85) 195.16,107.85 190.87,112.14 190.87,152.68 190.14,153.42 190.14,165.08 193.82,168.76 193.82,175.58 198.9,180.66 205.65,180.66 209.01,184.02 210.43,184.02 v1(212.76,186.35)
  IN4 w0.086: v1(24.45,78.86) 23.34,78.86 22.24,79.96 22.24,86.59 22.61,86.96 22.61,87.72 23.69,88.8 24.07,88.8 27.79,92.52 v1(27.79,93.88)
TBT_SBU1_P1_CON: length 32.4
  TOP w0.14: v2(8.2,92.14) 9.4,92.14 10.55,93.29 D10.1 11.12,93.29 11.36,93.05 12.3,93.05 12.63,93.37 12.87,93.37 13.19,93.69 13.19,94.66 13.33,94.8 13.56,94.8 R160.1 13.8,94.76 14.08,94.76 14.69,95.37 14.87,95.37 15.01,95.23 v1(15.01,95.16)
  BOTTOM w0.14: v1(15.01,95.16) 15.22,95.38 16.41,95.38 16.97,94.82 18.53,94.82 21.26,92.09 23.25,92.09 24.37,90.97 29.51,90.97 30.36,91.82 30.36,95.34 30.59,95.58 31.14,95.58 31.25,95.47 R1218.2 ; CN5.B8 8.17,92.1 v2(8.2,92.14)
TBT_SBU1_P1_CON_S: length 7.7
  TOP w0.079: 36.05,94.43 36.13,94.35 36.2,94.35 37.33,93.22 37.33,92.99 U9.M10
  TOP w0.14: 36.05,94.43 35.54,94.93 34.27,94.93 34.17,94.83 v1(34.17,94.7)
  BOTTOM w0.14: v1(34.17,94.7) 34.13,94.67 33.84,94.67 33.66,94.85 33.66,95.31 33.52,95.45 33.04,95.45 32.53,95.96 32.25,95.96 31.98,95.69 R1218.1
TBT_SBU1_P2_CON: length 28.9
  TOP w0.14: v1(15.67,79.72) 15.43,79.96 15.19,79.96 15.08,79.85 R300.1 14.65,79.85 14.5,79.99 14.34,79.99 14.2,79.85 14.2,79.66 13.92,79.38 13.72,79.38 13.72,79.38 13.67,79.33 D22.2 13.13,79.33 12.89,79.08 11.99,79.08 11.8,79.28 10.75,79.28 9.61,78.14 v2(8.24,78.14)
  BOTTOM w0.14: v2(8.24,78.14) 8.2,78.14 8.17,78.1 CN9.B8 ; v1(15.67,79.72) 15.79,79.83 16.89,79.83 17.9,78.83 17.9,78.2 18.61,77.49 21.18,77.49 24.65,74.03 25.33,74.03 25.83,74.52 25.83,77.13 24.77,78.19 24.13,78.19 23.85,78.47 23.85,79.03 24.01,79.18 R1220.2
TBT_SBU1_P2_CON_S: length 13.8
  TOP w0.079: U16.M10 32.68,75.9 30.92,77.66 30.71,77.66 30.69,77.64 30.64,77.64
  TOP w0.14: 30.64,77.64 29.81,77.64 29.75,77.59 29.75,77.59 v1(29.59,77.43)
  IN1 w0.086: v1(24.26,80.48) 24.26,80.35 24.15,80.24 23.86,80.24 23.78,80.33 23.78,80.91 23.95,81.08 24.57,81.08 24.83,80.82 25.26,80.82 27.03,79.05 27.03,78.75 27.77,78.02 29.01,78.02 29.21,77.81 29.21,77.56 29.34,77.43 v1(29.59,77.43)
  BOTTOM w0.14: v1(24.26,80.48) 24.01,80.23 R1220.1
TBT_SBU2_P1_CON: length 32.4
  TOP w0.14: v1(14.97,95.88) 14.97,95.78 14.83,95.64 14.58,95.64 13.97,95.03 13.87,95.03 R154.1 13.56,95.07 13.22,95.07 12.92,94.77 12.92,93.8 12.76,93.64 12.6,93.64 12.28,93.96 11.34,93.96 11.04,93.66 D10.2 10.55,93.66 9.84,92.95 9.66,92.95 9.43,93.18 9.43,93.36 v1(9.94,93.87)
  BOTTOM w0.14: R1219.1 31.53,96 31.37,95.85 30.48,95.85 30.09,95.45 30.09,91.93 29.4,91.24 24.48,91.24 23.36,92.36 21.37,92.36 18.64,95.09 17.08,95.09 16.53,95.64 15.21,95.64 v1(14.97,95.88) ; CN5.A8 9.91,93.85 v1(9.94,93.87)
