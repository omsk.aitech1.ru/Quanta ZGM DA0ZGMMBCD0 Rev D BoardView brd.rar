# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP (solid shape): 189.81,84.08 189.83,84.08 189.84,84.07 190.1,83.81 190.1,83.55 190.3,83.35 190.3,81.5 190.93,80.86 190.93,80.38 189.92,79.36 189.56,79.36 188.67,80.25 187.73,80.25 187.24,80.75 187.24,81.43 187.28,81.47 187.61,81.47 187.63,81.45 187.63,81.01 187.84,80.81 189.08,80.81 189.33,81.07 189.33,83.3 189.59,83.55 189.59,84.06 189.61,84.08
GND on TOP (solid shape): 236.24,121.14 237.22,121.14 237.37,120.99 237.37,118.45 237.24,118.33 235.66,118.33 235.54,118.45 235.26,118.45 235.15,118.56 235.14,118.61 235.07,118.84 234.86,118.98 234.85,118.99 234.83,119.02 234.83,120.49 235.59,121.25 236.13,121.25
GND on TOP (solid shape): 296.22,80.46 296.22,79.95 296.37,79.8 296.63,79.8 296.76,79.67 296.76,78.96 296.64,78.84 294.64,78.84 294.46,78.66 294.46,78.33 294.37,78.25 293.83,78.25 293.7,78.37 293.7,79.06 295.18,80.53 296.14,80.53
GND on TOP (solid shape): 312.32,98.09 312.32,97.08 312.32,97.08 312.32,96.94 312.44,96.83 312.74,96.83 312.78,96.81 312.79,96.77 312.79,95.13 312.76,95.1 311.07,95.1 311.04,95.13 311.04,96.84 311.05,96.85 311.89,96.85 312.01,96.98 312.01,97.08 312.01,97.08 312.01,98.09 312.06,98.13 312.08,98.15 312.1,98.15 312.26,98.15
GND on TOP (solid shape): 312.69,78.46 312.69,78.22 312.9,78.02 312.99,78.02 313,78.01 313.11,77.91 313.11,77.18 313.06,77.13 312.68,77.13 312.32,77.48 311.84,77.48 311.74,77.59 311.74,77.65 311.74,77.66 311.79,77.76 311.8,77.86 311.78,77.98 311.74,78.08 311.74,78.5 311.86,78.63 312.52,78.63
GND on TOP (solid shape): 318.44,98.12 318.44,98.11 318.64,98.11 318.67,98.09 318.67,96.92 318.75,96.83 319.1,96.83 319.13,96.82 319.15,96.78 319.15,95.13 319.12,95.1 317.41,95.1 317.38,95.12 317.38,96.84 317.4,96.86 318.27,96.86 318.36,96.95 318.36,97.08 318.36,97.08 318.36,98.07 318.37,98.1 318.39,98.12 318.41,98.12
GND on TOP (solid shape): 300.41,78.58 300.41,77.71 300.71,77.41 300.71,76.9 300.66,76.85 300.41,76.85 300.09,77.17 300.09,77.18 300,77.31 299.87,77.39 299.85,77.41 299.72,77.42 299.62,77.41 299.42,77.41 299.16,77.66 299.16,78.68 299.29,78.8 300.18,78.8
GND on TOP (solid shape): 21.24,77 21.24,76.39 21.1,76.25 21.08,76.25 20.93,76.26 20.8,76.26 16.31,76.26 16.27,76.28 16.26,76.31 16.26,76.44 16.34,76.52 19.66,76.52 19.84,76.7 19.84,76.83 19.87,76.92 19.88,77 19.88,77.05 19.86,77.11 19.87,77.13 20.07,77.33 20.91,77.33
GND on TOP (solid shape): 259.46,121.76 259.46,118.96 259.34,118.83 257.91,118.83 257.65,118.93 257.39,118.83 256.41,118.83 256.31,118.85 256.21,118.83 255.78,118.83 255.78,118.83 255.24,118.83 255.11,118.97 255.11,119.43 255.53,119.85 255.53,121.63 255.78,121.88 259.34,121.88
GND on TOP (solid shape): 263.2,85.03 263.2,84.57 262.99,84.37 262.89,84.37 262.87,84.39 262.23,84.39 262.13,84.29 262.13,83.96 262.26,83.83 262.64,83.83 262.7,83.77 262.7,82.91 262.69,82.89 262.31,82.89 262.31,83.31 262.03,83.59 262.03,83.84 261.85,84.01 255.3,84.01 255.23,84.08 254.19,84.08 253.93,84.34 253.34,84.34 253.16,84.52 253.16,84.93 253.42,85.18 263.05,85.18
GND on TOP (solid shape): 295.94,92.39 295.94,89.84 296.33,89.45 296.33,88.68 296.4,88.61 298.41,88.61 298.46,88.56 298.46,88.37 298.1,88 294.99,88 294.3,87.31 293.18,87.31 292.5,88 291.05,88 290.85,88.2 290.85,88.62 291.01,88.78 291.65,88.78 291.82,88.95 291.82,89.51 292.06,89.75 293.61,89.75 293.91,90.04 293.91,92.23 294.17,92.5 295.84,92.5
GND on TOP (solid shape): 67.43,50.97 67.5,51 67.58,50.97 67.65,50.92 67.75,50.9 68.05,50.9 68.09,50.9 68.13,50.91 68.22,50.9 68.26,50.82 68.26,49.81 68.16,49.7 66.3,49.7 66.18,49.82 66.18,50.38 66.36,50.56 67.02,50.56
GND on TOP (solid shape): 112.11,121.81 113.16,121.81 113.41,121.55 114.4,121.55 114.53,121.43 114.53,119.5 114.48,119.44 113.95,119.44 113.8,119.6 113.8,120.05 113.51,120.34 112.46,120.34 112.13,120.67 112.13,120.86 112.05,120.94 111.3,120.94 111.08,120.72 111.08,119.34 111.14,119.28 111.14,118.78 111.03,118.67 110.66,118.67 110.66,118.67 110.47,118.67 110.37,118.78 110.37,122.76 110.4,122.79 111.13,122.79
GND on TOP (solid shape): 310.98,88.2 310.98,88 311,87.98 311.55,87.98 311.72,87.8 311.72,86.96 311.55,86.8 311.41,86.8 311.19,87.02 311.19,87.13 311.18,87.13 311.18,87.28 311.01,87.45 310.86,87.45 310.74,87.57 310.74,87.95 310.74,87.95 310.74,88.2 310.77,88.23 310.95,88.23
GND on TOP (solid shape): 57.73,53.58 57.73,52.23 57.42,51.92 57.31,51.92 57.28,51.94 57.28,51.95 57.13,52.13 56.91,52.2 56.75,52.16 56.61,52.06 56.54,52.03 56.47,52.06 56.37,52.16 56.37,53.49 56.51,53.63 57.68,53.63
GND on TOP (solid shape): 237.4,75.06 237.4,72.98 237.78,72.61 237.78,71 237.9,70.87 241.97,70.87 242.03,70.81 242.03,70.61 241.98,70.56 240.97,70.56 240.64,70.22 240.64,67.21 240.61,67.18 237.12,67.18 237.09,67.21 237.09,70.8 237.18,70.89 237.33,70.89 237.47,71.03 237.47,71.06 237.47,72.05 237.47,72.05 237.36,72.17 236.72,72.81 236.72,75.06 236.89,75.24 237.22,75.24
GND on TOP (solid shape): 256.32,57.13 256.32,56.86 256.52,56.66 256.9,56.66 256.98,56.57 256.98,55.94 257.47,55.45 257.5,55.44 257.92,55.44 257.95,55.42 257.96,55.4 257.96,55.38 257.96,55.04 257.19,54.26 257.19,53.33 257.11,53.25 256.46,53.25 256.37,53.34 256.37,54.39 256.8,54.82 256.8,55.97 256.63,56.14 256.58,56.14 256.12,56.14 256.1,56.12 253.9,56.12 253.74,56.27 253.74,57.28 254.01,57.54 255.91,57.54
GND on TOP (solid shape): 48.51,59.8 48.51,57.01 48.34,56.83 47.44,56.83 47.38,56.88 47.38,57.01 47.39,57.05 47.39,57.43 47.38,57.47 47.38,57.77 47.39,57.81 47.39,58.19 47.38,58.23 47.38,58.35 47.43,58.4 47.43,59.88 47.45,59.92 47.48,59.93 48.39,59.93
GND on TOP (solid shape): 156.93,149.81 156.93,148.9 157.13,148.71 157.48,148.71 157.66,148.89 157.66,149.31 157.71,149.35 157.95,149.35 157.98,149.32 157.98,148.66 158.07,148.58 158.07,148.19 158.31,147.95 158.49,147.95 158.57,147.86 158.57,147 158.39,146.83 157.77,146.83 157.5,147.1 157.5,147.62 157.1,148.01 155.97,148.01 155.53,148.45 155.53,149.21 155.61,149.29 156.04,149.29 156.3,149.55 156.3,149.81 156.43,149.93 156.81,149.93
GND on TOP (solid shape): 246.93,43.1 246.93,42.53 246.77,42.38 246.33,42.38 246.22,42.49 246.22,42.72 245.92,43.03 244.94,43.03 244.64,42.73 244.64,41.64 244.2,41.2 244.2,40.45 244.35,40.3 245.63,40.3 246.03,39.91 246.03,39.62 246.29,39.36 246.74,39.36 246.82,39.28 248.8,39.28 248.92,39.16 248.92,38.6 248.75,38.42 246.02,38.42 245.92,38.53 244.13,38.53 243.4,39.25 243.4,43.8 244.4,44.8 245.22,44.8
GND on TOP (solid shape): 122.05,213.58 122.45,213.58 122.45,213.33 122.95,213.33 122.95,212.83 123.2,212.83 123.2,212.43 123.2,212.43 123.2,208.63 123.2,208.63 123.2,208.23 122.95,208.23 122.95,207.73 122.45,207.73 122.45,207.48 122.05,207.48 122.05,207.48 118.24,207.48 118.24,207.48 117.85,207.48 117.85,207.73 117.34,207.73 117.34,208.23 117.1,208.23 117.1,208.63 117.09,208.63 117.09,212.43 117.1,212.43 117.1,212.83 117.34,212.83 117.34,213.33 117.85,213.33 117.85,213.58 118.24,213.58 118.24,213.58 122.05,213.58
GND on TOP (solid shape): 244.05,113.95 244.05,113.35 244.05,113.34 244.05,112.9 244.05,112.89 244.05,111.96 243.89,111.81 243.26,111.81 243.25,111.82 243.25,112.22 243.28,112.26 243.28,112.27 243.35,112.34 243.35,113.16 243.22,113.28 242.31,113.28 242.16,113.13 242.16,113.07 242.13,113.04 242.13,112.59 242.12,112.59 241.81,112.59 241.77,112.63 241.77,113.45 242.11,113.79 242.74,113.79 242.83,113.88 242.83,114.34 242.84,114.38 242.88,114.39 243.6,114.39
GND on TOP (solid shape): 298.82,105.94 298.82,105.6 298.71,105.49 298.71,105.38 298.69,105.38 298.69,104.58 298.71,104.58 298.71,103.53 298.24,103.06 298.24,102.18 298.25,102.17 298.25,101.83 298.48,101.6 298.48,97.7 298.24,97.46 297.5,97.46 297.3,97.66 297.3,100.61 298.07,101.38 298.07,102.07 298,102.13 298,102.99 297.97,103.02 297.97,103.55 297.98,103.55 297.98,104.08 298.43,104.53 298.43,104.59 298.44,104.59 298.44,105.38 298.43,105.38 298.43,105.57 298.3,105.7 298.3,105.97 298.42,106.09 298.68,106.09
GND on TOP (solid shape): 32.34,41.01 32.45,41.01 32.46,41.01 32.62,40.97 32.77,41.01 32.78,41.01 33.49,41.01 33.52,41 33.7,40.84 33.91,40.79 34.45,40.79 34.48,40.79 34.5,40.78 34.52,40.77 34.6,40.69 34.6,40.15 34.53,40.08 33.35,40.08 32.81,39.54 31.53,39.54 31.36,39.71 31.36,40.99 31.41,41.04 32.31,41.04
GND on TOP (solid shape): 173.41,78.53 173.41,78.51 173.42,78.43 173.46,78.35 173.46,77.94 173.33,77.81 172.76,77.81 172.64,77.69 172.19,77.69 172.15,77.69 172.11,77.68 171.81,77.68 171.78,77.68 171.77,77.7 171.74,77.74 171.68,77.77 171.26,78.19 171.26,78.35 171.28,78.46 171.26,78.57 171.26,78.63 171.33,78.69 173.24,78.69
GND on TOP (solid shape): 270.28,78.78 270.34,78.78 270.38,78.74 270.56,78.74 270.61,78.68 270.61,76.01 270.51,75.91 270.18,75.91 270.08,76.01 270.08,76.02 270.13,76.13 270.15,76.26 270.13,76.38 270.08,76.5 270.08,76.85 270.13,76.97 270.15,77.09 270.13,77.22 270.08,77.34 270.08,77.59 269.67,77.99 269.67,78.2 269.69,78.21 269.69,78.97 269.8,79.08 269.98,79.08
GND on TOP (solid shape): 276.52,200.45 276.52,198.44 276.8,198.16 277.15,198.16 277.46,198.11 277.72,198.3 277.74,198.32 277.76,198.32 278.1,198.32 278.27,198.16 278.96,198.16 279.08,198.04 279.08,197.29 278.76,196.97 275.74,196.97 275.16,196.39 275.16,195.61 275.04,195.49 274.38,195.49 274.16,195.71 274.16,197.11 273.34,197.94 273.34,200.68 273.46,200.8 276.18,200.8
GND on TOP (solid shape): 276.99,131.39 276.99,130.91 277,130.91 277.02,130.89 277.29,130.61 277.8,130.61 277.95,130.64 278.08,130.71 278.34,130.71 278.63,131 280.59,131 280.89,130.7 280.89,129.84 280.74,129.69 279.08,129.69 278.85,129.92 277.96,129.92 277.58,129.54 277.58,129.04 277.5,128.96 277.21,128.96 277.19,128.98 277.19,129.42 277.12,129.49 276.65,129.49 276.3,129.14 275.37,129.14 275.13,129.38 275.13,131.19 275.37,131.44 276.95,131.44
GND on TOP (solid shape): 14.59,41.14 14.65,41.11 14.71,41.1 15.01,41.1 15.08,41.11 15.14,41.14 15.15,41.14 16.78,41.14 16.88,41.05 16.88,40.51 16.86,40.44 16.86,40.37 16.86,40.31 16.88,40.24 16.88,39.83 16.86,39.75 16.86,39.69 16.85,39.64 16.84,39.63 16.7,39.49 15.89,39.49 15.83,39.43 15.8,39.43 15.18,38.81 13.69,38.81 13.62,38.89 13.62,40.8 13.96,41.14 14.58,41.14
GND on TOP (solid shape): 79.16,42.17 79.83,42.17 79.92,42.07 79.92,41.19 79.84,41.11 73.41,41.11 73.2,41.32 73.2,41.78 73.31,41.89 73.95,41.89 74.01,41.96 74.05,41.98 74.23,42.17 74.46,42.17 74.58,42.29 76.05,42.29 76.31,42.03 76.54,42.03 76.66,41.93 76.81,41.9 77.12,41.9 77.37,42 77.47,42.25 77.47,42.34 77.49,42.36 78.97,42.36
GND on TOP (solid shape): 219.5,45.54 219.5,45.2 219.41,45.12 218.28,45.12 217.64,44.48 217.64,43.66 216.56,42.58 216.56,42.32 216.22,41.98 216.22,41.7 216.22,41.59 216.41,41.4 217.43,41.4 217.45,41.38 217.45,40.94 216.88,40.38 216.88,39.86 216.33,39.31 214.99,39.31 214.79,39.51 214.79,40.38 214.76,40.38 213.93,41.2 213.93,42.14 214.2,42.41 214.2,42.43 214.99,43.21 215.39,43.21 216.14,43.96 216.56,43.96 216.69,44.1 216.69,44.83 217.51,45.65 219.39,45.65
GND on TOP (solid shape): 257.41,72.18 257.41,71.69 257.58,71.51 257.58,71.11 257.74,70.96 257.87,70.96 257.91,70.95 257.94,70.95 258.22,70.95 258.25,70.95 258.28,70.96 258.4,70.96 258.55,71.11 258.55,71.77 258.7,71.92 260.15,71.92 260.19,71.87 260.25,71.85 260.63,71.85 260.69,71.87 260.73,71.92 261.34,71.92 261.45,71.82 261.45,70.47 261.3,70.33 257,70.33 256.84,70.49 256.84,70.69 256.82,70.7 256.82,72.12 256.92,72.23 257.36,72.23
GND on TOP (solid shape): 158.76,54.03 158.82,53.96 158.9,53.89 159.01,53.79 159.01,45.76 158.63,45.38 154.94,45.38 154.46,45.86 154.46,48.01 154.47,48.04 154.72,48.22 154.8,48.48 154.72,48.74 154.47,48.92 154.46,48.95 154.46,54.14 154.59,54.27 158.52,54.27
GND on TOP (solid shape): 254.97,119.24 254.97,118.79 255.07,118.69 255.57,118.69 255.74,118.52 255.74,117.64 255.47,117.36 255.45,117.36 255.37,117.35 255.29,117.32 254.79,117.32 254.39,116.92 254.39,116.5 254.43,116.45 254.43,116.42 254.69,116.16 254.72,116.16 254.83,116.05 254.86,116.05 255.09,115.82 255.09,115.53 254.94,115.38 254.94,113.15 254.75,112.95 254.75,112.67 254.49,112.41 253.77,112.41 253.7,112.48 253.7,114.81 253.79,114.9 253.79,115.25 253.64,115.4 253.64,117.91 254.08,118.35 254.08,119.14 254.23,119.29 254.92,119.29
GND on TOP (solid shape): 92.49,92.18 92.49,91.31 92.68,91.31 92.68,92.13 92.7,92.17 92.74,92.18 92.85,92.18 92.89,92.14 92.89,91.31 92.93,91.27 92.93,91.19 93.29,90.82 93.29,88.72 92.93,88.37 92.62,88.37 92.49,88.24 92.49,88.2 92.49,88.2 92.49,87.39 92.43,87.33 92.35,87.33 92.28,87.41 92.28,87.41 92.28,88.2 92.28,88.2 92.13,88.35 92,88.35 91.82,88.53 91.82,90.82 92.19,91.18 92.19,91.18 92.28,91.28 92.28,92.18 92.32,92.21 92.45,92.21
GND on TOP (solid shape): 43.04,81.16 43.17,81.16 43.31,81.01 43.31,79.74 43.16,79.59 42.63,79.59 42.33,79.89 41.37,79.89 41.05,79.57 41.05,79.06 40.5,78.51 38.61,78.51 38.26,78.15 38.26,77.59 36.5,75.83 36.5,75.53 36.43,75.45 35.82,75.45 35.77,75.5 35.77,76.32 35.97,76.52 36.17,76.52 36.5,76.85 36.86,76.85 37.67,77.66 37.67,78.22 38.53,79.08 38.53,81.05 38.59,81.1 38.61,81.11 38.64,81.11 38.67,81.1 38.7,81.1 38.84,81.1 39.18,81.1 39.29,81.12 39.39,81.17 43.03,81.17
GND on TOP (solid shape): 98.79,96.97 98.79,94.36 98.78,94.36 98.78,93.88 99.44,93.23 99.44,90.14 100.39,89.19 100.39,88.14 100.3,88.04 100.06,88.04 99.93,88.18 99.93,88.35 99.77,88.51 99.1,88.51 98.87,88.28 98.87,87.84 98.77,87.74 97.17,87.74 97.08,87.82 97.08,88.42 97.12,88.46 97.12,88.89 97.08,88.93 97.08,88.97 96.75,89.31 96.75,91.74 96.75,91.75 96.75,91.92 96.82,91.99 97.38,91.99 97.39,91.99 97.51,92.11 97.51,92.68 97.59,92.75 97.59,94.97 97.62,95 97.99,95 98.29,95.3 98.29,96.22 98.24,96.28 98.24,96.29 98.17,96.36 98.17,96.98 98.26,97.07 98.68,97.07
GND on TOP (solid shape): 239.18,136.11 239.18,135.89 239.48,135.59 239.48,135.04 239.48,134.82 239.44,134.78 239.44,134.32 239.27,134.15 239.27,134.04 239.2,133.97 238.85,133.97 238.85,133.98 238.66,133.79 238.66,133.58 238.87,133.38 239.42,133.38 239.5,133.3 239.5,132.79 239.5,132.77 239.5,130.8 239.33,130.63 238.55,130.63 238.35,130.83 238.35,133.1 238.22,133.23 237.8,133.23 237.6,133.43 237.6,134 238.05,134.45 238.05,134.56 238.05,135.06 238,135.11 237.99,135.13 237.99,135.15 237.99,135.48 238.56,136.06 238.56,136.13 238.76,136.34 238.95,136.34
GND on TOP (solid shape): 38.88,100.82 38.88,98.51 38.67,98.3 38.12,98.3 38,98.17 38,96.28 37.8,96.08 37.33,96.08 36.81,96.61 36.81,97.02 36.35,97.48 36.35,98.65 36.47,98.77 37.66,98.77 38.03,99.15 38.03,100.44 37.96,100.5 35.87,100.5 35.74,100.37 35.74,100.26 35.73,100.26 35.73,99.32 35.5,99.09 34.29,99.09 34,98.8 34,97.38 34.07,97.31 34.94,97.31 35.34,96.91 35.34,96.51 35.2,96.37 34.6,96.37 34.26,96.71 33.93,96.71 33.87,96.77 33.46,96.77 32.86,97.37 32.86,100.21 33.79,101.14 38.56,101.14
GND on TOP (solid shape): 46.84,36.88 46.85,36.86 46.86,36.84 46.86,36.56 46.81,36.52 46.81,36.32 46.28,35.79 43.05,35.79 42.99,35.85 42.99,36.3 43.01,36.33 43.04,36.35 43.94,36.35 43.98,36.39 44.02,36.39 44.06,36.39 44.1,36.41 44.14,36.41 45.72,36.41 45.77,36.41 45.93,36.41 46.05,36.53 46.06,36.54 46.26,36.66 46.36,36.87 46.37,36.91 46.41,36.92 46.8,36.92
GND on TOP (solid shape): 228.05,190.58 228.05,190.59 228.07,190.59 228.08,190.57 228.21,190.45 228.28,190.45 228.35,190.37 228.8,190.37 228.79,190.35 228.79,190.32 228.79,189.94 228.8,189.89 228.83,189.84 228.79,189.81 228.22,189.81 228.06,189.65 228.06,189.64 227.96,189.55 227.96,189.07 228.11,188.92 229.29,188.92 229.51,188.71 229.51,187.84 230.17,187.18 230.17,186.48 230.09,186.41 227.96,186.41 227.87,186.49 227.87,186.79 228.04,186.96 228.53,186.96 229.17,187.6 229.17,187.6 229.24,187.66 229.24,188.44 229.12,188.55 228.18,188.55 228.08,188.46 227.46,188.46 227.27,188.65 227.27,189.68 227.03,189.93 227.03,190.5 227.18,190.65 227.98,190.65
GND on TOP (solid shape): 152.62,148.66 152.62,148.28 152.84,148.06 152.84,148.05 153.15,148.05 153.35,147.85 153.35,146.85 153.36,146.84 153.36,139.59 153.97,138.98 158.63,138.98 158.63,138.97 159.52,138.97 159.59,138.9 159.59,136.56 159.46,136.44 159.01,136.44 158.87,136.58 158.87,137.82 158.63,138.06 153.73,138.06 153.4,137.74 153.4,136.73 153.21,136.54 153.21,136.03 153.1,135.93 151.15,135.93 151.09,135.99 146.9,135.99 146.77,136.11 146.77,136.37 146.52,136.62 146.24,136.62 146.14,136.72 146.14,137.99 144.93,139.2 144.93,147.08 145.08,147.23 150.49,147.23 150.97,147.71 150.97,148.5 151.24,148.78 152.5,148.78
GND on TOP (solid shape): 222.69,190.55 222.69,190.2 222.83,190.06 223.56,190.06 223.95,190.45 223.95,190.53 224.08,190.66 224.29,190.66 224.28,190.63 224.27,190.6 224.27,190.22 224.28,190.17 224.3,190.13 223.86,189.69 223.86,189.07 224,188.92 224.02,188.92 224.02,188.92 224.93,188.92 224.98,188.87 224.98,188.56 224.92,188.51 224.02,188.51 224.02,188.51 223.91,188.51 223.64,188.77 223.64,188.91 223.4,189.15 222.95,189.15 222.46,188.66 221.41,188.66 220.99,189.08 220.04,189.08 219.27,188.31 218.42,188.31 218.06,188.67 218.06,189.27 218.62,189.83 218.81,189.83 219.64,190.66 220.26,190.66 220.31,190.61 220.31,190.41 221,189.71 221.67,189.71 222.02,190.07 222.02,190.56 222.16,190.7 222.54,190.7
GND on TOP (solid shape): 228.66,72.59 228.66,72.3 228.41,72.04 228.02,72.04 227.98,72 227.98,71.16 227.84,71.03 227.84,69.43 227.77,69.36 227.77,69.29 227.72,69.24 227.72,68.68 227.68,68.64 226.7,68.64 226.64,68.7 226.64,69.16 226.66,69.2 226.69,69.21 226.79,69.21 227.03,69.45 227.21,69.45 227.29,69.46 227.38,69.48 227.47,69.48 227.59,69.59 227.59,69.65 227.59,69.66 227.65,69.77 227.66,69.9 227.64,70.03 227.59,70.15 227.59,70.37 227.64,70.49 227.66,70.62 227.66,72.37 228.09,72.79 228.46,72.79
GND on TOP (solid shape): 244.05,119.93 244.05,119.65 243.97,119.57 243.72,119.57 243.6,119.46 243.6,119 243.59,118.96 243.56,118.95 243.41,118.89 243.3,118.79 243.28,118.78 243.26,118.77 242.66,118.77 242.4,118.5 241.72,118.5 241.65,118.58 241.65,118.73 241.47,118.91 241.45,118.91 241.44,118.92 240.78,118.92 240.66,119.05 240.66,119.53 240.66,119.55 240.67,119.57 240.73,119.62 241.14,119.62 241.16,119.62 241.32,119.49 241.49,119.45 241.6,119.46 241.71,119.51 241.72,119.52 241.76,119.52 241.91,119.37 242.22,119.37 242.83,119.98 244,119.98
GND on TOP (solid shape): 312.24,81.93 314.28,81.93 314.4,81.8 314.4,81.57 314.63,81.34 315.43,81.34 315.47,81.34 315.57,81.34 316.23,80.68 316.23,78.21 316.24,78.2 316.24,77.88 316.31,77.81 316.31,76.98 316.17,76.84 315.58,76.84 315.48,76.94 315.48,77.24 315.65,77.41 315.65,79.62 314.91,80.35 311.66,80.35 311.58,80.43 311.58,80.87 311.62,80.88 311.83,81.03 311.92,81.27 311.89,81.42 311.8,81.54 311.77,81.61 311.79,81.68 311.85,81.77 311.87,81.88 311.87,81.93 312.23,81.93
GND on TOP (solid shape): 26.32,56.01 26.32,55.59 25.74,55.01 25.74,53.36 25.72,53.29 25.72,53.16 25.74,53.09 25.74,52.38 25.67,52.32 25.64,52.35 25.51,52.43 25.36,52.46 25.15,52.4 25.01,52.24 24.99,52.21 19.73,52.21 19.65,52.28 19.65,52.97 19.73,53.04 21.51,53.04 21.59,53.12 21.59,53.21 21.61,53.28 21.61,53.48 21.6,53.5 21.59,53.54 21.59,53.99 21.78,54.18 23.16,54.18 23.51,54.53 23.51,55.97 23.73,56.2 26.13,56.2
GND on TOP (solid shape): 306.79,64.96 306.79,64.5 306.95,64.34 306.95,64.11 307.23,63.83 307.81,63.83 307.86,63.8 307.92,63.77 308.01,63.69 308.01,63.45 307.95,63.4 307.94,63.39 307.83,63.36 307.73,63.29 307.71,63.28 307.4,62.98 307.2,62.98 306.92,62.69 306.92,62.54 306.69,62.3 306.15,62.3 306.06,62.39 306.06,62.77 306.11,62.82 306.47,62.82 306.54,62.89 306.54,63.05 306.65,63.16 306.69,63.19 306.72,63.23 306.76,63.27 306.76,63.69 306.71,63.74 306.69,63.77 306.63,63.82 306.57,63.88 306.21,63.88 306.15,63.82 305.9,63.82 305.77,63.95 305.77,64.2 305.93,64.37 306.02,64.37 306.12,64.47 306.12,64.86 306.3,65.04 306.71,65.04
GND on TOP (solid shape): 203,80.78 203,80.1 202.47,79.57 200.68,79.57 200.67,79.6 200.31,79.84 199.95,79.6 199.93,79.57 199.8,79.57 199.72,79.61 199.7,79.7 199.72,79.76 199.72,79.82 199.61,80.1 199.33,80.22 199.08,80.13 198.94,79.91 198.93,79.87 198.5,79.87 198.3,80.07 198.3,80.87 198.75,81.32 202.46,81.32
GND on TOP (solid shape): 249.91,121.25 250.22,121.25 250.24,121.22 250.24,117.5 250.66,117.09 250.66,116.31 250.78,116.19 251.01,116.19 251.01,116.19 251.23,116.19 251.36,116.06 251.36,115.74 251.08,115.46 251.08,114.6 250.85,114.38 250.85,114.1 250.75,114 249.25,114 248.88,114.36 248.39,114.36 248.36,114.39 248.36,114.69 248.42,114.75 249,114.75 249.12,114.62 250.6,114.62 250.8,114.83 250.8,115.36 250.57,115.58 250.43,115.58 250.18,115.84 250.18,116.03 249.85,116.36 249.85,117.2 249.91,117.26 249.91,117.84 249.79,117.97 247.48,117.97 247.2,118.25 247.2,118.71 248.87,118.71 249.13,118.96 249.13,121.3 249.3,121.48 249.69,121.48
GND on TOP (solid shape): 102.86,75.83 102.86,75.53 102.52,75.19 102.52,74.63 102.13,74.23 102.13,71.72 100.96,70.56 97.38,70.56 97.28,70.66 97.28,71.71 97.38,71.82 98.14,71.82 98.22,71.9 98.22,73.52 98.17,73.57 98.17,73.65 100.77,73.65 100.77,73.6 100.78,73.54 100.79,73.49 100.82,73.44 100.85,73.39 100.88,73.35 100.93,73.31 100.97,73.28 101.02,73.26 101.08,73.24 101.13,73.23 101.19,73.23 101.25,73.24 101.3,73.26 101.35,73.28 101.4,73.31 101.44,73.35 101.48,73.39 101.51,73.44 101.53,73.49 101.55,73.54 101.56,73.6 101.56,73.65 101.55,73.71 101.53,73.76 101.51,73.82 101.48,73.86 101.44,73.91 101.4,73.94 101.35,73.97 101.3,74 101.25,74.01 101.19,74.02 101.13,74.02 101.08,74.01 101.02,74 100.97,73.97 100.93,73.94 100.88,73.91 100.85,73.86 100.82,73.82 100.79,73.76 100.78,73.71 100.77,73.65 98.17,73.65 98.17,73.92 98.18,73.95 98.21,73.99 98.21,75.61 98.18,75.64 98.18,75.7 98.35,75.87 102.82,75.87
GND on TOP (solid shape): 252.95,214.94 253.01,214.94 253.07,214.94 253.14,214.96 253.63,214.96 253.63,214.96 253.76,214.96 253.78,214.93 253.78,213.99 253.73,213.9 253.63,213.9 253.54,213.93 253.44,213.95 253.05,213.55 253.44,213.16 253.52,213.16 253.59,213.19 253.69,213.18 253.73,213.09 253.73,212.79 253.55,212.61 252.9,212.61 252.17,211.88 251.45,211.88 251.37,211.96 251.37,212.32 252.18,213.13 252.18,214.29 252.85,214.96
GND on TOP (solid shape): 234.6,116.83 234.6,116.37 234.43,116.2 233.23,116.2 232.36,115.32 232.36,115.17 232.34,115.16 232.28,115.12 232.24,115.06 232.24,115.05 231.98,114.8 231.98,113.53 233.07,112.43 234.6,112.43 234.75,112.59 234.75,113.17 234.85,113.27 235.31,113.27 235.44,113.15 235.44,112.97 235.61,112.79 236.43,112.79 236.68,113.04 238.13,113.04 238.53,112.64 238.53,112.03 238.46,111.95 238.1,111.95 238.03,112.03 238.03,112.56 237.97,112.61 237.95,112.65 237.9,112.69 237.85,112.69 237.44,112.69 237.41,112.69 237.23,112.69 237.2,112.69 236.79,112.69 236.71,112.69 236.55,112.54 236.55,112.21 236.07,111.72 234.67,111.72 234.29,111.34 231.91,111.34 231.61,111.63 231.61,112.47 230.58,113.5 230.58,114.85 231.06,115.32 232.03,115.32 233.61,116.9 234.52,116.9
GND on TOP (solid shape): 40.76,40.55 40.76,40.44 40.75,40.4 40.75,40.37 40.75,40.09 40.75,40.06 40.76,40.03 40.76,39.91 40.76,39.9 40.84,39.82 42.42,39.82 42.49,39.75 42.51,39.73 42.51,39.7 42.5,39.65 42.49,39.59 42.52,39.44 42.6,39.31 42.6,39.14 42.79,38.95 42.79,38.64 42.67,38.52 42.67,37.24 42.5,37.07 41.39,37.07 41.32,37.07 41.14,36.89 41.02,36.78 40.7,36.78 40.66,36.82 40.66,37.09 41.11,37.54 41.47,37.54 42.15,38.22 42.15,38.8 42.05,38.91 41.8,39.16 40.92,39.16 40.56,39.53 40.54,39.53 40.52,39.54 40.43,39.58 40.32,39.59 40.22,39.58 40.12,39.54 40.11,39.53 40.06,39.53 39.87,39.71 39.87,39.96 40.24,40.32 40.24,40.52 40.37,40.65 40.66,40.65
GND on TOP (solid shape): 186.78,102.25 186.81,102.24 186.82,102.22 186.84,102.19 186.87,102.15 186.89,102.08 186.87,102.02 186.79,101.9 186.76,101.75 187.16,101.36 187.55,101.75 187.52,101.9 187.43,102.03 187.42,102.07 187.46,102.12 187.47,102.12 188.06,102.12 188.14,102.05 188.14,100.41 188.13,100.25 188.14,100.1 187.82,99.78 187.53,99.78 187.28,100.04 187.27,100.05 187.24,100.1 187.19,100.14 187.17,100.14 187.13,100.18 186.97,100.18 186.34,100.82 186.34,102.22 186.36,102.25
GND on TOP (solid shape): 18.14,65.83 18.21,65.82 18.28,65.83 18.35,65.84 20.06,65.84 20.14,65.83 20.21,65.82 20.28,65.83 20.35,65.84 20.46,65.84 20.54,65.83 20.61,65.82 20.67,65.83 20.7,65.82 20.72,65.81 20.74,65.79 20.74,62.83 20.7,62.78 20.68,62.78 20.61,62.78 20.53,62.77 20.46,62.76 20.35,62.76 20.28,62.77 20.21,62.78 20.13,62.77 20.06,62.76 18.35,62.76 18.28,62.77 18.21,62.78 18.13,62.77 18.06,62.76 17.95,62.76 17.88,62.77 17.81,62.78 17.73,62.77 17.71,62.78 17.69,62.79 17.63,62.85 17.63,65.8 17.65,65.83 17.68,65.84 17.75,65.83 17.81,65.82 17.88,65.83 17.95,65.84 18.06,65.84
GND on TOP (solid shape): 228.02,133.72 228.02,133.71 228.08,133.65 228.08,133.64 228.3,133.42 228.89,133.42 228.97,133.5 229.29,133.5 229.41,133.39 230.09,133.39 230.1,133.4 230.88,133.4 230.91,133.43 230.91,133.43 230.98,133.49 231.42,133.49 231.57,133.64 232.09,133.64 232.09,133.64 232.19,133.64 232.33,133.49 232.33,133.33 232.41,133.26 232.9,133.26 232.93,133.23 232.93,133.04 232.83,132.94 232.37,132.94 232.31,132.95 232.3,132.96 232.12,133.08 231.9,133.13 231.74,133.1 231.6,133.04 231.58,133.03 231.54,133.03 231.5,132.99 230.87,132.99 230.7,133.1 230.49,133.14 230.31,133.1 230.14,133.01 230.13,133 229.93,133.01 228.77,133.01 228.77,133.01 228.34,133.01 228.21,132.89 227.93,132.89 227.9,132.92 227.53,132.92 227.5,132.89 227.38,132.89 227.38,132.89 227.38,133.79 227.46,133.88 227.86,133.88
GND on TOP (solid shape): 303.07,69.68 303.11,69.67 303.12,69.63 303.12,68.63 303.13,68.63 303.13,68.39 303.29,68.22 303.4,68.22 303.44,68.21 303.45,68.17 303.45,66.19 303.71,65.94 303.83,65.94 303.83,65.93 304.81,65.93 304.84,65.91 304.86,65.88 304.86,65.8 304.87,65.78 304.86,65.76 304.84,65.74 304.81,65.73 303.83,65.73 303.78,65.73 303.45,65.39 303.45,63.99 303.44,63.96 303.4,63.94 302.81,63.94 302.81,63.86 302.8,63.82 302.76,63.81 300.08,63.81 299.9,63.63 299.9,63.46 299.92,63.44 299.92,62.43 299.91,62.4 299.89,62.39 299.88,62.38 299.84,62.39 299.77,62.38 299.75,62.39 299.73,62.41 299.72,62.43 299.72,63.42 299.72,63.42 299.72,63.63 299.54,63.81 299.02,63.81 298.97,63.86 298.97,68.24 299.23,68.5 299.55,68.5 299.82,68.22 302.72,68.22 302.92,68.42 302.92,69.64 302.97,69.68
GND on TOP (solid shape): 33.75,83.37 33.75,82.99 33.95,82.79 33.95,82.5 34.29,82.16 34.29,81.49 34.12,81.32 33.74,81.32 33.55,81.13 33.55,80.39 33.51,80.35 33.51,79.08 33.3,78.87 32.6,78.87 32.19,79.28 32.19,79.75 31.76,80.19 31.76,81.31 32.06,81.61 33.18,81.61 33.32,81.75 33.32,83.14 33.23,83.23 31.31,83.23 31.18,83.1 31.18,82.11 30.89,81.82 29.76,81.82 29.41,81.47 29.41,80.22 29.43,80.19 29.43,80.17 29.48,80.08 29.57,80.04 30.54,80.04 30.75,79.83 30.75,78.94 30.64,78.83 29.87,78.83 29.73,78.97 29.72,79 29.73,79.01 29.58,79.39 29.18,79.44 29.1,79.44 29.05,79.48 28.95,79.6 28.82,79.67 28.8,79.67 28.29,80.18 28.29,81.86 29.21,82.78 29.21,83.29 29.49,83.57 29.5,83.57 29.87,83.94 33.19,83.94
GND on TOP (solid shape): 41.59,48.5 41.6,48.48 41.61,48.46 41.61,47.98 41.18,47.55 40.73,47.55 40.7,47.56 40.52,47.81 40.25,47.9 40.13,47.88 40.02,47.83 40.01,47.83 39.99,47.83 39.82,47.66 39.63,47.66 39.48,47.63 39.34,47.55 39.12,47.55 39.04,47.63 39.04,47.66 39.11,47.78 39.14,47.93 39.08,48.13 38.93,48.28 38.92,48.28 38.8,48.4 38.42,48.4 38.14,48.13 38.14,47.46 37.9,47.22 37.45,47.22 37.29,47.07 37.27,47.06 37.21,47.07 37.16,47.08 36.88,46.96 36.76,46.68 36.76,46.64 36.77,46.6 36.75,46.52 36.67,46.48 35.28,46.48 35.19,46.58 35.19,47.18 35.64,47.63 36.3,47.63 37.47,48.8 41.29,48.8
GND on TOP (solid shape): 285.06,177.93 285.06,177.82 285,177.72 284.89,177.73 284.78,177.79 284.66,177.81 284.27,177.42 284.66,177.02 284.78,177.04 284.89,177.1 285,177.11 285.06,177.02 285.06,174.83 285,174.77 284.96,174.77 284.94,174.78 284.82,174.85 284.68,174.88 284.57,174.86 284.47,174.82 284.42,174.82 284.39,174.87 284.39,174.88 284.39,175.26 284.39,175.29 284.37,175.34 284.37,175.54 284.17,175.74 284.03,175.74 283.99,175.75 283.97,175.79 283.97,176.98 283.73,176.98 283.73,175.79 283.71,175.75 283.68,175.74 283.63,175.74 283.5,175.86 283.5,177.71 284.03,178.24 284.74,178.24
GND on TOP (solid shape): 269.2,184.01 269.2,183.58 269.55,183.23 270.36,183.23 270.74,182.86 270.74,182.76 271.24,182.25 271.75,182.25 271.75,182.25 274.34,182.25 274.74,181.84 274.74,179.99 274.42,179.68 273.84,179.68 273.77,179.71 273.74,179.8 273.75,179.83 273.75,179.87 273.64,180.15 273.36,180.27 273.21,180.24 273.08,180.15 273.01,180.12 272.94,180.15 272.82,180.21 272.69,180.24 272.53,180.2 272.39,180.1 272.32,180.07 272.24,180.1 272.11,180.18 271.96,180.21 271.68,180.1 271.57,179.82 271.57,179.79 271.54,179.71 271.47,179.68 267.87,179.68 267.01,180.54 267.01,183.86 267.14,183.99 268.05,183.99 268.14,184.07 268.14,184.12 268.28,184.27 268.94,184.27
GND on TOP (solid shape): 64.87,96.68 64.87,92.2 64.75,92.09 63.03,92.09 63.01,92.1 62.99,92.12 62.89,92.24 62.75,92.31 62.73,92.31 62.65,92.39 62.62,92.46 62.65,92.53 62.73,92.66 62.75,92.8 62.36,93.19 61.97,92.8 61.98,92.71 62.01,92.62 62.01,92.52 61.93,92.47 61.86,92.45 61.78,92.42 61.57,92.42 61.44,92.5 61.29,92.53 61.01,92.42 60.9,92.14 60.9,92.08 60.9,92.05 60.89,92.03 60.61,91.76 60.54,91.76 60.46,91.78 60.43,91.86 60.43,96.98 60.69,97.24 64.3,97.24
GND on TOP (solid shape): 60.53,85.39 60.79,85.39 60.86,85.32 60.86,85.13 60.89,85.1 60.89,85.08 61.01,84.88 61.22,84.8 61.29,84.8 61.36,84.82 61.74,84.82 62.01,84.56 62.01,84.24 61.97,84.19 61.95,84.19 61.7,84.06 61.61,83.8 61.72,83.52 62,83.41 62.08,83.42 62.16,83.44 62.24,83.44 62.29,83.39 62.42,83.21 62.61,83.13 62.63,83.13 62.71,83.05 62.71,82.87 62.71,82.81 62.71,82.13 63.26,82.13 63.26,81.79 62.86,81.39 62.79,81.32 62.77,81.25 62.75,81.2 62.74,81.14 62.73,81.07 62.75,80.95 62.79,80.85 62.79,80.58 62.61,80.4 60.66,80.4 60.43,80.63 60.43,85.4
GND on TOP (solid shape): outline of 102 points within 165.57,182.41 175.9,190.87
GND on TOP (solid shape): 270.98,207.76 271,207.76 271.11,207.65 272.15,207.65 272.26,207.76 273.8,207.76 273.93,207.63 273.93,207.32 273.78,207.17 273.78,206.44 274.02,206.2 274.17,206.2 274.81,205.56 274.81,203.43 274.81,203.33 274.89,203.25 275.5,203.25 275.85,203.6 275.85,204.35 275.99,204.49 276.6,204.49 277.07,204.02 277.4,204.02 277.43,203.99 277.43,203.77 277.33,203.66 276.45,203.66 275.41,202.63 271.8,202.63 271.73,202.71 271.73,203.28 271.77,203.36 271.86,203.38 272.81,204.35 271.47,204.52 271.39,204.47 271.31,204.5 270.82,204.99 270.66,204.99 270.59,205.06 270.59,205.37 270.34,205.62 270.34,205.69 269.93,206.11 269.93,206.24 269.19,206.97 268.25,206.97 268.1,207.13 268.1,207.81 268.19,207.9 270.49,207.9 270.55,207.96 270.78,207.96
GND on TOP (solid shape): outline of 98 points within 213.44,91.57 295.02,103.86
GND on TOP (solid shape): 190.03,99.43 190.07,99.41 190.08,99.38 190.08,91.73 190.12,91.56 190.21,91.41 190.37,91.26 190.37,89.43 190.4,89.26 190.5,89.12 190.6,89.01 190.6,86.96 190.4,86.75 189.51,86.75 189.21,87.06 189.2,87.09 189.22,87.15 189.22,87.19 189.22,87.49 189.2,87.6 189.11,87.7 189.1,87.73 189.1,90.5 189.06,90.54 189.06,90.59 188.85,90.79 188.27,90.79 188.04,90.56 188.04,88.71 187.96,88.63 187.58,88.63 187.43,88.79 187.43,92.04 186.08,93.38 186.08,97.06 186.13,97.15 186.23,97.15 186.32,97.12 186.41,97.1 186.81,97.5 186.41,97.89 186.32,97.88 186.23,97.85 186.13,97.85 186.08,97.94 186.08,98.41 186.16,98.49 186.49,98.49 186.74,98.24 187.1,98.24 187.2,98.13 187.2,95.24 186.79,94.83 186.79,94.43 186.92,94.3 189.51,94.3 189.66,94.45 189.66,95.24 189.28,95.62 189.28,96.86 189.66,97.24 189.66,97.93 189.28,98.31 189.28,99.12 189.54,99.39 189.62,99.43
GND on TOP (solid shape): outline of 81 points within 87.1,83 97.05,85.41
GND on TOP (solid shape): outline of 94 points within 225.82,143.42 227.95,150.33
GND on TOP (solid shape): outline of 273 points within 232.11,196.92 264.82,206.11
GND on TOP (solid shape): outline of 497 points within 208.32,53.78 219.58,68.73
GND on TOP (solid shape): outline of 168 points within 0.51,0.51 298.62,67.27
GND on TOP (solid shape): outline of 1379 points within 110.92,175.43 168.81,194.88
GND on TOP (solid shape): outline of 2243 points within 0.51,57.17 322.89,222.04
GND on BOTTOM (solid shape): 13.06,70 13.06,67.42 12.95,67.31 10.72,67.31 10.57,67.46 10.57,70.04 10.69,70.16 12.9,70.16
GND on BOTTOM (solid shape): 23.31,54.23 23.31,52.5 23.28,52.47 21.61,52.47 21.56,52.52 21.56,54.24 21.58,54.26 23.28,54.26
GND on BOTTOM (solid shape): 72.09,71.08 72.09,70.22 71.89,70.02 69.4,70.02 69.24,70.17 69.24,71.16 69.6,71.51 71.66,71.51
GND on BOTTOM (solid shape): 77.57,53.53 77.57,51.35 77.45,51.22 76.53,51.22 76.2,51.55 76.2,52.97 76.89,53.66 77.45,53.66
GND on BOTTOM (solid shape): 165.76,208.12 165.76,206.67 165.59,206.49 164.21,206.49 164.06,206.64 164.06,208.07 164.16,208.17 165.71,208.17
GND on BOTTOM (solid shape): 168.81,180.49 168.81,175.89 168.36,175.43 167.36,175.43 167.1,175.69 167.1,180.54 167.28,180.73 168.58,180.73
GND on BOTTOM (solid shape): 214.07,184.45 214.07,175.34 213.38,174.65 211.07,174.65 210.74,174.98 210.74,183.25 212.21,184.72 213.81,184.72
GND on BOTTOM (solid shape): 233.53,75.14 233.53,73.2 233.44,73.11 232.24,73.11 232.17,73.19 232.17,75.44 232.47,75.75 232.92,75.75
GND on BOTTOM (solid shape): 250.69,212.62 250.69,210.92 250.67,210.9 248.96,210.9 248.93,210.93 248.93,212.62 248.94,212.63 250.68,212.63
GND on BOTTOM (solid shape): 273.89,47.62 273.89,45.52 273.85,45.48 271.75,45.48 271.7,45.53 271.7,47.62 271.73,47.66 273.85,47.66
GND on BOTTOM (solid shape): 122.01,212.33 122.01,208.73 121.96,208.68 118.32,208.68 118.28,208.72 118.28,212.32 118.33,212.38 121.96,212.38
GND on BOTTOM (solid shape): 254.26,200.83 254.26,199.84 253.86,199.45 248.17,199.45 247.73,199.89 247.73,202.39 248.18,202.84 252.25,202.84
GND on BOTTOM (solid shape): 16.42,22.58 16.42,21.72 16.38,21.68 16.38,21 16.31,20.93 15.04,20.93 14.96,21.01 14.96,22.59 15.04,22.68 16.33,22.68
GND on BOTTOM (solid shape): 18.68,101.17 21.59,101.17 22,100.75 22,98.47 21.71,98.18 15.5,98.18 15.37,98.31 15.37,100.8 15.75,101.18 18.68,101.18
GND on BOTTOM (solid shape): 45.22,59.2 45.22,57.32 44.88,56.99 38.89,56.99 38.85,56.94 38.09,56.94 38,57.02 38,59.07 38.51,59.58 44.83,59.58
GND on BOTTOM (solid shape): 95.15,94.6 95.15,93.42 95.03,93.3 95.03,92.51 94.83,92.31 92.79,92.31 92.22,92.89 92.22,94.15 92.75,94.69 95.07,94.69
GND on BOTTOM (solid shape): 96.24,66.12 98.39,66.12 98.56,65.95 98.56,65.55 97.89,64.89 96.22,64.89 95.89,65.22 95.89,65.85 96.18,66.14 96.21,66.14
GND on BOTTOM (solid shape): 100.54,81.73 100.54,81.22 100.38,81.07 99.9,81.07 99.51,80.67 98.41,80.67 98.38,80.71 98.38,81.12 99.11,81.85 100.41,81.85
GND on BOTTOM (solid shape): 112.45,175.02 112.45,174.61 111.79,173.95 111.79,172.68 111.41,172.3 110.44,172.3 109.96,172.78 109.96,175.1 110.06,175.2 112.27,175.2
GND on BOTTOM (solid shape): 134.62,213.45 134.62,209.83 134.49,209.7 128.96,209.7 128.85,209.82 128.85,209.93 128.84,209.93 128.84,213.08 129.52,213.75 134.32,213.75
GND on BOTTOM (solid shape): 194.14,194.25 194.14,191.38 193.88,191.12 193.14,191.12 192.99,191.28 192.99,191.91 193.14,192.06 193.14,194.17 193.37,194.4 193.98,194.4
GND on BOTTOM (solid shape): 194.37,44.06 195.66,44.06 195.79,43.92 195.79,42.66 195.47,42.34 193.18,42.34 193.09,42.43 193.09,44.03 193.14,44.08 194.35,44.08
GND on BOTTOM (solid shape): 245.7,75.57 245.7,73.29 245.57,73.17 243.93,73.17 243.77,73.34 243.77,75.05 243.93,75.21 244.3,75.21 244.95,75.86 245.41,75.86
GND on BOTTOM (solid shape): 246.69,199.45 246.69,198.36 246.54,198.21 242.04,198.21 241.91,198.34 241.91,199.3 242.24,199.63 246.51,199.63
GND on BOTTOM (solid shape): 273,182.02 273,180.5 272.86,180.36 271.25,180.36 270.99,180.11 269.03,180.11 268.87,180.27 268.87,182.12 268.94,182.19 272.83,182.19
GND on BOTTOM (solid shape): 293.09,103.77 293.09,101.23 292.48,100.62 216.79,100.62 216.04,101.37 216.04,104.27 216.46,104.69 292.18,104.69
GND on BOTTOM (solid shape): 176.29,180.96 176.29,180.62 176.29,180.62 176.29,177.28 175.88,176.87 175.09,176.87 174.87,177.09 174.87,180.82 175.06,181.02 176.24,181.02
GND on BOTTOM (solid shape): 33.53,83.05 33.53,79.77 33.3,79.54 32.64,79.54 32.31,79.87 30.79,79.87 30.44,79.52 29.56,79.52 28.91,80.18 28.91,82.94 29.91,83.94 32.64,83.94
GND on BOTTOM (solid shape): 51.75,72.47 51.75,72.1 52.03,71.82 52.52,71.82 52.72,71.61 52.72,71.07 51.9,70.25 48.42,70.25 48.05,70.62 48.05,71.44 49.27,72.66 51.56,72.66
GND on BOTTOM (solid shape): 113.41,102.87 113.41,98.09 113.31,98 111.31,98 111.24,98.06 111.24,98.5 111.25,98.5 111.25,101.92 111.28,101.95 111.28,102.81 111.81,103.34 112.93,103.34
GND on BOTTOM (solid shape): 117.95,90 117.95,86.5 117.88,86.42 116.56,86.42 116.56,86.43 115.94,86.43 115.67,86.69 115.67,87.32 115.14,87.84 115.14,89.32 115.85,90.03 117.92,90.03
GND on BOTTOM (solid shape): 174.26,210.11 174.26,205.66 174.08,205.48 173.11,205.48 172.95,205.64 172.95,210.22 173.03,210.3 174.07,210.3
GND on BOTTOM (solid shape): 177.22,52.19 177.22,50.84 176.91,50.53 173.51,50.53 173.49,50.56 173.05,50.56 172.93,50.69 172.93,52.11 173.26,52.44 176.96,52.44
GND on BOTTOM (solid shape): 211.66,85.26 211.66,84.8 212.22,84.24 212.22,83.91 211.71,83.4 209.12,83.4 208.94,83.58 208.94,84.19 208.44,84.7 208.44,85.03 208.77,85.36 211.56,85.36
GND on BOTTOM (solid shape): 245.41,66.2 245.41,64.51 245.06,64.17 245.06,63.94 244.85,63.73 244.47,63.73 244.22,63.99 244.21,63.99 243.93,64.27 243.93,66.2 243.99,66.27 245.34,66.27
GND on BOTTOM (solid shape): 302.74,103.03 302.74,101.89 302.83,101.81 302.83,100.59 302.63,100.4 301.5,100.4 301.35,100.55 301.35,101.73 301.8,102.18 301.8,103.03 301.92,103.16 302.62,103.16
GND on BOTTOM (solid shape): 318.73,90.81 318.73,89.5 319.76,88.46 319.76,87.75 319.64,87.62 318.09,87.62 316.64,89.06 316.64,90.8 316.92,91.07 318.47,91.07
GND on BOTTOM (solid shape): 319.9,63.76 319.9,62.62 319.8,62.52 318.95,62.52 318.91,62.53 318.9,62.57 318.9,63.83 319.03,63.96 319.7,63.96
GND on BOTTOM (solid shape): 246.62,214.83 246.62,214.4 246.4,214.18 246.4,213.59 246.21,213.59 246.12,213.68 246.12,214 245.81,214.32 245.36,214.32 245.29,214.39 245.29,214.73 245.51,214.94 246.51,214.94
GND on BOTTOM (solid shape): 257.05,61.91 257.91,61.91 258.05,61.78 258.05,60.74 257.98,60.67 257.33,60.67 256.84,60.19 256.12,60.19 255.89,60.42 255.89,62.27 256.06,62.45 256.52,62.45
GND on BOTTOM (solid shape): 38.1,100.98 38.1,97.04 37.87,96.81 37.21,96.81 36.88,97.14 35.36,97.14 35.34,97.12 35.13,97.12 34.77,96.76 34.17,96.76 33.48,97.45 33.48,100.81 33.8,101.14 37.95,101.14
GND on BOTTOM (solid shape): 86.36,42.89 86.36,41.14 85.98,40.76 85.64,40.76 85.35,40.46 58.49,40.46 57.89,41.06 57.89,42.42 58.09,42.62 70.87,42.62 71.28,42.22 83.56,42.22 84.6,43.27 85.98,43.27
GND on BOTTOM (solid shape): 190.12,42.58 190.12,41.29 189.92,41.09 189.92,40.9 189.88,40.85 189.85,40.79 189.68,40.62 188.57,40.62 188.27,40.92 188.27,42.58 188.42,42.73 189.97,42.73
GND on BOTTOM (solid shape): 224.66,79.65 224.66,79.03 224.4,78.78 224.11,78.78 224.11,78.78 224.01,78.78 223.85,78.62 223.53,78.62 223.49,78.67 223.49,78.95 223.63,79.09 223.63,79.59 223.85,79.81 224.49,79.81
GND on BOTTOM (solid shape): 233.13,49.32 233.41,49.32 233.46,49.28 233.46,48.11 232.67,47.32 231.72,47.32 231.65,47.39 231.65,48.4 231.61,48.44 231.61,48.47 231.57,48.49 231.57,49.33 231.93,49.69 232.76,49.69
GND on BOTTOM (solid shape): 233.24,66.93 233.28,66.91 233.29,66.88 233.29,64.5 233.08,64.29 232.22,64.29 232.14,64.37 232.14,66.21 232.16,66.22 232.16,66.26 232.82,66.93
GND on BOTTOM (solid shape): 241,85.19 241,79.42 240.43,78.86 235.54,78.86 233.97,80.43 233.97,85.33 234.13,85.48 240.7,85.48
GND on BOTTOM (solid shape): 242.96,37.54 242.96,36.96 242.36,36.36 242.13,36.36 241.89,36.6 241.89,36.77 241.73,36.92 241.37,36.92 241.3,37 241.3,37.53 241.34,37.58 242.92,37.58
GND on BOTTOM (solid shape): 244.8,44.65 244.8,43.1 243.97,42.27 242.64,42.27 242.49,42.41 242.49,42.63 242.62,42.75 243.07,42.75 243.33,43.01 243.33,43.91 244.22,44.79 244.66,44.79
GND on BOTTOM (solid shape): 278.36,187.04 278.36,184.95 278.13,184.73 277.08,184.73 276.91,184.56 276.91,183.55 276.7,183.33 275.98,183.33 275.85,183.47 275.85,186.37 276.71,187.24 278.16,187.24
GND on BOTTOM (solid shape): 11.25,78.41 11.25,78.26 11.59,77.93 11.59,77.83 11.59,77.83 11.59,77.62 11.58,77.61 11.58,77.42 11.56,77.4 11.27,77.4 11.23,77.44 11.23,77.55 10.62,78.17 10.62,78.41 10.8,78.6 11.06,78.6
GND on BOTTOM (solid shape): 84.31,46.23 84.31,43.59 83.59,42.88 83.59,42.71 83.27,42.38 78.39,42.38 78.06,42.71 78.06,43.67 76.96,44.77 76.96,47.04 77.27,47.35 83.18,47.35
GND on BOTTOM (solid shape): 128.34,41.32 129.79,41.32 129.98,41.13 129.98,38.86 129.89,38.77 128.34,38.77 128.16,38.95 128.16,40.59 128.15,40.6 128.15,40.64 127.89,40.9 127.43,40.9 127.01,41.32 127.01,42.02 127.06,42.07 127.59,42.07
GND on BOTTOM (solid shape): 167.64,49.21 168.41,49.21 168.63,48.98 168.63,47.92 169.17,47.38 169.9,47.38 170.06,47.23 170.06,46.93 169.9,46.78 166.45,46.78 165.79,47.44 165.79,49.57 165.94,49.72 167.14,49.72
GND on BOTTOM (solid shape): 226.19,89.75 226.19,88.65 226.41,88.43 226.81,88.43 226.94,88.3 226.94,87.82 226.77,87.66 224.75,87.66 224.49,87.92 224.49,88.43 224,88.92 224,89.72 224.16,89.88 226.06,89.88
GND on BOTTOM (solid shape): 256.89,57.93 256.89,56.87 256.9,56.87 256.9,50.18 256.68,49.96 254.94,49.96 254.79,50.11 254.79,52.11 254.38,52.52 253.48,52.52 253.28,52.72 253.28,54.4 254.31,55.42 254.31,57.75 254.79,58.23 256.59,58.23
GND on BOTTOM (solid shape): 282.39,111.12 213.82,111.12 213.82,114.17 279.34,114.17 279.34,187.45 196.03,187.45 196.03,170.43 119.07,170.43 119.07,114.17 183.75,114.17 183.75,111.12 116.02,111.12 116.02,173.48 192.98,173.48 192.98,190.5 282.39,190.5
GND on BOTTOM (solid shape): 294.03,90.25 295.86,90.25 296.33,89.78 296.33,88.47 296.22,88.37 293.52,88.37 293.08,88.81 293.08,89.3 292.9,89.48 292.9,90.33 292.96,90.39 293.89,90.39
GND on BOTTOM (solid shape): 296.7,70.65 296.7,67.74 296.45,67.5 295.66,67.5 294.44,68.71 293.81,68.71 293.65,68.78 293.39,69.04 293.39,70.86 296.49,70.86
GND on BOTTOM (solid shape): 49.14,92.36 49.14,89.51 48.69,89.07 46.43,89.07 46.21,89.29 46.21,89.45 46.21,93.1 46.31,93.21 48.29,93.21
GND on BOTTOM (solid shape): 147.69,49.95 147.87,49.77 147.87,48.37 147.44,47.94 144.89,47.94 144.39,48.44 144.39,49.27 144.51,49.39 145.18,49.39 145.53,49.74 145.92,49.74 146.13,49.95 147.15,49.95
GND on BOTTOM (solid shape): 190.21,75.83 190.21,71.71 190.53,71.39 190.71,71.39 190.84,71.25 190.84,70.87 190.57,70.6 186.94,70.6 186.62,70.92 186.62,73.5 186.71,73.59 186.71,75.85 186.71,75.86 186.73,75.88 186.78,75.94 190.1,75.94
GND on BOTTOM (solid shape): 208.2,101.58 208.2,100.46 205.9,98.15 204.76,98.15 204.33,98.58 204.33,99.21 205.34,100.22 205.34,101.56 205.45,101.67 208.11,101.67
GND on BOTTOM (solid shape): 245.09,46.69 245.09,46.49 244.61,46.01 244.61,45.92 244.49,45.8 244.13,45.8 244.06,45.87 244.06,46.22 244.07,46.23 243.9,46.39 243.27,46.39 243.24,46.43 243.24,46.68 243.25,46.69 243.86,46.69 244.02,46.84 244.94,46.84
GND on BOTTOM (solid shape): 275.3,89.54 275.86,89.54 275.97,89.42 275.97,88.77 275.17,87.97 273.45,87.97 273.32,88.1 273.32,88.42 273.32,88.45 273.31,88.48 273.31,88.61 272.96,88.96 272.96,89.78 273.05,89.88 274.96,89.88
GND on BOTTOM (solid shape): 158.52,54.06 158.52,52.57 158.78,52.31 159.36,52.31 159.46,52.21 159.46,46.27 158.83,45.63 154.79,45.63 154.28,46.14 154.28,47.61 154.84,48.17 154.84,50.33 154.69,50.48 154.08,50.48 154,50.56 154,54.12 154.1,54.22 158.37,54.22
GND on BOTTOM (solid shape): 166.13,42.08 166.13,40.69 166.45,40.37 171.68,40.37 173.13,41.82 176,41.82 176.2,41.62 176.2,38.77 175.69,38.27 164.13,38.27 163.58,38.81 163.58,41.94 164.09,42.45 165.77,42.45
GND on BOTTOM (solid shape): 283.81,121.83 283.81,120.84 284.1,120.55 284.49,120.55 284.67,120.38 284.67,120.09 284.42,119.84 284.42,119.35 284.23,119.16 283.17,119.16 282.71,119.61 282.71,121.78 282.89,121.95 283.68,121.95
GND on BOTTOM (solid shape): 44.99,40.5 44.99,38.51 44.84,38.36 43.57,38.36 43.54,38.39 43.54,38.4 43.46,38.5 43.36,38.58 43.35,38.58 43.06,38.87 43.06,38.99 42.65,39.41 42.65,40.3 43.03,40.68 44.81,40.68
GND on BOTTOM (solid shape): 228.91,80.25 228.91,78.23 228.43,77.75 227.93,77.75 227.89,77.79 227.89,79.21 227.74,79.36 227.74,79.88 227.74,79.89 227.79,79.97 227.8,80.04 227.8,80.26 227.92,80.38 228.78,80.38
GND on BOTTOM (solid shape): 257.06,215.16 257.06,214.63 256.75,214.32 255.9,214.32 255.45,213.87 254.93,213.87 254.85,213.78 254.51,213.78 254.44,213.85 254.44,214.27 254.47,214.3 255.32,214.3 255.51,214.49 255.51,215.22 255.52,215.23 256.99,215.23
GND on BOTTOM (solid shape): 293.16,122.54 293.16,120.39 293.47,120.08 293.47,119.45 293.14,119.11 292.43,119.11 291.71,119.11 291.47,119.36 291.47,120.8 291.18,121.09 291.18,121.51 291.25,121.57 291.25,122.32 291.18,122.39 291.18,122.84 291.23,122.89 292.82,122.89
GND on BOTTOM (solid shape): 224.01,56.21 224.4,56.21 224.72,55.89 228.89,55.89 229.01,55.77 229.01,54.78 228.88,54.65 227.41,54.65 226.97,55.09 224.34,55.09 223.91,55.52 223.83,55.52 223.69,55.67 223.69,55.9 223.64,55.94 223.64,56.11 223.55,56.2 223.55,56.31 223.63,56.39 223.83,56.39
GND on BOTTOM (solid shape): 229.02,213.93 229.02,213.44 229.21,213.26 230.52,213.26 230.52,213.25 231.02,213.25 231.2,213.07 231.2,212.28 231.39,212.09 231.39,210.27 231.13,210.01 230.74,210.01 230.73,210.02 230.41,210.02 230.4,210.01 228.07,210.01 227.72,210.36 227.72,213.87 227.9,214.05 228.91,214.05
GND on BOTTOM (solid shape): 231.88,37.95 231.88,37.34 232.31,36.91 234.22,36.91 234.41,36.72 234.41,36.34 234.13,36.06 226.12,36.06 226.06,36.12 226.06,37.49 226,37.55 226,38.18 226.01,38.21 226.05,38.23 227.14,38.23 227.15,38.24 231.6,38.24
GND on BOTTOM (solid shape): 253.35,120.89 253.35,118.85 253.49,118.71 253.49,118.26 253.42,118.19 252.76,118.19 252.69,118.12 252.46,118.12 252.33,118.25 252.33,118.65 252.58,118.9 252.58,119.43 252.17,119.84 252.17,120.93 252.23,120.99 253.25,120.99
GND on BOTTOM (solid shape): 294.83,104.5 294.83,104.22 295.1,103.96 295.1,103.5 295.53,103.06 295.53,102.53 295.48,102.48 294.82,102.48 294.73,102.57 294.73,103.45 294.6,103.58 294.59,103.63 294.59,103.75 294.01,104.33 294.01,104.64 294.14,104.77 294.56,104.77
GND on BOTTOM (solid shape): 110.34,49.64 110.34,49.11 110.31,49.03 110.3,48.95 110.31,48.87 110.34,48.78 110.34,47.94 110.02,47.63 109.29,47.63 108.49,48.42 107.3,48.42 107.2,48.53 107.2,49.66 107.29,49.75 110.22,49.75
GND on BOTTOM (solid shape): 280.53,203.32 280.53,203.32 283.72,203.32 283.8,203.25 283.8,202.93 283.63,202.75 281.78,202.75 281.56,202.98 280.93,202.98 280.68,202.73 280.68,200.14 280.52,199.98 280.14,199.98 279.95,200.17 279.95,202.71 279.47,203.19 279.47,203.46 279.63,203.62 280.23,203.62
GND on BOTTOM (solid shape): 251.31,121.35 251.31,121.12 251.09,120.89 251.09,120.44 250.97,120.33 250.97,119.61 250.97,119.61 250.76,119.61 250.76,119.97 250.77,119.98 250.77,120.54 250.86,120.63 250.86,120.95 250.87,120.97 250.79,121.04 250.79,121.28 250.82,121.31 250.82,121.42 250.88,121.42 250.96,121.51 251.16,121.51
GND on BOTTOM (solid shape): 288.01,50.43 288.01,47.89 287.76,47.64 284.53,47.64 284.52,47.65 283.63,47.65 283.49,47.79 283.49,48.12 283.85,48.48 283.85,49.67 283.49,50.03 282.04,50.03 281.51,49.49 281.51,48.5 281.26,48.25 279.91,48.25 279.79,48.37 279.79,48.89 279.78,48.89 279.78,50.28 280.42,50.92 287.53,50.92
GND on BOTTOM (solid shape): 51.62,51.73 51.62,50.71 50.96,50.05 48.09,50.05 47.85,49.82 47.85,46.52 47.71,46.38 46.76,46.38 46.73,46.41 46.73,46.96 46.68,47.01 46.68,47.1 46.23,47.55 46.23,50.16 46.47,50.39 46.48,50.39 46.57,50.43 46.65,50.49 48.21,52.06 51.29,52.06
GND on BOTTOM (solid shape): 98.78,55.94 98.78,55.58 98.75,55.55 98.75,55.55 98.75,52.96 98.63,52.85 98.32,52.85 97.74,53.42 97.74,53.92 97.81,54.14 97.74,54.36 97.74,54.98 97.31,55.41 97.31,56.05 97.39,56.12 98.61,56.12
GND on BOTTOM (solid shape): 125.83,52.24 125.83,49.65 125.78,49.59 125.67,49.59 125.58,49.62 125.5,49.62 125.43,49.62 125.34,49.59 124.97,49.59 124.77,49.39 124.77,48.27 124.49,47.99 121.26,47.99 121.08,48.17 121.08,52.26 121.14,52.31 125.76,52.31
GND on BOTTOM (solid shape): 246.49,39.14 248.81,39.14 248.92,39.03 248.92,38.6 248.71,38.39 246.19,38.39 246.03,38.55 244.41,38.55 243.7,39.25 243.4,39.25 243.32,39.32 243.32,40.18 243.03,40.47 242.56,40.47 242.48,40.55 242.48,40.7 242.66,40.88 244.76,40.88
GND on BOTTOM (solid shape): 255.53,89.75 255.53,88.72 255.77,88.48 256.1,88.48 256.29,88.29 256.28,88.29 256.28,87.88 256.19,87.78 253.94,87.78 253.66,88.06 253.66,88.43 253.63,88.46 253.63,88.47 253.6,88.52 253.55,88.55 253.54,88.55 253.42,88.67 253.42,89.8 253.5,89.88 255.4,89.88
GND on BOTTOM (solid shape): 265.31,89.75 265.31,88.61 265.51,88.41 265.97,88.41 266.07,88.3 266.06,88.29 266.06,87.88 265.97,87.78 263.79,87.78 263.62,87.96 263.62,88.32 263.54,88.39 263.5,88.47 263.43,88.51 263.02,88.91 263.02,89.62 263.27,89.88 265.18,89.88
GND on BOTTOM (solid shape): 111.43,95.44 111.43,92.83 111.2,92.6 107.62,92.6 107.35,92.87 110.38,92.87 110.38,93.09 108.83,93.09 108.83,92.87 107.35,92.87 107.11,93.11 107.11,93.37 110.38,93.37 110.38,93.59 108.83,93.59 108.83,93.37 107.11,93.37 107.11,95.48 107.01,95.58 107.01,95.59 107.19,95.77 111.1,95.77
GND on BOTTOM (solid shape): 120.41,43.41 120.43,43.41 120.45,43.39 120.48,43.36 120.52,43.33 120.53,43.31 120.54,43.29 120.54,42.41 120.28,42.15 120.28,41.87 120.23,41.83 120.23,41.43 120.28,41.39 120.28,41.31 120.18,41.21 118.76,41.21 118.67,41.3 118.67,42.07 119.32,42.71 119.32,43.34 119.39,43.41
GND on BOTTOM (solid shape): 135.28,45.86 135.28,42.56 135.96,41.89 140.97,41.89 142.21,40.65 147.3,40.65 147.68,40.27 147.68,38.9 147.38,38.6 140.06,38.61 138.87,38.61 137.72,37.45 136.69,37.45 135.54,38.61 131.52,38.61 131.17,38.95 131.17,40.4 131.98,41.21 131.98,45.78 132.21,46.01 135.13,46.01
GND on BOTTOM (solid shape): 203.91,83.63 203.95,83.59 204.04,83.5 204.08,83.5 204.14,83.49 204.2,83.48 204.26,83.49 204.33,83.5 204.42,83.5 204.52,83.4 204.52,83.15 204.45,83.07 202.59,83.07 202.49,83.17 202.49,83.78 202.72,84.01 203.53,84.01
