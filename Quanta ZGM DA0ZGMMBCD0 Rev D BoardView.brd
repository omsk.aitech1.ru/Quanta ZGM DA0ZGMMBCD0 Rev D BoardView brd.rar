# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBD_CMD49: length 14.9
  BOTTOM w0.165: VRAM5.K12 268.49,156.83 268.49,155.44 268.37,155.32 268.37,154.78 267.85,154.26 266.31,154.26 265.88,153.83 259.52,153.83 259.29,153.6 257.07,153.6 UG6.V1
FBD_CMD50: length 20
  IN4 w0.102: v2(257.28,152.86) 257.72,152.42 267.62,152.42 270.01,154.81 270.01,155.38 269.63,155.76 269.63,156.43 v2(269.25,156.81)
  BOTTOM w0.102: v2(257.28,152.86) 256.63,152.86 256.42,153.07 256.42,153.37 256.25,153.53 254.96,153.53 UG6.W4 ; VRAM5.L12 268.88,157.17 269.24,156.81 v2(269.25,156.81)
FBD_CMD51: length 18.5
  IN2 w0.114: v2(267.75,158.34) 267.76,158.34 267.79,158.31 267.8,158.31 268.72,157.39 268.72,155.86 269.48,155.11 v2(269.62,155.11)
  BOTTOM w0.102: v2(267.75,158.34) 267.76,158.34 268.13,157.97 VRAM5.K11
  BOTTOM w0.165: UG6.W1 256.8,153.27 259.51,153.27 259.68,153.44 266.52,153.44 266.73,153.23 267.74,153.23 v2(269.62,155.11)
FBD_CMD52: length 17.9
  IN4 w0.102: v2(269.25,158.35) 268.83,157.93 268.83,155.76 269.24,155.35 269.24,154.94 267.14,152.84 v2(258.48,152.84)
  BOTTOM w0.102: VRAM5.M11 269.63,158 269.27,158.35 v2(269.25,158.35) ; UG6.Y1 256.88,152.39 258.02,152.39 v2(258.48,152.84)
FBD_DBI0: length 14.7
  IN2 w0.102: v2(252.25,143.7) 252.25,143.67 253.94,141.99 254.08,141.99 255.06,141.01 256.89,141.01 257.11,140.79 258.71,140.79 259.38,140.12 262.7,140.12 262.96,140.38 262.96,140.88 263.26,141.18 v2(263.26,141.55)
  BOTTOM w0.102: v2(252.25,143.7) 252.55,144 UG6.AM7 ; VRAM7.R2 263.6,141.95 263.26,141.61 v2(263.26,141.55)
FBD_DBI1: length 23.7
  IN1 w0.102: v2(252.35,139.39) 252.78,139.82 254.12,139.82 254.37,139.57 256.7,139.57 257.01,139.27 259.31,139.27 ; v2(272.25,142.31) 271.88,141.93 271.88,140.25 271.86,140.23
  IN1 w0.127: 271.86,140.23 271.23,139.61 267.74,139.61 267.4,139.27 259.31,139.27
  BOTTOM w0.161: VRAM7.D2 271.89,141.95 v2(272.25,142.31) ; v2(252.35,139.39) 252.35,139.72 UG6.AV7
FBD_DBI2: length 14.8
  IN2 w0.102: v2(263.27,149.82) 263.27,148.46 262.71,147.89 262.27,147.89 261.83,147.46 261.83,147.11 261.58,146.86 256.83,146.86 256.73,146.96 253.06,146.96 v2(252.34,147.68)
  BOTTOM w0.102: v2(263.27,149.82) 263.27,149.84 VRAM7.R13
  BOTTOM w0.161: UG6.AF7 252.32,148.09 252.32,147.7 v2(252.34,147.68)
FBD_DBI3: length 22.9
  IN1 w0.102: v2(252.23,145.86) 252.53,146.17 254.49,146.17 255.28,146.96 259,146.96 260.72,148.68 265.8,148.68 265.81,148.68 270.21,148.68 270.38,148.86 270.38,149.25 270.59,149.46 271.9,149.46 v2(272.24,149.8)
  BOTTOM w0.102: v2(272.24,149.8) 272.24,149.83 VRAM7.D13 ; UG6.AJ7 252.55,146.19 v2(252.23,145.86)
FBD_DBI4: length 29.2
  IN1 w0.102: v2(252.2,157.78) 252.48,157.49 252.93,157.49 253.26,157.83 253.26,158.04 253.46,158.24 253.92,158.24 256.8,161.13 256.8,161.71 257.09,161.99 257.53,161.99 257.91,162.37 258.66,162.37 258.85,162.57 258.85,164.94 260.62,166.71 267.74,166.71 268.06,166.38 270.83,166.38 271.06,166.15 271.06,165.68 271.25,165.49 271.67,165.49 271.87,165.29 271.87,164.68 v2(272.23,164.32)
  BOTTOM w0.102: v2(252.2,157.78) 252.2,157.08 UG6.P7 ; VRAM5.R2 271.88,164.68 v2(272.23,164.32)
FBD_DBI5: length 16.5
  IN2 w0.102: v2(252.2,159.17) 252.65,159.62 255.28,159.62 255.75,160.09 256.53,160.09 256.8,160.35 256.8,160.69 257.06,160.96 257.36,160.96 257.6,161.2 257.6,161.82 258.08,162.3 258.08,162.95 260.65,165.52 262.7,165.52 263.23,164.98 v2(263.23,164.33)
  BOTTOM w0.102: VRAM5.D2 263.6,164.7 v2(263.23,164.33) ; v2(252.2,159.17) 252.55,158.82 UG6.L7
FBD_DBI6: length 27.3
  IN1 w0.102: v2(251.5,152.18) 251.52,152.18 252.89,153.56 256.06,153.56 256.74,154.23 258.66,154.23 259.91,155.49 259.91,156.49 260.67,157.24 261.12,157.24 261.38,157.5 261.38,157.8 262.33,158.76 271.27,158.76 271.88,158.14 271.88,157.2 v2(272.25,156.82)
  BOTTOM w0.102: UG6.Y7 252.21,152.18 v2(251.5,152.18) ; VRAM5.R13 v2(272.25,156.82)
FBD_DBI7: length 17.1
  IN2 w0.102: v2(252.25,154.2) 252.25,154.14 252.64,153.75 252.64,153.24 252.46,153.06 252.46,152.61 252.66,152.42 255.27,152.42 255.9,151.79 259.01,151.79 260.15,152.93 261.82,152.93 263.65,154.76 263.65,155.66 263.26,156.05 v2(263.25,156.05)
  BOTTOM w0.102: v2(263.25,156.05) 263.63,156.42 VRAM5.D13 ; v2(252.25,154.2) 252.25,154.32 UG6.U7
FBD_EDC0: length 9.6
  IN2 w0.102: v2(262.51,142.31) 262.12,142.7 262.12,143.3 261.94,143.47 256.37,143.47 256.22,143.32 255.4,143.32 v2(255.1,143.62)
  BOTTOM w0.102: v2(255.1,143.62) 254.65,144.07 UG6.AM4 ; VRAM7.T2 v2(262.51,142.31)
FBD_EDC1: length 21.3
  IN1 w0.127: v2(255.2,139.19) 255.7,138.68 267.64,138.68 267.98,139.02 271.47,139.02 272.81,140.36 272.81,141.4 v2(272.99,141.58)
  BOTTOM w0.102: VRAM7.C2 v2(272.99,141.58)
  BOTTOM w0.161: v2(255.2,139.19) 255.13,139.26 255.13,139.45 UG6.AV4
FBD_EDC2: length 11.6
  IN2 w0.102: v2(255.07,147.88) 255.45,147.5 256.06,147.5 256.5,147.93 257.04,147.93 257.22,148.12 260.15,148.12 260.71,148.68 262.7,148.68 262.88,148.86 262.88,150.22 v2(262.5,150.6)
  BOTTOM w0.102: v2(255.07,147.88) 255.07,147.9 UG6.AF4 ; v2(262.5,150.6) 262.5,150.57 VRAM7.T13
FBD_EDC3: length 22.4
  IN1 w0.102: v2(273,150.56) 272.63,150.18 272.63,148.89 271.68,147.94 270.87,147.94 270.47,147.54 270.47,147.1 270.04,146.68 259.98,146.68 259.49,146.18 257.38,146.18 256.61,145.41 255.43,145.41 v2(255.06,145.78)
  BOTTOM w0.102: UG6.AJ4 254.65,146.19 v2(255.06,145.78) ; v2(273,150.56) 272.64,150.2 VRAM7.C13
FBD_EDC4: length 26
  IN1 w0.102: v2(255.14,156.04) 255.93,156.04 256.27,156.38 256.76,156.38 257.43,157.04 257.43,157.98 257.73,158.28 258.9,158.28 259.75,159.13 259.75,159.93 260.61,160.78 260.61,163.01 260.78,163.19 271.76,163.19 271.87,163.3 271.87,163.75 272.05,163.94 272.5,163.94 272.62,164.06 272.62,164.69 v2(272.99,165.07)
  BOTTOM w0.102: v2(272.99,165.07) 272.63,164.7 VRAM5.T2
  BOTTOM w0.161: v2(255.14,156.04) 254.65,156.53 UG6.P4
FBD_EDC5: length 13.9
  IN2 w0.102: v2(255.14,158.12) 255.33,157.93 256.39,157.93 257.18,158.73 257.18,159.27 257.5,159.59 258.76,159.59 259.87,160.7 259.87,162.23 260.82,163.18 262,163.18 262.13,163.31 262.13,163.41 262.14,163.41 262.14,163.73 262.13,163.73 262.13,164.18 262.14,164.18 262.14,164.5 262.13,164.5 262.13,164.73 v2(262.5,165.1)
  BOTTOM w0.102: v2(255.14,158.12) 254.65,158.61 UG6.L4
  BOTTOM w0.161: VRAM5.C2 262.88,164.72 v2(262.5,165.1)
FBD_EDC6: length 22.5
  IN1 w0.102: v2(255.19,151.78) 255.48,151.78 256.97,153.26 258.74,153.26 261.13,155.64 266.43,155.64 266.82,156.03 266.82,156.48 267.54,157.2 271.02,157.2 271.13,157.08 271.13,156.67 271.37,156.43 272.62,156.43 v2(272.98,156.07)
  BOTTOM w0.102: VRAM5.T13 272.63,156.42 v2(272.98,156.07) ; v2(255.19,151.78) 255.19,151.98 UG6.Y4
FBD_EDC7: length 10.9
  IN2 w0.102: v2(255.15,153.94) 255.37,153.71 259.09,153.71 260.38,155 260.38,156.17 260.65,156.44 262.1,156.44 v2(262.5,156.83)
  BOTTOM w0.102: v2(255.15,153.94) 254.65,154.43 UG6.U4 ; v2(262.5,156.83) 262.5,156.82 262.51,156.82 262.88,156.46 VRAM5.C13
FBD_VREFC: length 1.8
  TOP w0.203: v2(267.02,140.45) 267.14,140.45 267.56,140.02 RG42.1
  BOTTOM w0.102: VRAM7.K1 267.02,140.84 v2(267.02,140.45)
FBD_VREFC_H: length 3
  BOTTOM w0.165: VRAM5.K1 268.13,167.8 267.73,168.2 RG110.1
FBD_ZQ_1_A: length 1.2
  TOP w0.203: v2(268.2,151.54) 268.25,151.59 RG33.1
  BOTTOM w0.254: v2(268.2,151.54) 268.13,151.47 VRAM7.J14
FBD_ZQ_1_B: length 1.1
  TOP w0.203: v2(267.48,151.56) 267.48,151.57 RG32.1
  BOTTOM w0.254: VRAM7.K14 267.38,151.46 v2(267.48,151.56)
FBD_ZQ_2_A: length 1.6
  TOP w0.14: RG26.1 267.35,154.42 267.21,154.56 v2(267.21,154.94)
  BOTTOM w0.102: v2(267.21,154.94) 267.38,155.11 VRAM5.J14
FBD_ZQ_2_B: length 1.7
  TOP w0.14: v2(267.78,155.13) 267.78,154.81 268.17,154.42 RG27.1
  BOTTOM w0.102: v2(267.78,155.13) 268.13,155.48 VRAM5.K14
FBVDD_EN: length 170.1
  TOP w0.14: v1(234.83,115.38) 234.5,115.38 234.33,115.21 UG2.4 ; v1(212.46,124.23) 212.46,124.28 211.99,124.75 209.58,124.75 209.33,124.51 v1(209.33,124.22)
  TOP w0.203: v1(235.37,208.55) 235.37,209.08 235.57,209.28 v1(236.55,209.28) 236.76,209.08 245.34,209.08 245.85,209.59 246.36,209.59 247.05,210.28 PR50.2
  IN2 w0.089: v1(234.83,115.38) 234.42,115.38 233.95,115.85 232.58,115.85 232.25,115.53 231.65,115.53 230.74,116.43 230.74,118.29 223.86,125.16 223.07,125.16 222.48,124.57 218.58,124.57 218.24,124.23 v1(212.46,124.23) ; v1(209.33,124.22) 208.4,125.16 204.63,125.16 204.19,125.59 200.23,125.59 194.63,131.19 194.63,147.69 197.89,150.95 197.89,156.55 198.15,156.81 198.15,163.65 199.35,164.85 199.35,166.9 200.95,168.5 201.67,168.5 205.17,172.01 207.59,172.01 209.87,174.28 209.87,178.96 209.28,179.55 209.28,183.2 211.57,185.49 213.55,185.49 215.18,187.11 215.42,187.11 216.08,186.45 217.27,186.45 v1(217.55,186.73)
  IN3 w0.089: v1(217.55,186.73) 218.61,187.78 228.31,187.78 230.21,189.69 230.21,190.06 230.81,190.66 230.81,191.57 231.12,191.87 231.56,191.87 233.11,193.42 233.11,196.6 233.86,197.35 233.86,203.55 235.79,205.47 235.79,208.27 235.56,208.5 235.39,208.5 235.37,208.52 v1(235.37,208.55)
FBVDD_PSI: length 148.2
  TOP w0.14: v1(245.11,212.43) 245.47,212.79 v1(245.75,212.79)
  IN2 w0.089: v1(267.62,132.37) 267.76,132.51 268.64,132.51 268.83,132.32 273.3,132.32 276.9,135.93 276.9,136.18 277.56,136.83 277.81,136.83 279.84,138.87 279.84,152.38 281.18,153.72 281.18,165.24 284.19,168.26 284.19,170.44 283.84,170.8 283.34,170.8 275.07,179.07 275.07,185.36 276.13,186.42 276.13,188.32 275.55,188.9 274.93,188.9 273.73,190.1 273.73,191.99 273.92,192.18 274.74,192.18 275.23,192.68 277.34,192.68 277.54,192.88 278.47,192.88 279.29,193.69 279.29,196.06 278.59,196.75 278.36,196.99 275.87,196.99 274.39,198.47 274.39,199.57 271.05,202.91 271.05,203.39 266.78,207.66 266.78,212.31 266.17,212.92 265.03,212.92 263.98,213.98 262.56,213.98 261.99,214.55 260.7,214.55 260.38,214.86 257.79,214.86 255.9,216.74 254.09,216.74 253.37,216.02 251.66,216.02 251.05,215.41 249.1,215.41 248.45,214.77 247.17,214.77 246.64,214.24 246.64,213.32 246.1,212.79 v1(245.75,212.79)
  BOTTOM w0.102: UG6.BG3 255.68,133.29 256.57,133.29 256.62,133.24 256.87,133.24 256.92,133.19 258.12,133.19 258.97,134.04
  BOTTOM w0.14: 258.97,134.04 259.44,134.51 261.17,134.51 261.91,133.77 263.68,133.77 RG126.1 RG127.1 266.35,132.27 266.59,132.51 267.48,132.51 v1(267.62,132.37)
  BOTTOM w0.203: PR382.2 245.85,212.79 v1(245.75,212.79)
FBVDDQ_SENSE: length 44.6
  TOP w0.127: PR113.1 233.45,186.8 v1(233.05,186.4) 231.97,185.32 227.48,185.32 227.24,185.56 224.3,185.56 223.94,185.92 217.56,185.92 217.34,185.7 216,185.7 214.46,184.16 214.46,174.26 214.77,173.95 214.77,172.73 215.38,172.12 215.38,169.88 219.01,166.25 219.01,164.34 v2(219.98,163.37)
  BOTTOM w0.102: UG6.E54 219.65,163.04 v2(219.98,163.37)
FLIP_DP: length 3.1
  BOTTOM w0.178: U56.21 24.55,24.48 24.72,24.65 24.72,25.55 25,25.83 R1180.2 25.95,25.83 R1179.2
FRM_LCK#: length 117.8
  IN2 w0.089: v1(282.54,198.57) 282.54,198.29 281.83,197.58 281.83,196.22 281.37,195.76 281.37,188.61 280.57,187.81 280.57,181.78 279.68,180.88 278.24,180.88 277.48,180.12 277.48,178.47 283.87,172.08 284.37,172.08 285.48,170.97 285.48,167.61 283.15,165.28 283.15,153.88 281.13,151.85 281.13,138.34 278.82,136.03 278.82,132.23 278.23,131.64 278.23,129.98 277.5,129.26 274.75,129.26 273.83,130.18 265.53,130.18 264.28,128.93 261.63,128.93 258.91,126.22 v1(258.91,125.32) 260.94,123.29 260.94,121.3 260.96,121.28 260.96,119.26 259.91,118.21 v1(259.76,118.21)
  BOTTOM w0.102: v1(258.91,125.32) 258.73,125.51 258.45,125.51 257.84,126.11 257.84,129.46 257.26,130.04 256.87,130.44 256.37,130.44 UG6.BM2
  BOTTOM w0.14: v1(282.54,198.57) 282.27,198.29 Q82.1 ; RG176.1 259.82,117.58 259.82,118.15 v1(259.76,118.21)
FVDDQ_SENSE_I: length 15.2
  TOP w0.14: PR79.2 228.34,206.81 228.23,206.7 v1(228.23,206.63)
  BOTTOM w0.14: v1(228.23,206.63) 228.2,206.63 226.53,204.97 226.53,203.69 227.59,202.63 231.85,202.63 233.24,201.24 233.24,199.52 232.83,199.11 232.4,199.11 232.25,199.26 PR435.1
FVDDQ_SENSE_V: length 24.5
  TOP w0.14: PR47.2 233.81,211.42 233.99,211.24 v1(233.99,210.86) ; PR74.1 229.95,207.81 229.77,207.63 PR82.2 229.77,206.66 229.91,206.52 v1(229.92,206.52)
  BOTTOM w0.14: v1(233.99,210.86) 233.99,210.58 v1(229.92,206.52) 229.49,206.08 228.03,206.08 226.8,204.86 226.8,203.8 227.7,202.9 231.96,202.9 233.5,201.35 233.5,199.41 232.94,198.84 232.37,198.84 PR444.1
G_CTL: length 721.3
  TOP w0.254: R278.1 300.79,80.51 300.82,80.48 Q34.2 300.82,79.34 300.59,79.11 299.06,79.11 298.88,78.93 298.88,77.2 v1(299.04,77.05) ; v1(251.48,213.12) R26.1 251.91,213.9 251.6,214.21 Q4.2 ; Q65.2 44.11,36.7 44.14,36.68 R652.1 45.72,36.68 v1(45.96,36.92)
  IN2 w0.254: v1(248.95,216.28) 248.83,216.16 248.21,216.16 247.9,216.47 247.32,216.47 246.08,215.23 246.08,213.55 245.82,213.3 245.49,213.3 245.26,213.06 245.26,211.91 246,211.16 246,210.28 243.55,207.82 241.82,207.82 241.12,207.13 237.26,207.13 236.35,208.04 236.35,208.83 235.94,209.23 234.35,209.23 234.32,209.27 232.4,209.27 231.7,209.97 228.7,209.97 227.81,209.08 223.7,209.08 222.02,207.4 222.02,205.35 221.54,204.87 220.16,204.87 219.59,205.45 213.18,205.45 212.6,204.87 202.74,204.87 202.22,205.38 202.22,206.04 199.85,208.42 195.51,208.42 193.91,206.82 193.91,205.71 192.94,204.75 189.3,204.75 189.07,204.98 185.56,204.98 184.92,204.33 176.08,204.33 176,204.26 174.48,204.26 172.6,206.14 172.6,216.83 171.4,218.02 167.49,218.02 166.8,217.33 165.91,217.33 164.37,215.79 163.48,215.79 162.77,215.08 162.77,212.64 157.58,207.46 v1(151.23,207.46) ; v1(299.04,77.05) 298.55,76.56 297.4,76.56 297.16,76.8 295.53,76.8 293.62,74.89 287.6,74.89 286.88,74.18 286.88,71.83 285.77,70.72 285.77,70.15 283.32,67.7 283.32,64.1 284.48,62.94 284.48,62.11 285.65,60.95 285.65,57.98 282.44,54.78 282.44,53.98 281.29,52.83 278.96,52.83 274.71,48.57 271.68,48.57 269.1,45.99 269.1,45.53 267.01,43.44 261.89,43.44 261.6,43.73 259.79,43.73 259.03,42.97 259.03,40.22 255.39,36.59 250.22,36.59 248.88,37.94 247.32,37.94 246.55,38.71 246.55,39.13 245.36,40.32 245.36,44.89 244.85,45.4 243.98,45.4 242.24,43.66 241.37,43.66 240.2,44.83 238.19,44.83 237.89,45.12 229.85,45.12 229.14,44.42 229.14,43.08 227.29,41.24 221,41.24 219.54,39.78 209.63,39.78 209.35,40.06 206.08,40.06 206.04,40.11 202.46,40.11 201.99,40.58 190.97,40.58 188.94,42.61 188.05,42.61 185.86,44.8 184.16,44.8 180.49,48.47 180.49,50.14 177.61,53.02 174.48,53.02 172.88,54.62 171.26,54.62 169.54,56.34 166.06,56.34 164.99,57.41 164.5,57.41 162.76,59.15 160.86,59.15 158.27,61.74 157.91,61.74 157.6,62.04 150.49,62.04 149.6,61.15 145.29,61.15 145.16,61.01 133.42,61.01 132.76,60.35 124.36,60.35 123.07,59.06 119.89,59.06 118.75,57.92 117.2,57.92 115.89,56.61 113.21,56.61 111.13,54.53 103.71,54.53 101.01,51.82 94.21,51.82 89.71,47.32 89.71,44.8 85.93,41.01 72.79,41.01 71.72,42.08 70.96,42.08 69.99,43.04 60.24,43.04 56.62,46.66 48.25,46.66 46.19,44.61 46.19,37.15 v1(45.96,36.92)
  IN3 w0.254: v1(285.32,113.73) 282.79,116.26 282.7,116.26 282.02,116.93 282.02,151.42 285.33,154.73 285.33,172.08 285.9,172.65 285.9,183.15 285.31,183.74 285.31,185.38 285.9,185.97 285.9,190.48 285.83,190.55 285.83,199.54 283.95,201.43 283.95,204.16 283.48,204.63 283.48,208.72 281.78,210.41 279.75,210.41 278.51,211.65 277.35,211.65 276.92,212.08 276.92,213.3 276.56,213.66 276.56,215.51 276.22,215.85 273.87,215.85 272.96,216.77 272.7,216.77 272.2,217.27 267.08,217.27 266.86,217.49 265.91,217.49 265.14,216.72 264.88,216.72 263.36,215.19 260.23,215.19 259.99,214.95 258.45,214.95 257.91,215.49 257.91,216.38 257.26,217.03 253.09,217.03 251.39,215.34 249.41,215.34 248.95,215.79 v1(248.95,216.28) ; v1(138.88,216.43) 138.89,216.42 138.89,216.32 139.35,215.86 139.35,214.21 145.38,208.18 150.51,208.18 v1(151.23,207.46)
  IN4 w0.254: v1(299.04,77.05) 299.5,77.51 300.91,77.51 301.76,78.35 303.74,78.35 307.95,82.56 307.95,85.96 309.2,87.22 310.21,87.22 310.76,87.77 310.76,88.91 311.21,89.35 312.66,89.35 314.07,90.76 316.73,90.76 319.77,93.81 319.77,97.08 317.23,99.61 314.14,99.61 313.65,99.12 311.16,99.12 310.65,99.63 306.18,99.63 305.67,100.14 305.33,100.14 305.04,100.42 304.56,100.42 302.42,102.55 301.15,102.55 298.08,105.62 298.08,106.61 296.48,108.21 293.44,108.21 290.84,110.81 290.84,111.11 288.93,113.02 287.17,113.02 286.95,113.25 285.8,113.25 v1(285.32,113.73) ; v1(248.95,216.28) 248.98,216.28 249.88,215.38 250.85,215.38 252.67,217.2 253.58,217.2 253.83,216.95 253.83,215.47 v1(251.48,213.12)
  BOTTOM w0.254: v1(151.23,207.46) 151.42,207.27 R714.2 151.42,204.79 151.07,204.45 150.71,204.45 150.72,204.45 Q78.3 ; v1(138.88,216.43) 138.88,217.05 R681.1 138.74,217.09 138.2,216.55 Q73.2
G_CTL_LOGO: length 21.3
  TOP w0.14: v1(160.91,202.17) 160.91,201.56 162.15,200.32 R1216.1 162.94,199.84 163.45,199.33 165.08,199.33 165.28,199.53 Q126.2 ; v1(150.56,206.64) 150.11,206.19 U1.31
  IN2 w0.089: v1(150.56,206.64) 150.87,206.34 155.53,206.34 156.14,205.73 158.78,205.73 159.79,204.71 159.79,204.1 160.3,203.59 160.3,202.68 160.81,202.17 v1(160.91,202.17)
G_CTL_LOGO_C: length 131.7
  TOP w0.508: R1213.1 170.41,200.5 v1(172.71,202.79) 173.1,203.19 173.1,203.92 173.5,204.32 175.4,204.32 176.41,205.32 176.41,206.08 176.69,206.36 178.03,206.36 178.87,205.53 v1(179.3,205.53)
  IN3 w0.508: v1(265.26,192.32) 266.32,193.38 266.32,194.53 265.81,195.03 264.42,195.03 263.53,195.92 263.53,202.4 265.56,204.43 265.56,206.21 264.59,207.18 260.96,207.18 259.85,206.06 259.08,206.06 258.55,206.59 254.28,206.59 253.9,206.21 238.26,206.21 236.86,207.61 236.86,208.84 234.65,211.04 234.65,211.21 234.35,211.51 233.39,211.51 232.79,210.91 231.47,210.91 230.97,210.4 227.71,210.4 227.35,210.76 226.55,210.76 225.56,209.77 223.52,209.77 222.28,208.52 222.28,204.84 221.49,204.05 219.69,204.05 219.13,204.61 215.85,204.61 215.27,204.03 200.31,204.03 197.74,206.59 196.09,206.59 195.71,206.21 195.71,205.22 193.65,203.16 189.52,203.16 188.76,203.92 180.35,203.92 179.3,204.97 v1(179.3,205.53)
G_CTL_MCU: length 7.2
  TOP w0.203: U1.22 147.8,202.24 147.87,202.17
  TOP w0.254: 147.87,202.17 148.5,201.54 150.14,201.54 150.74,202.14 v1(153.65,202.14)
G_CTL_TURBO: length 2.1
  BOTTOM w0.254: v1(279.12,196.97) R725.1 277.65,196.97 277.63,196.94 Q81.2
G_CTL_TURBO_C: length 146.9
  TOP w0.203: U1.26 150.02,204.19
  TOP w0.254: 150.02,204.19 153.03,204.19 153.32,203.9 157.77,203.9 v1(158.16,204.28) ; v1(268.43,194.7) 268.11,195.02 267.53,195.02 267.5,195.05 CN1.14
  IN1 w0.254: v1(272.18,197.04) 271.73,196.58 271.22,196.58 270.56,195.92 268.76,195.92 268.33,195.49 268.33,194.81 v1(268.43,194.7) 268.25,194.7 267.39,195.57 264.75,195.57 263.73,194.55 263.73,193.35 260.87,190.49 251.1,190.49 250.46,191.12 241.64,191.12 240.96,190.45 237.43,190.45 237.16,190.18 223.76,190.18 223.12,190.82 219.66,190.82 219.22,190.38 212.26,190.38 211.19,189.32 208.67,189.32 206.74,191.25 200.93,191.25 199.85,190.17 192.18,190.17 187.04,195.31 181.99,195.31 181.56,195.74 179.79,195.74 177.09,198.44 176.11,198.44 173.66,200.89 173.66,202.82 172.29,204.19 172.29,205.19 170.74,206.73 170.74,207.89 169.87,208.76 161.16,208.76 158.16,205.76 v1(158.16,204.28)
  BOTTOM w0.254: v1(272.18,197.04) 272.18,197.06 272.83,197.71 R724.1
G_CTRL_LEFT: length 66.6
  TOP w0.508: R322.1 v1(303.1,76.8)
  IN3 w0.508: v1(261.12,49.97) 261.27,49.97 263.51,52.21 265.39,52.21 266.25,53.08 267.87,53.08 268.16,52.78 270.37,52.78 270.63,52.53 272.92,52.53 273.28,52.89 276.7,52.89 280.17,56.35 280.86,56.35 283.35,58.85 283.35,64.26 282.99,64.62 282.99,67.46 283.61,68.08 283.61,68.08 283.99,68.46 283.99,68.73 287.99,72.73 289.04,72.73 290.83,74.53 290.83,75.73 292.89,77.79 292.89,78.35 294.29,79.74 301.76,79.74 303.1,78.4 v1(303.1,76.8)
  BOTTOM w0.508: v1(261.61,49.48) v1(261.12,49.97) 260.9,50.19 CN14.3
G_CTRL_RIGHT: length 6.6
  TOP w0.508: v1(41.75,38.65) 41.75,38.47 41.24,37.96 40.89,37.96 40.26,37.33 40.26,35.36 R654.1
  BOTTOM w0.508: CN22.3 v1(41.75,38.65)
GC6FBEN: length 54.2
  TOP w0.14: v1(231.88,116.13) 233.4,117.64 235.26,117.64 235.63,117.27 UG2.1
  IN2 w0.089: v1(231.88,116.13) 231.99,116.23 234.82,116.23 235.46,115.6 235.46,114.94 235.67,114.73 242.47,114.73 244.75,117.01 244.75,118.19 244.38,118.57 244.38,118.99 244.86,119.47 245.29,119.47 245.63,119.81 246.29,119.81 247.19,118.9 249.46,118.9 250.51,117.84 252.85,117.84 253.25,117.44 256.07,117.44 256.42,117.8 256.42,118.3 256.33,118.39 v1(256.29,118.39) 255.93,118.02 255.09,118.02 254.67,118.44 254.67,119.33 255.06,119.71 255.06,121.43 256.85,123.22 256.85,128.44 256.45,128.84 255.93,128.84 v2(255.7,129.07)
  BOTTOM w0.102: v2(255.7,129.07) UG6.BN3
  BOTTOM w0.14: QG23.2 232.08,115.45 232.31,115.68 RG180.1 232.84,115.84 232.56,116.13 v1(231.88,116.13) ; QG21.5 256.31,118.37 v1(256.29,118.39)
GC6FBEN_Q: length 99.9
  IN3 w0.089: v1(199.81,54.48) 199.81,55.84 200.1,56.13 200.1,57.44 197.17,60.36 197.17,63.99 197.47,64.29 197.47,66.72 197.08,67.11 197.08,77 197.23,77.15 197.23,86.87 198.25,87.89 198.25,93.85 199.94,95.55 199.94,96.45 202.42,98.92 202.42,100.65 202.87,101.11 204.42,101.11 204.8,101.49 204.8,103.54 207.6,106.34 207.6,110.76 212.13,115.28 216.66,115.28 217.78,116.4 225.79,116.4 226.57,117.18 226.96,117.18 v1(227.08,117.06)
  BOTTOM w0.102: 203.35,53.25 203.42,53.32 204.17,53.32 204.98,54.13 205.78,54.13 206.45,54.81 206.81,54.81 207.08,55.08 207.08,55.55 207.08,55.56 207.08,56.59 U49.N46 ; v1(199.81,54.48) 199.75,54.41 199.75,53.25
  BOTTOM w0.14: QG22.3 227.08,116.82 v1(227.08,117.06) ; R1090.1 200.15,51.76 TP164.1 ; TP164.1 199.75,52.48 199.75,53.25 ; TP164.1 201.1,52.71 202.81,52.71 203.35,53.25
GEN2_MODE: length 3.1
  TOP w0.203: PR41.2 224.62,212.62 PR39.2 225.68,212.98 PU2.26
GFX_SCL: length 28.2
  TOP w0.14: RG100.1 v1(261.1,113.09) 261.37,113.36 261.56,113.36 261.8,113.6 QG11.4 261.8,114.25 261.13,114.92 261.13,115.52 260.73,115.93 v1(260.4,115.93)
  IN4 w0.086: v1(260.4,115.93) 259.81,115.93 259.56,115.68 258.78,115.68 258.3,116.16 254.69,116.16 254.37,116.48 254.37,117.49 253.88,117.98 253.58,118.28 253.58,118.78 252.99,119.37 252.49,119.37 252.1,119.76 252.1,121.75 250.54,123.3 250.54,127.05 251.31,127.81 251.31,129.59 v2(252.2,130.48)
  BOTTOM w0.102: UG6.BL8 251.86,130.82 252.2,130.49 v2(252.2,130.48)
GFX_SDA: length 23.1
  TOP w0.14: v1(263.16,116.77) 263.16,116.63 262.83,116.3 RG86.1 262.51,116.02 262.81,115.72 QG11.1
  IN4 w0.086: v1(263.16,116.77) 263.16,116.77 261.06,118.87 261.06,119.49 259.89,120.66 259.89,121.59 259.16,122.32 258.17,122.32 257.09,123.4 255.61,123.4 252.97,126.04 252.97,127.5 252.54,127.92 252.54,128.7 252.59,128.75 252.59,130.14 252.66,130.21 252.66,130.71 v2(252.2,131.17)
  BOTTOM w0.102: UG6.BL7 v2(252.2,131.17)
GPD_7: length 24.2
  TOP w0.14: v1(216.77,53.73) 217.02,53.73 217.4,54.11 218.46,54.11 219.71,52.86 225.74,52.86 226.53,53.65 226.53,54.42 225.92,55.03 223.68,55.03 222.04,56.67 R575.2
  BOTTOM w0.102: 217.03,53.25 216.76,53.53 216.76,53.72 v1(216.77,53.73) 216.76,53.73 216.41,54.08 216.41,54.62 216.13,54.9 216.13,55.93 216.06,56 216.06,56.59 U49.AL46
  BOTTOM w0.14: 217.03,53.25 218,52.28 R1073.1 218,52.16 217.69,52.16 217.66,52.14 R1079.2
GPIO14_IFPA_HPD_TBT: length 12.4
  TOP w0.102: v1(257.43,132.78) 255.17,132.78 254.69,132.3 253.17,132.3 v2(252.8,132.67)
  BOTTOM w0.102: v2(252.8,132.67) UG6.BJ6 ; 258.97,132.78 v1(257.43,132.78)
  BOTTOM w0.14: QG17.3 263.4,133.27 263.26,133.41 262.54,133.41 262.11,132.98 261.78,132.98 261.54,133.21 RG124.2 260.23,133.21 259.79,132.78 258.97,132.78
GPIO14_IFPA_HPD_TBT_Q: length 2.2
  BOTTOM w0.14: QG17.2 262.45,135.44 262.77,135.75 RG120.1 RG119.1
GPIO15_IFPB_HPD_TBT: length 40.1
  TOP w0.14: QG7.3 278.42,128.22 279.34,127.3 v1(279.34,126.93) 279.34,126.69 278.86,126.21 RG62.2 278.1,126.21 277.99,126.32 v1(277.95,126.32)
  IN4 w0.086: v1(277.95,126.32) 275.55,123.92 270.05,123.92 269.01,122.88 269.01,121.33 267.73,120.04 266.48,120.04 266.16,120.36 266.16,122.05 265.14,123.06 264.2,123.06 262.46,124.8 261.73,124.8 260.66,125.88 260.66,126.22 260.01,126.87 260.01,127.6 258.4,129.21 258.4,130.75 257.65,131.5 256.9,131.5 256.16,132.25 254.92,132.25 254.53,131.86 v2(254.29,131.86)
  BOTTOM w0.102: UG6.BJ5 254.26,131.91 254.29,131.88 v2(254.29,131.86)
GPIO15_IFPB_HPD_TBT_Q: length 25.7
  TOP w0.14: RG70.1 292.46,118.81 RG78.1 292.46,117.64 289.46,114.64 288.04,114.64 287.89,114.8 284.66,114.8 281.79,117.67 v1(281.79,118.89) 281.79,127.03 280.42,128.4 QG7.2
GPIO17_IFPD_HPD_EDP: length 20.3
  TOP w0.102: 258.97,132.25 257.9,132.25 257.52,131.87 v2(255.7,131.87)
  TOP w0.14: 258.97,132.25 260.41,132.25 260.58,132.42 262.92,132.42 263.49,132.99 264.89,132.99 268.39,136.49 v1(270.61,136.49) RG48.2 272.88,136.49 272.91,136.52 QG4.3
  BOTTOM w0.102: v2(255.7,131.87) UG6.BJ3
GPIO17_IFPD_HPD_EDP_Q: length 3
  TOP w0.14: v1(276.1,136.49) 276.19,136.4 RG47.1 RG49.1 276.47,135.63 276.41,135.57 QG4.2
GPIO18_IFPE_HPD_DP: length 20.6
  TOP w0.14: v1(259.74,129.68) 268.28,129.68 269.09,128.87 272.29,128.87 v1(272.42,128.99) 272.61,129.18 RG59.2 272.61,130.05 272.75,130.19 273.23,130.19 273.61,129.81 QG6.3
  BOTTOM w0.102: 258.97,130.45 257.54,131.88 256.39,131.88 UG6.BJ2
  BOTTOM w0.14: 258.97,130.45 v1(259.74,129.68)
GPIO18_IFPE_HPD_DP_Q: length 2.1
  TOP w0.14: QG6.2 276.1,128.46 276.13,128.49 276.53,128.49 276.62,128.4 RG61.1 RG60.1
GPIO24_IFPF_HPD: length 58.3
  TOP w0.14: v1(267.86,121.77) 267.86,123.21 269.68,125.03 271.83,125.03 272.34,125.54 277.08,125.54 279.56,123.06 280.15,123.06 280.64,123.55 280.64,123.55 RG63.2 280.64,124.25 280.11,124.79 280.11,127.31 279.48,127.93 279.48,128.86 279.91,129.29 281.2,129.29 282.22,130.31 v1(282.22,134.71) 282.22,139.21 282.53,139.52 QG3.3
  IN4 w0.086: v1(267.86,121.77) 266.06,123.56 264.3,123.56 260.89,126.98 260.89,127.26 258.91,129.23 258.91,130.78 257.81,131.88 257.06,131.88 256.05,132.89 254.68,132.89 v2(254.3,133.27)
  BOTTOM w0.102: UG6.BG4 v2(254.3,133.27)
  BOTTOM w0.14: v1(267.86,121.77) 267.86,123.09 268.02,123.25 RG144.1
GPIO24_IFPF_HPD_Q:
  vias: v1(285.45,140.11)
GPIO26_SPI_WP#: length 24.7
  BOTTOM w0.102: UG6.BG2 256.4,133.97 257.21,133.97 257.43,133.74 257.94,133.74 258.68,134.48 258.68,134.61 258.97,134.9
  BOTTOM w0.14: 258.97,134.9 259.29,135.22 261.25,135.22 262.08,134.38 264.07,134.38 264.75,133.71 267.05,133.71 269.79,130.96 271.86,130.96 272.38,131.48 UG7.3 272.38,134.41 272.33,134.46 RG122.2 272.33,135.36 272.51,135.54 TPG51.1 272.51,136.17 272.27,136.41 RG118.1
GPIO27_IFPC_HPD_HDMI: length 18.4
  TOP w0.14: v1(266.07,132.98) 267.72,132.98 267.77,132.94 v1(271.15,132.94) RG52.2 272.81,132.94 272.83,132.97 QG5.3
  BOTTOM w0.102: UG6.BG1 257.05,133.62 257.29,133.39 257.94,133.39 258.97,134.42
  BOTTOM w0.14: 258.97,134.42 258.97,134.47 259.41,134.91 261.16,134.91 261.97,134.1 263.96,134.1 265.08,132.98 v1(266.07,132.98)
GPIO27_IFPC_HPD_HDMI_Q: length 3
  TOP w0.14: QG5.2 276.36,132.02 276.46,131.92 RG55.1 RG53.1 276.36,132.68 v1(276.1,132.93)
GPP_B18: length 6.2
  TOP w0.14: R524.1 223.81,61.43 223.17,62.07 222.61,62.07 222.3,61.76 221.95,61.76 221.5,62.21 v1(220,62.21) 220,61.38 R532.2
  BOTTOM w0.102: U49.AU36 219.75,61.75 220,62 v1(220,62.21)
GPP_B22: length 2
  TOP w0.14: R553.1 219.88,58.75 v1(220.3,59.17) 220.5,59.37 R546.2
  BOTTOM w0.102: U49.AW41 220.48,59.35 v1(220.3,59.17)
GPP_D1: length 1.5
  TOP w0.14: TP64.1 220.65,64.49 v1(220.75,64.59)
  BOTTOM w0.102: U49.AW32 220.38,64.01 220.74,64.37 220.74,64.58 v1(220.75,64.59)
GPP_G2: length 1.8
  TOP w0.14: v1(223.5,71.98) 223.5,73.08 TP177.1
  BOTTOM w0.102: v1(223.5,71.98) U49.BE15
GPP_G10: length 2
  TOP w0.14: TP54.1 221.82,71.79 v1(221.82,71.09)
  BOTTOM w0.102: U49.BA17 221.7,71.21 v1(221.82,71.09)
GPP_G11: length 10.4
  BOTTOM w0.079: U49.AY17 221.04,71.55 221.5,72.02 221.97,72.02 222.27,71.72 222.86,71.72 222.97,71.61 222.97,71.47 223.06,71.37 223.39,71.37
  BOTTOM w0.102: 223.39,71.37 223.51,71.37 223.56,71.32 223.82,71.32 223.99,71.15 224.51,71.15 225.16,71.79 226.4,71.79 226.82,72.22 R952.2 227.46,72.56 227.92,73.02 v1(228.68,73.02) 228.88,72.82 R953.1
GPP_G14: length 1.5
  TOP w0.14: v1(217.77,70.22) 217.77,70.48 TP55.1
  BOTTOM w0.102: U49.AN21 217.46,69.72 217.77,70.03 v1(217.77,70.22)
GPP_G15: length 4.7
  TOP w0.14: v1(216.99,69.25) 217.42,69.68 R437.1 220.22,69.68 220.55,70.01 R433.2
  BOTTOM w0.102: v1(216.99,69.25) 216.58,69.66 U49.AL21
GPP_H18: length 8.7
  BOTTOM w0.102: R932.1 229.14,76.87 228.89,76.62 227.84,76.62 227.62,76.84 R931.2 227.5,77.17 223.96,77.17 223.86,77.27 223.35,77.27 223.24,77.16 222.99,77.16 222.58,77.57 222.58,78.1 222.84,78.36 U49.BE3
GPS_EN#_EC: length 198.4
  TOP w0.14: R596.1 174.4,54.57 173.8,53.96 173.33,53.96 172.9,53.53 v1(172.9,53.4) ; R576.1 168.37,57.61 v1(168.63,57.87)
  IN3 w0.089: v1(182.5,48.38) 182.58,48.38 182.86,48.09 187.21,48.09 191.36,43.94 197.33,43.94 198.4,42.87 200.5,42.87 200.75,43.12 209.81,43.12 211.27,44.59 219.05,44.59 219.18,44.72 221.3,44.72 225.02,48.44 230.44,48.44 231.12,49.12 237.29,49.12 237.36,49.19 238.22,49.19 238.83,49.8 241.33,49.8 243.68,52.15 247.22,52.15 247.9,52.84 249.31,52.84 250.31,51.83 252.32,51.83 252.86,52.37 256.41,52.37 256.72,52.06 261.03,52.06 262.93,53.96 264.54,53.96 265.23,54.66 266.53,54.66 267.71,55.83 270.21,55.83 271.15,54.89 273.25,54.89 273.44,55.08 274.78,55.08 275.09,54.76 276.34,54.76 279.51,57.94 280.2,57.94 281.77,59.5 281.77,63.61 281.4,63.98 281.4,68.1 282.41,69.12 282.41,69.39 284.17,71.14 284.17,72.67 287.4,75.91 287.54,76.05 287.54,77.17 293.09,82.71 296.08,82.71 297.78,84.41 297.78,85.63 298.84,86.69 298.84,87.4 302.06,90.62 302.06,92.52 304.75,95.21 307.4,95.21 308.58,94.04 308.58,93.52 309,93.1 309.41,93.1 309.83,93.52 311.58,93.52 311.76,93.33 311.76,92.41 311.02,91.67 311.02,88.7 v1(311.35,88.37)
  BOTTOM w0.14: v1(311.35,88.37) 311.35,87.72 311.02,87.38 310.61,87.38 310.42,87.19 R865.2 309.63,86.96 309.58,87 CN7.26 ; v1(168.63,57.87) 169.81,57.87 172.28,55.4 172.28,53.89 172.76,53.4 v1(172.9,53.4) 173.38,52.93 177.56,52.93 180.7,49.79 180.7,49.13 181.36,48.47 182.41,48.47 v1(182.5,48.38)
GPU_ADC_INN: length 193.8
  TOP w0.14: v1(234.8,215.72) 234.61,215.9 234,215.9 233.96,215.94 PR13.2
  IN1 w0.086: v1(234.8,215.72) 234.56,215.95 234.08,215.95 233.96,215.83 233.96,214.3 234.76,213.51 234.76,212.31 238.02,209.04 241.32,209.04 241.62,209.34 243.16,209.34 244.19,210.36 244.19,211.38 244.97,212.17 244.97,215.92 244.54,216.35 244.54,217.48 245.06,218 246.3,218 246.77,218.47 251.16,218.47 251.3,218.33 266.71,218.33 267.39,217.64 272.45,217.64 273.86,216.23 277.48,216.23 278.11,215.61 278.11,215.03 277.76,214.68 277.18,214.68 276.96,214.47 276.96,212.43 280.27,209.13 281.32,209.13 283.36,207.09 283.36,206.83 284.7,205.49 284.7,200.33 285.97,199.06 285.97,188.03 285.32,187.37 284.93,187.37 v1(284.67,187.11)
  IN2 w0.089: v1(274.4,136.07) 274.62,136.29 275.47,136.29 276.8,137.62 277.43,137.62 279.37,139.56 279.37,152.58 280.69,153.9 280.69,167.91 282.13,169.34 283.6,169.34 283.72,169.22 v1(283.72,169)
  IN3 w0.089: v1(251.32,123.08) 251.52,123.08 251.65,123.22 251.65,123.85 253.8,126 256.2,126 257.38,127.19 258.97,127.19 261.33,129.55 266.13,129.55 268.45,131.87 269.34,131.87 271.17,133.69 271.17,134.59 271.53,134.94 274.01,134.94 274.97,135.91 274.97,136.21 274.88,136.3 274.51,136.3 274.4,136.19 v1(274.4,136.07)
  IN4 w0.086: v1(284.67,187.11) 284.41,187.37 284.28,187.37 284.19,187.27 284.19,181.97 284.05,181.83 284.05,179.76 285.32,178.5 285.32,173.17 284.34,172.19 284.34,169.58 284.16,169.4 283.85,169.4 283.67,169.21 283.67,169.06 v1(283.72,169)
  BOTTOM w0.102: v1(251.32,123.08) 251.58,123.34 251.58,123.94 250.8,124.71 250.8,127.47 250.45,127.82 UG6.BR10
  BOTTOM w0.14: CG521.2 252.54,121.26 252.68,121.4 252.68,121.69 252.54,121.83 252.2,121.83 251.58,122.45 251.58,122.83 v1(251.32,123.08)
GPU_ADC_INP: length 194.6
  TOP w0.14: PR8.2 232.82,216.15 232.88,216.21 234.06,216.21 234.11,216.17 234.51,216.17 v1(234.75,216.42)
  IN1 w0.086: v1(284.67,187.9) 285.04,187.53 285.25,187.53 285.81,188.09 285.81,198.99 284.53,200.26 284.53,205.42 283.19,206.76 283.19,207.02 281.25,208.96 280.2,208.96 276.8,212.36 276.8,214.54 277.11,214.85 277.69,214.85 277.94,215.1 277.94,215.54 277.42,216.06 273.79,216.06 272.38,217.48 267.33,217.48 266.64,218.16 251.23,218.16 251.09,218.3 246.84,218.3 246.37,217.83 245.13,217.83 244.71,217.41 244.71,216.42 245.14,215.99 245.14,212.1 244.35,211.31 244.35,210.3 243.23,209.17 241.69,209.17 241.39,208.87 237.96,208.87 234.59,212.24 234.59,213.44 233.8,214.23 233.8,215.9 234.02,216.12 234.45,216.12 v1(234.75,216.42)
  IN2 w0.089: v1(274.6,136.71) 274.6,136.66 274.78,136.48 275.39,136.48 276.72,137.81 277.35,137.81 279.18,139.64 279.18,152.66 280.5,153.98 280.5,167.98 282.05,169.53 283.44,169.53 v1(283.65,169.74)
  IN3 w0.089: v1(274.6,136.71) 274.6,136.61 274.72,136.49 274.96,136.49 275.16,136.29 275.16,135.83 274.09,134.75 271.61,134.75 271.36,134.51 271.36,133.61 269.42,131.67 268.53,131.67 266.21,129.36 261.41,129.36 259.05,127 257.46,127 256.28,125.81 253.88,125.81 251.84,123.77 251.84,123.28 v1(252.03,123.08)
  IN4 w0.086: v1(283.65,169.74) 283.83,169.56 284.09,169.56 284.18,169.65 284.18,172.26 285.15,173.24 285.15,178.43 283.89,179.7 283.89,181.9 284.02,182.03 284.02,187.34 284.22,187.53 284.41,187.53 284.67,187.8 v1(284.67,187.9)
  BOTTOM w0.102: v1(252.03,123.08) 251.78,123.34 251.78,124.02 251,124.8 251,127.47 251.03,127.49 251.03,127.64 250.8,127.87 250.8,128.11 250.45,128.46 UG6.BP10
  BOTTOM w0.14: v1(252.03,123.08) 251.82,122.87 251.82,122.55 252.3,122.07 252.64,122.07 252.92,121.79 252.92,121.43 CG522.2
GPU_CLK: length 255.1
  TOP w0.14: C475.1 39.78,61.81 39.78,62.79 v1(40.08,63.08)
  IN1 w0.086: v1(40.08,63.08) 40.08,63.28 39.96,63.39 39.63,63.39 39.53,63.3 39.53,62.7 39.77,62.47 40.29,62.47 50.87,63.4 58.74,63.4 63.43,64.86 82.5,64.86 84.47,65.68 92.29,65.68 92.54,65.93 109.19,65.93 109.7,66.25 123.7,66.25 123.85,66.09 138.33,66.09 141.2,66.51 150.9,69.14 163.77,69.14 164.69,69.52 174.19,69.52 174.49,69.82 177.68,69.82 178.73,70.86 179.23,70.86 181.04,69.76 182.71,69.76 184.99,70.04 186.12,70.04 187.2,71.12 188.27,71.12 197.15,80 197.15,80.54 198.26,81.65 198.26,93.99 199.28,95.02 201.09,97.88 203.1,102.27 205.11,107.23 205.11,110.5 211.96,117.35 226.02,117.35 226.49,117.82 230.96,117.82 232,116.77 236.17,116.77 238.79,117.86 240.07,118.12 241.91,118.88 243.12,120.09 244.21,121.47 244.63,122.11 244.63,123.05 245.26,126.61 245.46,127.72 245.71,129.12 245.71,131.2 245.44,131.47 245.3,131.47 245.2,131.37 v2(245.2,131.17)
  BOTTOM w0.104: UG6.BL17 v2(245.2,131.17)
GPU_CLK#: length 255.2
  TOP w0.14: C474.1 39.36,61.81 39.36,62.79 v1(39.07,63.08)
  IN1 w0.086: v1(39.07,63.08) 39.3,62.86 39.3,62.6 39.67,62.23 40.3,62.23 50.88,63.16 58.78,63.16 63.48,64.62 82.54,64.62 84.51,65.44 92.39,65.44 92.64,65.69 109.26,65.69 109.77,66.01 123.6,66.01 123.76,65.85 138.35,65.85 141.25,66.28 150.93,68.9 163.82,68.9 164.74,69.28 174.29,69.28 174.59,69.58 177.78,69.58 178.82,70.63 179.16,70.63 180.98,69.52 182.72,69.52 185.01,69.8 186.22,69.8 187.3,70.88 188.37,70.88 197.39,79.9 197.39,80.44 198.5,81.55 198.5,93.9 199.47,94.87 201.3,97.77 203.32,102.18 203.32,102.18 205.35,107.18 205.35,110.4 212.06,117.11 226.12,117.11 226.59,117.58 230.86,117.58 231.9,116.54 236.21,116.54 238.86,117.63 240.14,117.89 242.05,118.68 243.3,119.93 244.41,121.33 244.87,122.04 244.87,123.03 245.71,127.72 245.95,129.1 245.95,131.3 245.54,131.71 245.27,131.71 v2(245.16,131.82)
  BOTTOM w0.102: v2(245.16,131.82) 245.46,131.52 UG6.BK17
GPU_CLK#_C: length 1.5
  TOP w0.14: C474.2 39.36,61.01 39.36,60.62 39.23,60.49 U27.14
GPU_CLK_C: length 1.5
  TOP w0.14: C475.2 39.78,61.01 39.78,60.44 39.73,60.39 U27.13
GPU_D0: length 252.2
  TOP w0.14: C477.1 41.31,61.81 41.31,62.22 41.63,62.54 41.63,64.37 v1(41.86,64.61)
  IN1 w0.086: v1(41.86,64.61) 41.86,64.92 41.74,65.05 41.43,65.05 41.33,64.95 41.33,64.29 41.52,64.1 58.49,64.1 63.13,65.57 81.8,65.57 83.77,66.38 91.73,66.38 92.09,66.75 108.57,66.75 109.07,66.95 122.5,66.95 122.91,67.12 137.21,67.12 137.27,67.14 139.39,68.28 139.39,68.28 142.28,69.84 150.09,69.84 150.23,69.84 150.37,69.84 163.4,69.84 164.32,70.22 173.76,70.22 174.07,70.53 177.3,70.53 178.5,71.74 184.87,71.74 185.83,72.43 188.58,72.43 196.36,80.21 196.36,80.75 197.55,81.94 197.55,94.29 198.19,94.92 200.44,98.26 203.04,105.58 203.04,109.42 211.95,118.34 226,118.34 226.22,118.56 231.22,118.56 232.3,117.48 236.03,117.48 239.14,118.77 239.52,118.77 241.29,120.54 241.55,120.54 242.41,120.86 243.92,122.38 243.92,123.57 244.16,127.72 244.23,128.91 244.93,129.61 244.93,129.78 244.79,129.93 244.66,129.93 v2(244.55,129.82)
  BOTTOM w0.102: UG6.BM19 244.15,129.92 244.25,129.82 v2(244.55,129.82)
GPU_D0#: length 252.2
  TOP w0.14: C476.1 40.89,61.81 40.89,62.4 41.21,62.72 41.21,64.26 v1(40.86,64.61)
  IN1 w0.086: v1(40.86,64.61) 41.09,64.38 41.09,64.19 41.42,63.86 58.53,63.86 63.18,65.33 81.85,65.33 83.82,66.15 91.83,66.15 92.19,66.51 108.62,66.51 109.12,66.71 122.55,66.71 122.96,66.88 137.24,66.88 137.35,66.91 139.5,68.07 139.5,68.07 142.19,69.53 142.34,69.61 150.09,69.61 150.23,69.6 150.27,69.6 163.45,69.6 164.37,69.99 173.86,69.99 174.17,70.29 177.39,70.29 178.6,71.5 184.95,71.5 185.91,72.19 188.68,72.19 196.6,80.11 196.6,80.65 197.79,81.85 197.79,94.19 198.37,94.77 200.65,98.15 203.28,105.53 203.28,109.33 212.05,118.1 226.1,118.1 226.32,118.32 231.12,118.32 232.2,117.24 236.07,117.24 239.18,118.53 239.61,118.53 241.39,120.3 241.6,120.3 242.5,120.62 244.16,122.28 244.16,123.56 244.4,127.72 244.47,128.8 245.17,129.51 245.17,129.88 244.88,130.17 244.7,130.17 244.51,130.36 v2(244.51,130.46)
  BOTTOM w0.104: UG6.BL19 v2(244.51,130.46)
GPU_D0#_C: length 1.5
  TOP w0.14: U27.11 40.73,60.23 40.77,60.27 40.77,60.77 40.88,60.88 40.88,61.02 40.72,61.19 C476.2
GPU_D0_C: length 1.5
  TOP w0.14: C477.2 41.3,61.01 41.3,60.71 41.19,60.6 41.19,60.3 41.23,60.26 U27.10
GPU_D1: length 252.3
  TOP w0.14: C479.1 42.83,61.81 42.83,62.51 43.44,64.08 43.44,65.01 43.22,65.23 43.22,65.46 v1(43.51,65.75)
  IN1 w0.086: v1(43.51,65.75) 43.24,65.75 43.04,65.56 43.04,65.39 43.14,65.28 43.86,65.13 45.18,65 58.44,65 62.96,66.27 81.01,66.27 83.44,67.28 88.13,67.28 89.01,67.46 106.64,67.46 107.54,67.83 122.77,67.83 124.08,68.37 129.3,68.37 129.38,68.29 132.6,68.29 133.96,68.85 141.84,70.55 153.92,70.55 162.55,70.55 165.44,71.75 175.69,71.75 177.36,72.44 182.35,72.44 185.85,73.19 188.35,73.19 195.52,80.37 195.52,80.92 196.85,82.24 196.85,98.5 199.56,101.22 199.56,103.24 201.07,104.75 202.31,106.16 202.31,109.7 211.66,119.04 225.71,119.04 225.99,119.33 231.45,119.33 232.59,118.19 235.86,118.19 238.39,119.88 239.3,119.88 240.67,121.25 241.25,121.25 241.63,121.63 242.17,121.63 243.22,122.67 243.22,127.96 243.3,128.04 243.3,128.91 243.89,129.51 243.89,131.52 243.84,131.58 243.84,132.04 244.07,132.27 244.34,132.27 244.49,132.42 v2(244.49,132.56)
  BOTTOM w0.102: v2(244.49,132.56) UG6.BJ19
GPU_D1#: length 252.4
  TOP w0.14: C478.1 42.41,61.81 42.41,62.59 43.02,64.16 43.02,64.84 42.8,65.06 42.8,65.46 v1(42.51,65.75)
  IN1 w0.086: v2(244.49,131.86) 244.32,132.04 244.17,132.04 244.08,131.94 244.08,131.68 244.13,131.62 244.13,129.41 243.54,128.82 243.54,127.94 243.45,127.86 243.45,122.57 242.27,121.39 241.73,121.39 241.35,121.01 240.77,121.01 239.4,119.64 238.47,119.64 235.93,117.95 232.49,117.95 231.35,119.09 226.09,119.09 225.81,118.8 211.76,118.8 202.55,109.6 202.55,106.07 201.31,104.65 199.8,103.14 199.8,101.12 197.08,98.4 197.08,82.15 195.76,80.82 195.76,80.27 188.45,72.95 185.88,72.95 182.38,72.2 177.41,72.2 175.74,71.51 165.49,71.51 162.59,70.31 153.82,70.31 153.82,70.31 141.87,70.31 134.01,68.61 132.65,68.05 129.28,68.05 129.2,68.13 124.13,68.13 122.82,67.59 107.59,67.59 106.69,67.22 89.03,67.22 88.15,67.04 83.49,67.04 81.06,66.04 63.01,66.04 58.47,64.76 45.16,64.76 45.16,64.76 43.83,64.9 43.01,65.06 42.86,65.24 42.81,65.31 42.81,65.45 v1(42.51,65.75)
  BOTTOM w0.104: UG6.BK19 v2(244.49,131.86)
GPU_D1#_C: length 1.5
  TOP w0.14: U27.8 42.23,60.23 42.28,60.27 42.28,60.69 42.38,60.79 42.38,61.05 C478.2
GPU_D1_C: length 1.5
  TOP w0.14: U27.7 42.73,60.28 42.7,60.32 42.7,60.51 42.8,60.61 42.8,60.98 C479.2
GPU_D2: length 252.1
  TOP w0.14: v1(45.38,66.76) 45.09,66.47 45.09,63.08 44.36,62.35 44.36,61.81 C481.1
  IN1 w0.086: v1(45.38,66.76) 45.38,67.02 45.24,67.15 44.87,67.15 44.79,67.07 44.79,66.39 44.92,66.26 45.13,66.17 47.47,65.71 58.19,65.71 62.55,66.98 80.21,66.98 82.63,67.99 88.05,67.99 90.71,68.51 98.88,69.32 101.28,69.32 104.08,68.16 106.43,68.16 107.33,68.53 115.52,68.53 117.49,69.35 129.34,69.35 129.64,69.05 131.87,69.05 133.87,69.56 140.41,71.4 150.3,71.4 150.86,71.96 156.29,71.96 156.47,71.77 163.65,71.77 165.3,72.46 175.55,72.46 177.68,73.34 177.7,73.36 181.22,73.36 181.87,74.01 188.17,74.01 194.81,80.66 194.81,81.21 196.14,82.54 196.14,98.82 198.75,101.43 198.75,103.58 199.39,104.22 200.22,106.88 200.24,106.91 201.59,108.8 201.59,109.98 211.36,119.75 225.41,119.75 225.73,120.06 231.71,120.06 232.88,118.89 234.12,118.89 234.51,119.28 234.51,120.64 235.01,121.13 237.98,121.13 238.81,121.96 240.96,121.96 241.33,122.33 241.87,122.33 242.51,122.97 242.51,127.76 242.31,127.95 242.31,128.8 243.47,129.95 243.47,131.16 243.37,131.26 243.19,131.26 v2(243.1,131.17)
  BOTTOM w0.102: UG6.BL20 243.45,131.07
  BOTTOM w0.104: v2(243.1,131.17) 243.35,131.17 243.45,131.07
GPU_D2#: length 252.2
  TOP w0.14: C480.1 43.94,61.81 43.94,62.52 44.67,63.26 44.67,66.47 v1(44.38,66.76)
  IN1 w0.086: v1(44.38,66.76) 44.55,66.59 44.55,66.29 44.78,66.06 45.06,65.94 47.44,65.47 58.23,65.47 62.58,66.74 80.25,66.74 82.68,67.75 88.08,67.75 90.74,68.28 98.9,69.08 101.24,69.08 104.03,67.92 106.47,67.92 107.37,68.29 115.57,68.29 117.53,69.11 129.24,69.11 129.54,68.81 131.9,68.81 133.9,69.32 133.93,69.32 140.45,71.16 150.4,71.16 150.96,71.72 156.19,71.72 156.37,71.53 163.69,71.53 165.35,72.22 175.6,72.22 177.77,73.12 181.32,73.12 181.97,73.77 188.26,73.77 195.05,80.56 195.05,81.11 196.38,82.44 196.38,98.72 198.99,101.33 198.99,103.48 199.6,104.09 200.43,106.77 201.83,108.73 201.83,109.88 211.46,119.51 225.51,119.51 225.83,119.83 231.61,119.83 232.78,118.65 234.22,118.65 234.75,119.18 234.75,120.54 235.11,120.89 238.08,120.89 238.91,121.72 241.06,121.72 241.43,122.1 241.97,122.1 242.75,122.87 242.75,127.85 242.55,128.05 242.55,128.7 243.7,129.85 243.7,131.26 243.47,131.5 243.28,131.5 243.12,131.66 v2(243.12,131.87)
  BOTTOM w0.102: UG6.BK20 243.45,131.56 243.17,131.84 243.16,131.84 243.14,131.86 243.12,131.86 v2(243.12,131.87)
GPU_D2#_C: length 1.4
  TOP w0.14: U27.5 43.73,60.28 43.81,60.36 43.81,61.14 C480.2
GPU_D2_C: length 1.5
  TOP w0.14: C481.2 44.23,60.89 U27.4
GPU_DDCCLK: length 310.5
  IN3 w0.089: v2(250.84,130.43) 250.69,130.43 250.04,129.78 250.04,128.26 249.76,127.99 249.76,122.9 v1(249.38,122.52) 249.38,122.37 249.29,122.28 247.28,122.28 246.12,123.43 246.12,124.94 243.17,127.89 237.73,127.89 237.18,127.34 222.98,127.34 218.98,123.33 214.7,123.33 213.5,122.13 206.61,122.13 204.99,120.52 204.99,118.29 199.67,112.96 199.67,108.73 200.16,108.24 200.16,106.52 199.47,105.83 198.52,105.83 196.65,103.96 v1(196.65,103.85) ; v1(21.06,43.29) 20.93,43.42 20.93,44.02 22.03,45.11 26.35,45.11 36.38,49.27 42.86,51.95 47.89,51.95 49.5,52.62 57.84,52.62 60.39,55.17 60.39,56.14 62.27,58.02 63.23,58.02 63.82,58.61 64.62,58.61 68.15,62.14 85.55,62.14 86.64,61.06 100.88,61.06 101.34,61.25 110.34,61.25 110.69,61.61 111.4,61.61 111.9,62.11 119.23,62.11 119.85,62.72 124.13,62.72 125.24,63.84 136.5,63.84 v1(137.24,64.58)
  IN4 w0.086: v1(196.65,103.85) 196.21,103.4 196.21,102.47 197.13,101.54 197.13,101.04 197.28,100.88 197.28,99.29 196.14,98.15 196.14,79.88 189.91,73.65 188.14,73.65 187.87,73.38 186.7,73.38 186.46,73.14 185.47,73.14 185.17,73.14 184.54,72.51 167.24,72.51 166.52,71.79 161.95,71.79 161.7,72.05 157.64,72.05 157.39,71.79 156.34,71.79 156.08,72.05 151.73,72.05 148.29,68.61 147.62,68.61 145.91,66.9 140.36,66.9 138.04,64.58 v1(137.24,64.58)
  BOTTOM w0.102: v2(250.84,130.43) 250.45,130.82 UG6.BL10 ; RG154.1 248.34,121.15 249.15,121.96 249.15,122.29 v1(249.38,122.52)
  BOTTOM w0.14: Q117.4 19.26,35.56 19.12,35.7 19.12,36.82 19.29,36.98 19.74,36.98 R1174.2 19.81,37.25 19.4,37.25 19.26,37.39 19.26,37.63 21.91,40.28 21.91,41.75 20.72,42.94 20.72,43.15 20.86,43.29 v1(21.06,43.29)
GPU_DDCDATA: length 309.6
  IN3 w0.089: v1(136.55,64.58) 136.55,64.45 136.33,64.23 125.08,64.23 123.97,63.12 119.69,63.12 119.07,62.5 111.74,62.5 111.24,62 110.51,62 110.15,61.64 101.27,61.64 100.8,61.45 86.8,61.45 85.72,62.53 67.98,62.53 64.45,59 63.66,59 63.07,58.41 62.11,58.41 60,56.3 60,55.34 57.67,53.01 49.42,53.01 47.81,52.35 42.78,52.35 36.16,49.6 26.27,45.51 21.87,45.51 20.93,44.57 20.54,44.18 20.54,43.41 20.45,43.32 v1(20.27,43.32) ; v2(250.81,129.79) 250.6,129.79 250.43,129.62 250.43,128.1 250.15,127.82 250.15,122.48 v1(249.56,121.88) 247.11,121.88 245.73,123.27 245.73,124.78 243.01,127.5 237.9,127.5 237.34,126.94 223.14,126.94 219.14,122.94 214.86,122.94 213.67,121.74 209,121.74 200.07,112.8 200.07,108.89 200.56,108.41 200.56,106.36 199.63,105.44 198.68,105.44 197.16,103.91 197.16,103.39 196.88,103.11 v1(196.7,103.11)
  IN4 w0.086: v1(196.7,103.11) 196.6,103.01 196.6,102.63 197.52,101.7 197.52,101.2 197.67,101.04 197.67,99.13 196.53,97.99 196.53,79.72 190.07,73.26 188.31,73.26 188.03,72.99 186.86,72.99 186.62,72.75 185.34,72.75 184.71,72.12 167.4,72.12 166.68,71.4 161.79,71.4 161.53,71.66 157.81,71.66 157.55,71.4 156.18,71.4 155.92,71.66 152.69,71.66 151.62,70.58 150.81,70.58 148.45,68.22 147.78,68.22 146.07,66.51 140.52,66.51 138.2,64.18 136.72,64.18 136.55,64.35 v1(136.55,64.58)
  BOTTOM w0.102: v2(250.81,129.79) 250.55,129.79 250.45,129.89 UG6.BM10 ; v1(249.56,121.88) 249.48,121.88 248.89,121.29 RG155.1
  BOTTOM w0.14: v1(20.27,43.32) 20.27,42.75 21.46,41.56 21.46,40.46 18.82,37.82 18.82,37.4 R1173.1 18.68,37.04 18.68,34.57 18.37,34.26 Q117.1
GPU_EDP_AUXN: length 196.2
  TOP w0.14: v1(259.07,209.8) 259.29,209.8 259.41,209.92 259.41,210.07 259.61,210.27 259.95,210.27 260.05,210.18 260.05,209.93 260.19,209.79 260.54,209.79 260.68,209.93 260.68,210.2 260.88,210.4 261.25,210.4 261.39,210.26 261.39,209.75 261.53,209.61 262.58,209.61 262.77,209.8 263.19,209.8 263.38,209.61 263.65,209.61 263.67,209.58 v1(263.67,209.57)
  IN4 w0.086: v2(249.4,131.17) 249.4,130.96 249.49,130.86 249.98,130.86 250.29,130.55 250.29,127.47 247.88,125.05 247.32,125.05 246.98,124.72 246.43,124.72 245.79,124.08 245.79,122.05 245.62,121.88 245.62,121.73 v1(245.82,121.53) 245.7,121.53 245.56,121.39 245.56,120.7 247.9,118.37 249.62,118.37 251.67,116.32 251.67,115.71 251.33,115.37 251.33,115.36 251.08,115.12 251.08,113.65 252.31,112.42 261.99,112.42 262.34,112.78 275.38,112.78 280.78,118.18 280.78,139.86 280.51,140.13 280.51,152.33 281.5,153.32 281.5,196.48 283.09,198.07 283.09,201.63 282.02,202.7 282.02,204.37 280.42,205.97 280.42,209.85 278.23,212.03 278.23,214.38 279.03,215.19 279.03,216.11 279.74,216.82 279.74,217.76 278.95,218.56 266.96,218.56 264.82,216.41 264.82,214.08 262.64,211.9 262.64,209.39 263.25,208.78 263.83,208.78 264.09,209.03 264.09,209.49 263.93,209.65 263.78,209.65 263.7,209.57 v1(263.67,209.57)
  BOTTOM w0.102: UG6.BL11 249.8,130.87 249.8,131.07 249.7,131.17 v2(249.4,131.17)
  BOTTOM w0.14: RG157.1 245.7,121.03 245.7,121.4 v1(245.82,121.53) ; v1(259.07,209.8) 259.48,209.8 259.62,209.66 R708.2
GPU_EDP_AUXN_R: length 1.7
  BOTTOM w0.14: U37.10 260.64,209.7 260.5,209.84 260.26,209.84 260.07,209.65 R708.1
GPU_EDP_AUXP: length 196.2
  TOP w0.14: v1(269.61,210.35) 269.58,210.38 267.74,210.38 267.52,210.6 v1(266.55,210.6) 265.41,210.6 264.51,209.71 v1(264.51,209.58)
  IN4 w0.086: v2(249.4,130.47) 249.63,130.7 249.91,130.7 250.13,130.48 250.13,127.54 247.81,125.22 247.25,125.22 246.91,124.88 246.36,124.88 245.62,124.15 245.62,122.12 245.42,121.91 245.42,121.74 v1(245.18,121.5) 245.39,121.28 245.39,120.64 247.83,118.2 249.56,118.2 251.51,116.25 251.51,115.77 251.21,115.47 251.21,115.47 250.92,115.18 250.92,113.58 252.24,112.26 262.06,112.26 262.41,112.61 275.45,112.61 280.94,118.11 280.94,139.93 280.67,140.2 280.67,152.26 281.67,153.26 281.67,196.41 283.25,198 283.25,201.69 282.18,202.77 282.18,204.43 280.58,206.03 280.58,209.91 278.4,212.1 278.4,214.32 279.2,215.12 279.2,216.04 279.91,216.75 279.91,217.83 279.01,218.72 266.9,218.72 264.65,216.48 264.65,214.15 262.48,211.97 262.48,209.32 263.18,208.61 263.9,208.61 264.25,208.96 264.25,209.32 v1(264.51,209.58)
  BOTTOM w0.102: UG6.BM11 v2(249.4,130.47)
  BOTTOM w0.14: R707.1 269.07,209.7 269.61,210.24 v1(269.61,210.35) ; v1(245.18,121.5) 245.24,121.44 245.24,121.17 RG156.1
GPU_EDP_AUXP_R: length 1.7
  BOTTOM w0.14: R707.2 267.92,210.34 U37.6
GPU_EDP_TXN0: length 159.9
  IN4 w0.086: v1(248.33,124.05) 248.34,124.05 248.53,123.85 248.53,123.52 249.04,123.01 249.85,123.01 251.46,121.4 251.46,119.5 252.22,118.73 252.73,118.73 252.95,118.52 252.95,118.01 253.73,117.23 253.73,116.14 254.87,115 260.99,115 261.15,114.84 274.52,114.84 278.65,118.96 278.65,138.08 277.15,139.58 277.15,144.78 277.23,144.87 277.34,144.87 277.55,145.07 277.55,145.51 277.37,145.69 277.23,145.69 277.15,145.78 277.15,147.76 277.23,147.85 277.77,147.85 277.96,148.03 277.96,148.59 277.77,148.77 277.23,148.77 277.15,148.86 277.15,152.55 279.42,154.83 279.42,185.87 279.24,186.05 278.66,186.05 278.55,186.17 278.55,186.56 278.64,186.65 279.24,186.65 279.42,186.83 279.42,187.39 279.24,187.57 276.75,187.57 276.66,187.66 276.66,188.08 276.75,188.17 279.24,188.17 279.42,188.35 279.42,189.06 279.24,189.24 277.56,189.24 277.47,189.33 277.47,193.92 276.97,194.42 276.97,200.43 276.75,200.65 276.75,206.11 275.24,207.62 274.84,207.62 273.71,208.75 273.21,208.75 273.12,208.83 273.12,209.5 272.76,209.86 272.04,209.86 270.61,211.29 270.61,211.46 270.26,211.81 269.35,211.81 v1(269.02,212.14)
  BOTTOM w0.102: v1(248.33,124.05) 248.34,124.05 248.57,123.81 248.57,123.41 248.72,123.25 248.72,122.59 248.57,122.44 248.57,122.19 248.26,121.88 246.45,121.88 245.09,123.24 245.09,123.81 243.86,125.05 243.86,127.03 UG6.BT19
  BOTTOM w0.14: C580.1 269.63,211.96 269.49,211.82 269.34,211.82 v1(269.02,212.14)
GPU_EDP_TXN0_R: length 1.4
  BOTTOM w0.14: U36.36 270.98,212.09 270.91,212.02 270.65,212.02 270.48,211.85 270.32,211.85 C580.2
GPU_EDP_TXN1: length 159.2
  IN4 w0.086: v1(247.37,122.75) 247.59,122.53 247.59,122.22 249.26,120.55 249.89,120.55 250.4,120.04 250.4,119.77 253.18,117 253.18,115.9 255.15,113.93 261.07,113.93 261.42,114.28 274.75,114.28 279.2,118.73 279.2,138.35 278.65,138.91 278.65,153.08 279.98,154.41 279.98,190.59 279.8,190.78 279.06,190.78 278.97,190.86 278.97,191.29 279.06,191.37 279.8,191.37 279.98,191.55 279.98,192.25 278.95,193.29 278.95,193.49 279.31,193.85 279.31,194.36 279.09,194.58 278.97,194.58 278.84,194.7 278.84,195.05 278.97,195.17 279.09,195.17 279.28,195.36 279.28,196.43 279.09,196.62 278.79,196.62 278.7,196.7 278.7,197.12 278.79,197.21 279.09,197.21 279.28,197.39 279.28,198.55 279.09,198.73 278.59,198.73 278.5,198.82 278.5,199.21 278.59,199.29 278.81,199.29 279,199.48 279,200.04 278.81,200.22 278.2,200.22 278.12,200.31 278.12,207.02 278.37,207.27 278.37,208.31 277.96,208.71 275.87,208.71 275.79,208.8 275.79,210.12 275.05,210.86 274.52,210.86 274.34,211.05 273.43,211.05 273.29,210.9 272.71,210.9 272.46,211.15 272.46,211.54 272.19,211.8 272.07,211.8 271.85,212.02 271.85,213.32 272.12,213.59 272.18,213.59 272.36,213.77 272.36,214.44 272.18,214.63 271.79,214.63 271.41,215 271.41,215.97 271.23,216.15 271.04,216.15 270.9,216.29 270.9,216.35 v1(271.13,216.59)
  BOTTOM w0.102: v1(247.37,122.75) 247.56,122.56 247.56,122.44 247.46,122.34 246.85,122.34 245.69,123.5 245.69,124.03 244.33,125.4 244.33,126.61 244.71,127 244.71,127.55 244.49,127.78 244.49,128 244.36,128.31 244.36,128.31 244.2,128.7 UG6.BP19
  BOTTOM w0.14: v1(271.13,216.59) 271.03,216.59 270.76,216.32 270.76,215.99 C574.1
