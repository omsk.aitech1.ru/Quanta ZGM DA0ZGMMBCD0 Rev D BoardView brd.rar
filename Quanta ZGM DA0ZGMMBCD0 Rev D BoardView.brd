# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
NVVDD_CORE1: length 8
  IN2 w0.508: v1(244.8,118.72) 244.8,118.71 245.96,117.55 v1(249.51,117.55)
  BOTTOM w0.254: UG8.4 244.16,120.39 244.63,119.92 244.63,118.89 v1(244.8,118.72)
  vias: v1(254.51,118.33)
NVVDD_CORE1_EN: length 87.2
  TOP w0.14: RG83.2 249.3,117.06 249.62,116.74 249.62,116.03 v1(249.76,115.89) 249.41,115.54 CG400.1 250.24,115.07 RG89.2 ; PD2.1 279.53,83.15 279.84,83.46 v1(280.34,83.46) 280.76,83.05 PR167.2
  IN1 w0.086: v1(256.52,114.58) 256.52,115.52 257.05,116.05 258.68,116.05 259.27,115.46 259.74,115.46 260.34,114.86 260.34,114.41 260.58,114.17 263.27,114.17 263.76,114.66 278.9,114.66 v1(278.92,114.63)
  IN3 w0.089: v1(280.34,83.46) 280.34,83.58 283.97,87.21 287.99,87.21 289.42,88.64 290.29,88.64 291.82,90.17 291.82,90.61 292.15,90.95 292.15,94.07 291.89,94.33 291.89,99.87 293.11,101.08 293.11,105.79 287.4,111.5 287.28,111.62 287.28,112.11 286.46,112.93 285.28,112.93 283.58,114.63 v1(278.92,114.63)
  BOTTOM w0.14: v1(249.76,115.89) 249.84,115.89 250.52,115.21 DG4.1 250.52,114.83 250.89,114.45 256.39,114.45 v1(256.52,114.58)
NVVDD_EN: length 34.5
  TOP w0.14: v1(245.15,120) 245.51,120 v1(245.81,120.3)
  IN2 w0.089: v1(245.15,120) 245.15,120 246.37,120 247.27,119.09 249.99,119.09 250.35,118.74 253.81,118.74 254.87,119.79 254.87,121.57 254.09,122.35 254.09,125.68 252.52,127.24 252.52,128.84 252.58,128.89 252.58,129.2 252.77,129.39 253.76,129.39 254.03,129.65 254.03,130.05 254.31,130.33 v2(254.31,130.47)
  BOTTOM w0.102: v2(254.31,130.47) 254.35,130.43 254.79,130.43 255.08,130.15 255.33,130.15 UG6.BM3
  BOTTOM w0.14: RG150.1 241.92,121.78 242.19,122.06 242.19,122.98 242.53,123.32 242.53,124.03 242.7,124.19 243.32,124.19 243.51,124 UG8.2 243.51,122.44 243.74,122.21 244.25,122.21 244.55,121.91 244.55,120.48 245.03,120 v1(245.15,120)
NVVDD_PGOOD: length 106
  TOP w0.14: v1(247,114.57) 247.17,114.39 RG94.1 246.81,113.55 246.6,113.77 DG1.1 ; PR188.2 266.26,79.85 v1(266.43,79.67)
  IN1 w0.086: v1(285.02,111.46) 284.6,111.88 283.59,111.88 283.41,111.7 260.33,111.7 257.79,114.24 257.79,115.02 v1(257.22,115.58)
  IN2 w0.089: v1(257.22,115.58) 256.88,115.24 254.16,115.24 253.84,115.57 253.13,115.57 252.1,114.54 251.4,114.54 250.9,115.04 247.47,115.04 v1(247,114.57) ; v1(266.43,79.67) 266.43,80.48 269.73,83.78 272.36,83.78 274.65,86.07 279.63,86.07 283.59,90.04 286.49,90.04 287.22,89.31 291.37,89.31 291.91,89.85 291.91,92.44 292.21,92.75 292.21,97.75 292.8,98.34 292.8,107.16 289.19,110.77 288.47,110.77 287.01,112.23 286.08,112.23 285.31,111.46 v1(285.02,111.46)
  BOTTOM w0.14: QG21.2 256.31,116 256.73,115.58 v1(257.22,115.58) 257.62,115.18 258.68,115.18 RG182.2
NVVDD_PSI: length 152.3
  TOP w0.102: PR186.2 267.72,79.9 267.87,80.05 v1(267.9,80.05)
  IN1 w0.086: v2(256.4,129.77) 255.74,129.77 255.35,130.16 254.69,130.16 254.26,129.73 254.26,127.88 253.55,127.17 253.55,125.63 252.43,124.52 252.43,122.7 252.12,122.39 252.12,120.27 249.97,118.12 249.97,116.71 249.18,115.92 249.18,115.39 246.05,112.27 212.79,112.27 211.08,110.55 211.08,109.69 210.94,109.55 210.94,104.92 210.09,104.07 210.09,102.23 209.5,101.63 209.5,99.45 209.02,98.97 209.02,97.42 210.44,96 212.76,96 v1(213.7,95.06)
  IN2 w0.089: v1(267.9,80.05) 268.46,79.49 268.46,77.08 267.08,75.71 264.41,75.71 263.88,75.17 260.86,75.17 260.53,74.84 259.62,74.84 259.08,74.31 256.01,74.31 255.62,74.7 254.7,74.7 253.8,75.6 253.39,75.6 250.42,78.58 v1(250.42,79.03)
  IN3 w0.089: v1(232.77,84.55) 232.7,84.62 225.03,84.62 222.88,86.77 220.36,86.77 220.12,87.01 217.39,87.01 216.66,87.74 216.66,88.51 215.43,89.74 215.43,94.85 215.01,95.26 213.9,95.26 v1(213.7,95.06)
  IN4 w0.086: v1(250.42,79.03) 250.22,79.23 236.34,79.23 233.02,82.56 233.02,84.3 v1(232.77,84.55)
  BOTTOM w0.102: v2(256.4,129.77) 256.4,129.79 256.73,130.12 UG6.BM1
NVVDD_PWM_GPU: length 99.5
  TOP w0.14: v1(266.09,81.34) 265.91,81.16 PR183.2
  IN3 w0.089: v1(266.09,81.34) 268.33,81.34 269.7,82.72 280.22,82.72 280.79,83.29 280.79,83.64 284.1,86.96 288.01,86.96 289.5,88.45 290.37,88.45 292.01,90.09 292.01,90.53 292.34,90.87 292.34,94.15 292.08,94.41 292.08,99.79 293.3,101 293.3,105.96 287.47,111.78 287.47,112.19 286.54,113.12 285.36,113.12 283.28,115.2 277.95,115.2 277.63,114.87 270.45,114.87 v1(269.86,115.47)
  IN4 w0.086: v1(269.86,115.47) 269.86,118.27 269.25,118.87 266.95,118.87 266,117.93 265.56,117.93 265.1,118.39 265.1,120.22 265.31,120.43 265.31,120.92 264.89,121.34 263.52,121.34 263.17,121.68 263.17,122.25 261.6,123.82 261.6,124.14 260.38,125.36 259.76,125.36 258.94,126.18 258.94,127.17 257.75,128.36 v2(256.39,128.36)
  BOTTOM w0.102: v2(256.39,128.36) 256.39,128.38 UG6.BP2
NVVDD_SENSE_I: length 23.5
  TOP w0.14: PR69.2 225.29,208.11 v1(225.11,208.29)
  IN4 w0.086: v1(225.11,208.29) 224.55,207.74 224.55,204.66 226.5,202.71 226.5,197.06 228.92,194.64 228.92,192.59 229.3,192.22 229.3,191.98 229.09,191.77 v1(228.99,191.77)
  BOTTOM w0.14: v1(228.99,191.77) 228.99,191.49 228.73,191.23 226.03,191.23 225.89,191.37 225.89,191.45 226,191.55 PR479.2
NVVDD_SENSE_V: length 25.1
  TOP w0.14: PR78.2 225.34,207.57 v1(225.09,207.32)
  IN4 w0.086: v1(229.63,191.76) 229.47,191.92 229.47,192.28 229.09,192.66 229.09,194.71 226.67,197.13 226.67,202.78 224.72,204.73 224.72,206.95 v1(225.09,207.32)
  BOTTOM w0.14: PR400.1 v1(225.81,207.61) 225.38,207.61 v1(225.09,207.32) ; PR480.2 225.45,191.55 225.62,191.37 225.62,191.26 225.92,190.96 228.84,190.96 v1(229.63,191.76)
OUT_DP_TXN0: length 3
  BOTTOM w0.14: C861.2 18.98,18.69 18.98,18.95 18.98,19.05 18.98,19.51 19.57,20.1 19.57,20.55 19.62,20.59 U56.39
OUT_DP_TXN1: length 2.9
  BOTTOM w0.14: U56.36 20.82,20.57 20.77,20.53 20.77,19.51 21.05,19.23 21.05,18.67 C865.2
OUT_DP_TXN2: length 3.5
  BOTTOM w0.14: U56.34 21.62,20.54 21.66,20.49 21.66,19.78 22.25,19.2 22.54,19.2 22.82,18.91 22.82,18.68 C863.2
OUT_DP_TXN3: length 4.1
  BOTTOM w0.14: U56.31 22.82,20.58 22.86,20.54 22.86,20.32 23.86,19.32 24.55,19.32 24.91,18.96 24.91,18.7 C866.2
OUT_DP_TXP0: length 3
  BOTTOM w0.14: C862.2 18.66,18.66 18.66,18.95 18.66,19.05 18.66,19.64 19.26,20.23 19.26,20.56 19.22,20.6 U56.40
OUT_DP_TXP1: length 2.9
  BOTTOM w0.14: U56.37 20.42,20.6 20.46,20.56 20.46,19.38 20.73,19.1 20.73,18.67 C868.2
OUT_DP_TXP2: length 3.5
  BOTTOM w0.14: U56.33 22.02,20.55 21.98,20.52 21.98,19.91 22.38,19.51 22.67,19.51 23.14,19.04 23.14,18.71 C864.2
OUT_DP_TXP3: length 4.1
  BOTTOM w0.14: C867.2 25.23,18.69 25.23,19.09 24.69,19.64 23.99,19.64 23.17,20.45 23.17,20.57 23.22,20.61 U56.30
OVERT#: length 18
  IN4 w0.086: v2(252.19,132.57) 252.46,132.3 253.97,132.3 254.24,132.57 256.1,132.57 256.98,131.69 257.73,131.69 258.7,130.72 258.7,129.18 260.44,127.43 v1(260.44,127.11)
  BOTTOM w0.102: UG6.BK7 252.55,131.58 252.19,131.94 v2(252.19,132.57)
  BOTTOM w0.14: v1(260.44,127.11) 260.44,127.69 v1(260.8,128.04) 260.96,128.21 QG19.1 261.75,128.21 262.46,128.92 262.94,128.92 263.1,129.07 RG129.2
PANEL_OD: length 30
  TOP w0.14: v1(280.29,196.58) 280.14,196.74 276.74,196.74 276.33,196.33 276.33,195.52 275.77,194.96 273.79,194.96 272.68,193.85 CN2.20
  IN3 w0.089: v1(280.29,196.58) 282.48,196.58 283.49,195.57 283.49,189.09 v1(282.81,188.41)
  BOTTOM w0.14: v1(282.81,188.41) 283.8,187.41 283.8,185.61 284.45,184.96 Q128.3 284.99,185.13 285.53,185.66 R1229.2 R1230.2
PANEL_OD_R: length 200.2
  TOP w0.14: v1(215.8,76.46) 215.31,76.46 214.86,76.01 214.07,76.01 213.77,76.32 213.77,79.29 212.55,80.51 212.55,81.55 212.25,81.85 212.25,82.59 212.6,82.95 212.6,84.77 213.08,85.26 213.44,85.26 213.85,85.66 213.85,85.81 214.25,86.22 214.25,87.24 214.1,87.39 214.1,93.36 212.02,95.44 212.02,101.05 v1(212.45,101.49)
  IN2 w0.089: v1(282.82,113.82) 280.13,113.82 278.09,111.78 249.04,111.78 248.79,112.03 226.48,112.03 221.54,116.97 215.19,116.97 212.37,114.15 212.37,109.74 212.53,109.59 212.53,101.56 v1(212.45,101.49)
  IN4 w0.086: v1(282.82,113.82) 282.82,113.87 285.04,116.08 285.04,120.3 282.89,122.45 282.89,133.63 283.76,134.5 284.64,134.5 286.74,136.61 286.74,138.38 282.8,142.33 282.8,151.33 283.79,152.32 283.79,161.59 286.61,164.42 v1(286.61,184.49)
  BOTTOM w0.102: U49.AJ8 215.59,76.46 v1(215.8,76.46)
  BOTTOM w0.14: R1229.1 286.26,186.14 286.59,185.81 286.59,184.52 v1(286.61,184.49) 286.61,183.65 286.22,183.26 Q128.2
PBLED: length 229
  TOP w0.14: R484.1 189.88,65.35 v1(190.07,65.16)
  IN3 w0.089: v1(267.49,196.89) 267.8,196.89 268.18,196.51 268.18,195.24 267.97,195.03 267.97,192.62 267.83,192.48 267.83,189.83 268.66,188.99 272.74,188.99 273.08,189.33 277.55,189.33 280.71,186.16 280.71,154.4 279.27,152.96 279.27,139.46 276.44,136.63 276.44,135.55 271.52,130.63 268.96,130.63 266.27,127.95 264.57,127.95 263.13,126.51 261.04,126.51 260.78,126.25 260.78,125.5 259.76,124.47 258.32,124.47 257.38,123.53 256.07,123.53 255.65,123.95 254.47,123.95 254.11,123.59 254.11,122.46 250.71,119.06 247.47,119.06 246.42,120.12 245.62,120.12 245.27,120.47 244,120.47 242.99,121.48 240.89,121.48 237.18,125.19 226.89,125.19 223.6,121.9 215.3,121.9 214.1,120.7 209.44,120.7 202.12,113.38 202.12,107.33 202.72,106.73 202.72,105.79 202.09,105.16 201.19,105.16 198.96,102.93 198.96,102.07 198.87,101.98 196.16,101.98 195.73,101.55 195.73,88.93 194.71,87.91 194.71,78.19 194.57,78.05 194.57,65.8 v1(194.82,65.55)
  IN4 w0.086: v1(190.07,65.16) 190.43,65.16 190.83,65.56 194.81,65.56 v1(194.82,65.55)
  BOTTOM w0.14: R731.2 266.22,194.81 266.72,195.3 Q83.2 267.53,195.63 266.98,196.18 266.98,196.38 v1(267.49,196.89)
PBLED#: length 4.4
  TOP w0.14: v1(267.48,198.84) 267.19,198.55 CN1.7
  BOTTOM w0.14: v1(267.48,198.84) 267.23,198.59 D53.1 ; D53.1 266.62,197.35 Q83.3 ; D53.1 266.62,199.44 v1(266.58,199.48)
PBLED_R: length 5.6
  TOP w0.14: R484.2 187.65,65.35 187.35,65.05 186.94,65.05 186.71,65.29 C452.1 186.71,65.59 186.57,65.73 186.37,65.73 185.94,65.3 184.41,65.3 U23.81
PCBEEP_EC: length 200.1
  TOP w0.14: D26.2 319.67,78.06 v1(318.35,76.74) ; v1(173.21,59.74) 173.05,59.58 173.05,59.09 172.19,58.23 170.05,58.23 169.91,58.09 U23.34
  IN2 w0.089: v1(303.51,73.32) 302.69,74.13 302.01,74.13 300.9,75.24 300.9,76.74 300.05,77.59 297.66,77.59 297.44,77.81 291.98,77.81 290.96,76.8 288.22,76.8 285.97,74.55 285.97,74.04 284.82,72.88 284.82,70.49 282.41,68.08 282.41,63.72 283.57,62.56 283.57,61.73 284.74,60.57 284.74,59.41 284.61,59.28 284.3,58.97 283.31,58.97 283.05,58.71 283.05,58.46 281.02,56.43 280.15,56.43 279.4,55.69 279.4,54.62 278.63,53.85 278.63,53.78 274.33,49.48 270.11,49.48 267.84,47.21 257.3,47.21 256.77,47.74 248.69,47.74 247.94,46.99 243.06,46.99 241.81,45.74 238.57,45.74 238.28,46.03 229.47,46.03 228.23,44.79 228.23,43.46 227.09,42.32 223.68,42.32 223.07,42.93 212.9,42.93 210.93,40.97 206.46,40.97 206.41,41.02 202.95,41.02 202.13,41.84 195.41,41.84 195.15,42.09 194.81,42.09 194.2,42.7 192.59,42.7 192.26,43.03 191.86,43.03 186.7,48.18 186.06,48.18 184.69,49.56 184.69,51.83 183,53.52 182.48,53.52 181.59,54.41 179.48,54.41 178.02,55.87 178.02,56.85 177.85,57.03 177.85,57.04 175.99,58.9 173.87,58.9 173.21,59.56 v1(173.21,59.74)
  IN3 w0.089: v1(318.35,76.74) 318.35,77.17 317.86,77.66 316.36,77.66 315.13,78.89 312.28,78.89 311.97,78.58 311.97,77.56 311.79,77.38 310.95,77.38 308.95,75.38 308.95,73.75 306.97,71.77 305.54,71.77 305.15,72.16 305.15,72.72 304.55,73.32 v1(303.51,73.32)
PCH_2_CPU_TRIG: length 166.1
  IN2 w0.089: v1(125.84,143.73) 125.84,144.18 125.45,144.57 123.93,144.57 123.81,144.45 122.17,144.45 121.58,145.04 120.51,145.04 119.03,143.56 119.03,142.24 119.35,141.92 119.66,141.92 119.89,141.69 119.89,140.32 114.31,134.75 113.04,134.75 112.39,134.1 112.39,127.03 111.36,125.99 111.36,124.02 112.37,123.01 123.21,123.01 125.42,120.79 179.15,120.79 193.63,106.31 193.63,105.35 199.28,99.7 199.28,90.28 200.09,89.46 201.35,89.46 206.38,84.43 207.38,84.43 209.15,82.66 209.62,82.66 210.06,82.22 211.52,82.22 212.21,82.91 214.04,82.91 214.81,83.69 217.26,83.69 v1(217.35,83.78)
  BOTTOM w0.102: U42.CT23 127.93,143.19 127.62,142.89 127.06,142.89 126.96,142.99
  BOTTOM w0.14: v1(217.35,83.78) 217.48,83.65 R906.1 ; 126.96,142.99 126.83,143.12 126.44,143.12 v1(125.84,143.73)
PCH_2_CPU_TRIG_R: length 5.3
  BOTTOM w0.102: U49.AL4 216.55,78.45 216.55,78.85 216.32,79.08 216.32,80.54 216.72,80.94 216.72,81.9 217.48,82.66 R906.2
PCH_AZ_CODEC_RST#_PD: length 3.5
  TOP w0.14: Q23.3 306.64,87.43 307.67,86.4 v1(307.67,86.07) 308.34,85.4 D20.1
PCH_BLON_EC: length 220.5
  TOP w0.14: U23.88 186.88,68.1 187.04,67.94 189.24,67.94 190,67.18 190.98,67.18 191.43,66.73 v1(191.44,66.73)
  IN3 w0.089: v1(198.4,68) 198.81,68.42 198.81,69.79 198.53,70.07 198.53,76.4 198.74,76.61 198.74,80.36 198.84,80.47 198.84,86.29 199.77,87.22 199.77,93.26 202.66,96.16 203.18,96.16 208.06,101.04 208.06,102.78 208.75,103.47 208.75,105.26 209.51,106.01 209.51,109.96 210.06,110.51 210.06,110.98 212.81,113.73 240.53,113.73 240.82,114.01 244.1,114.01 244.59,113.52 247.94,113.52 248.36,113.94 260.99,113.94 261.34,114.3 261.34,115.23 261.34,115.23 261.34,116.1 263.29,118.05 264.11,118.05 265,118.94 268.41,118.94 269.04,119.57 269.04,121.72 272.18,124.86 272.18,125.19 275.67,128.68 277.6,128.68 280.43,131.52 280.43,152.48 281.87,153.92 281.87,187.05 279.55,189.38 279.55,190.86 279.75,191.06 279.75,192.46 279.55,192.66 279.55,193.22 v1(279.84,193.52)
  IN4 w0.086: v1(191.44,66.73) 196.45,66.73 197.52,67.81 198.2,67.81 v1(198.4,68)
  BOTTOM w0.14: v1(279.84,193.52) 279.26,194.1 279.26,195.56 279.69,196 279.69,198.97 279.73,199.01 279.73,202.05 279.4,202.38 278.75,202.38 278.49,202.64 R718.1
PCH_DISP_ON: length 160.2
  TOP w0.14: v1(262.46,123.97) 262.46,123.61 263.17,122.9 265.46,122.9 266.12,122.24 266.12,120.99 265.4,120.28 265.4,119.89 266.51,118.78 268.46,118.78 269.67,117.56 269.67,116.32 270.34,115.66 270.34,114.19 TP20.1 ; R571.1 208.19,57.76 v1(208.29,57.87)
  IN3 w0.089: v1(262.46,123.97) 263.93,123.97 265.88,122.03 265.88,121.21 264.77,120.1 262.94,120.1 262.68,119.85 261.77,119.85 261.29,119.37 261.29,117.92 259.87,116.5 259.26,116.5 259.2,116.56 258.8,116.56 258.68,116.44 256.23,116.44 255.95,116.16 254.66,116.16 254.48,116.35 249.63,116.35 249.25,115.96 249.25,115.63 249.03,115.41 248.68,115.41 247.96,116.13 244.53,116.13 243.48,115.08 240.38,115.08 240.09,114.79 231.72,114.79 231.16,115.36 230.33,115.36 229.88,114.9 212.3,114.9 207.98,110.59 207.98,106 206.99,105 206.99,101.74 206.06,100.8 205.46,100.8 203.91,99.26 203.91,98.44 202.71,97.24 202.23,97.24 198.7,93.71 198.7,87.66 197.63,86.59 197.63,77.01 197.46,76.84 197.46,68.66 197.55,68.57 197.55,67.65 197.85,67.35 197.85,64.21 198.26,63.8 198.26,61.94 197.69,61.37 197.69,60.87 198.22,60.34 201.54,60.34 203.26,58.62 203.26,57.48 204.22,56.52 205.34,56.52 205.98,55.89 206.59,55.89 208.13,57.42 208.13,57.7 v1(208.29,57.87)
  BOTTOM w0.102: v1(208.29,57.87) 208.83,57.87 208.89,57.92 209.64,57.92 U49.V45
  BOTTOM w0.14: U43.1 262.53,123.9 v1(262.46,123.97)
PCH_DMIC_CLK: length 201.4
  TOP w0.14: v1(234.55,78.28) 234.55,78.17 235.38,77.33 235.38,75.61 234.93,75.16 233.56,75.16 233.3,74.91 232.33,74.91 231.52,75.72 229.49,75.72 228.45,74.68 v1(227.88,74.68) 227.21,74.01 U17.3 227.05,70.46 226.54,70.46 R432.1 ; v1(278.26,190.89) 278.37,191 278.9,191 R61.1
  IN1 w0.086: v1(234.55,78.28) 234.78,78.04 235.77,78.04 236.85,76.96 245.66,76.96 246.81,78.1 247.67,78.1 250.67,81.1 250.67,83.87 253.5,86.7 258.3,86.7 258.99,86.01 264.71,86.01 265.35,86.65 270.93,86.65 271.27,86.31 272.2,86.31 272.57,86.68 273.47,86.68 274.06,86.09 279.79,86.09 279.85,86.15 280.86,86.15 283.89,89.19 284.99,89.19 285.79,88.39 286.62,88.39 287.09,87.93 291.02,87.93 292.98,89.89 292.98,95.29 292.97,95.3 293.15,95.48 293.15,105.61 288.5,110.27 288.5,110.98 287.61,111.87 287.61,112.09 286.37,113.33 286.31,113.33 285.34,114.3 285.05,114.3 282.98,116.37 282.65,116.37 280,119.01 280,132.09 277.59,134.5 277.59,136.14 278.03,136.59 278.61,136.59 280.8,138.78 280.8,153.89 284.12,157.22 284.12,160.64 283.59,161.17 283.59,165.79 284.12,166.32 284.12,170.68 283.69,171.12 283.69,174.96 284.14,175.41 284.14,178.94 283.99,179.09 283.99,180.13 284.19,180.33 284.19,183.38 278.72,188.84 278.72,190.59 278.43,190.89 v1(278.26,190.89)
PCH_DMIC_DAT: length 208.2
  TOP w0.14: U19.3 225.43,67.27 R461.1 R460.1 223.45,67.7 223.45,68.49 222.9,69.04 222.9,73.44 226.03,76.57 228.86,76.57 229.27,76.97 232.34,76.97 233.25,76.06 234.04,76.06 234.36,76.38 234.36,77.27 233.93,77.7 233.93,78.67 v1(234.04,78.78) ; v1(278.08,192.29) 278.08,192.42 278.22,192.56 R59.1
  IN1 w0.086: v1(278.08,192.29) 278.08,191.28 277.81,191.01 277.81,190.47 278.38,189.9 278.38,188.46 283.75,183.09 283.75,180.37 283.65,180.27 283.65,178.73 283.8,178.58 283.8,175.56 283.35,175.11 283.35,170.93 283.25,170.83 283.25,156.83 280.46,154.03 280.46,138.92 278.47,136.93 277.89,136.93 277.25,136.29 277.25,134.36 279.66,131.95 279.66,118.87 284.66,113.87 284.66,113.8 285.48,112.99 286.22,112.99 287.27,111.95 287.27,111.73 288.15,110.84 288.15,110.13 292.81,105.47 292.81,95.62 292.63,95.44 292.63,95.16 292.64,95.15 292.64,90.03 290.88,88.27 287.23,88.27 286.76,88.73 285.93,88.73 285.13,89.53 283.75,89.53 280.72,86.49 279.35,86.49 278.74,87.1 272.26,87.1 272.16,86.99 265.21,86.99 264.57,86.35 259.13,86.35 258.44,87.04 253.36,87.04 250.33,84.01 250.33,81.24 247.53,78.44 246.67,78.44 245.52,77.3 237,77.3 235.61,78.68 234.14,78.68 v1(234.04,78.78)
PCH_DPST_PWM: length 204.9
  TOP w0.14: R499.1 204.32,62.96 204.48,63.11 v1(206.64,63.11) ; v1(282.96,178.16) 283.1,178.31 U4.7
  IN1 w0.086: v1(282.96,178.16) 283.33,177.79 283.33,176.49 281.55,174.71 281.55,157.11 279.06,154.62 279.06,139.5 278.57,139.01 277.35,139.01 275.85,137.51 275.85,135.22 275.01,134.38 275.01,127.31 275.45,126.86 275.45,126.24 274.3,125.09 272.41,125.09 269.58,122.26 265.11,122.26 264.63,122.74 261.16,122.74 259.73,124.17 258.34,124.17 257.64,123.46 256.75,123.46 254.88,121.59 254.88,119.81 252.53,117.46 252.53,114.67 251.95,114.09 248.94,114.09 246.37,111.51 213.18,111.51 212.84,111.18 212.84,110.09 v1(212.09,109.34)
  IN3 w0.089: v1(212.09,109.34) 212.09,106.82 211.49,106.22 211.49,104.42 210.94,103.88 210.94,100.61 210.49,100.16 210.49,98.78 209.86,98.14 208.5,98.14 203.46,93.09 203.46,89.65 203.46,89.65 203.46,88.43 204.6,87.28 204.6,83.13 204.49,83.02 204.49,82.66 204.71,82.44 205.15,82.44 205.72,81.87 205.72,78.71 204.23,77.22 204.23,76.36 203.78,75.9 203.17,75.9 202.79,75.53 202.79,75.13 203.45,74.47 203.45,73.59 203.75,73.28 203.75,72.82 202.79,71.86 202.79,70.47 201.97,69.65 201.97,67.35 200.61,65.99 200.61,65.24 199.58,64.21 199.58,62.35 199.71,62.23 200.32,62.23 200.68,62.6 200.68,63.26 201.15,63.73 205.06,63.73 205.59,63.21 206.55,63.21 v1(206.64,63.11)
  BOTTOM w0.102: U49.T35 208.63,62.79 206.97,62.79 v1(206.64,63.11)
PCH_LVDS_BLON: length 135.9
  TOP w0.14: TP23.1 265.13,116.22 v1(265.13,115.84) ; R516.1 209.41,62.2 208.54,61.33 v1(208.54,61.33)
  IN1 w0.086: v1(267.32,119.34) 266.36,118.37 266.36,117.06 v1(265.13,115.84)
  IN3 w0.089: v1(208.54,61.33) 207.71,62.17 205.13,62.17 204.51,62.78 202.45,62.78 201.7,62.04 199.63,62.04 199.39,62.28 199.39,64.29 200.42,65.32 200.42,66.07 201.78,67.43 201.78,69.82 202.6,70.64 202.6,71.94 202.92,72.26 202.92,74.73 202.6,75.05 202.6,75.61 203.09,76.1 203.7,76.1 204.04,76.44 204.04,77.3 205.53,78.79 205.53,81.79 205.07,82.25 204.63,82.25 203.8,83.08 203.8,83.08 203.8,87.6 203.47,87.92 202.59,88.8 202.59,89.42 203.17,90 203.17,93.08 208.43,98.33 209.78,98.33 210.3,98.86 210.3,100.24 210.75,100.69 210.75,103.95 211.3,104.5 211.3,106.3 211.9,106.9 211.9,108.91 211.62,109.19 211.62,109.54 212.65,110.57 212.65,111.3 213.47,112.13 240.34,112.13 240.68,111.78 251.06,111.78 251.62,112.34 261.65,112.34 265.13,115.82 v1(265.13,115.84)
  BOTTOM w0.102: U49.T37 208.9,61.69 208.54,61.33 v1(208.54,61.33)
  BOTTOM w0.14: QG25.3 265.07,115.78 v1(265.13,115.84) ; v1(267.32,119.34) 267.32,119.75 267.53,119.96 267.53,121.31 267.39,121.45 U45.1
PCH_PWROK: length 45.9
  TOP w0.14: R632.2 207.55,42.79 v1(207.55,41.85) ; U23.78 182.81,64.1 182.49,63.78 182.49,62.56 182.35,62.42 181.82,62.42 181.38,61.97 181.38,59.49 183.87,57 183.87,53.91 v1(182.96,53)
  IN4 w0.086: v1(207.55,41.85) 206.91,41.22 199.95,41.22 194.99,46.17 192.05,46.17 185.23,53 v1(182.96,53)
PCH_SLP_S0IX#: length 18.3
  TOP w0.14: v1(232.31,68.29) 233.43,68.29 233.79,67.93 R441.1
  BOTTOM w0.102: U49.BE40 223.76,59.72 223.88,59.84 224.39,59.84 224.59,60.03 225.29,60.03 225.62,59.7 226.79,59.7 227.26,60.17 227.26,60.64 227.57,60.96 228.72,60.96 R1006.1 228.91,61.38 229.03,61.51 229.46,61.51 229.56,61.61 229.56,62.09 229.87,62.4 230.23,62.4 230.33,62.5 230.33,62.72 230.64,63.02
  BOTTOM w0.14: 230.64,63.02 230.71,63.1 231.36,63.1 231.64,63.38 231.64,66.44 232.31,67.11 v1(232.31,68.29)
PCH_SPI1_CLK: length 40.6
  IN1 w0.086: v1(248.95,57.98) 248.95,58.01 248.46,58.49 246.62,58.49 245.69,57.57 244.29,57.57 242.73,56 239.91,56 238.21,54.31 237.4,54.31 236.2,55.5 233.16,55.5 233.13,55.53 230.42,55.53 230.09,55.86 227.43,55.86 226.84,56.45 224.9,56.45 223.8,57.55 222.46,57.55 221.45,58.56 220.29,58.56 219.23,59.63 217.78,59.63 v1(217,60.41)
  BOTTOM w0.102: U49.AN39 217.46,60.41 v1(217,60.41)
  BOTTOM w0.14: v1(248.95,57.98) 248.95,58.29 248.11,59.13 246.98,59.13 246.84,59 RS2.2 246.51,59 246.41,59.09 R1020.1
PCH_SPI1_CLK_R: length 2.4
  BOTTOM w0.14: R1015.2 R1016.1 245.37,59.45 R1020.2 245.73,58.92 R1029.1
PCH_SPI1_SI: length 35.6
  TOP w0.14: R508.1 218.36,62.05 v1(218.17,62.24) 217.92,62.49 217.92,63.14 218.1,63.32 218.88,63.32 219.53,63.97 220.38,63.97 220.55,63.8 R492.2
  IN1 w0.086: v1(243.08,57.62) 243.06,57.6 238.69,57.6 237.98,56.89 233.32,56.89 232.89,56.47 231.45,56.47 230.37,57.54 229.51,57.54 228.76,56.79 227.82,56.79 227.23,57.39 225.28,57.39 223.07,59.6 223.07,59.86 222.41,60.52 221.64,60.52 220.96,61.2 218.91,61.2 218.17,61.93 v1(218.17,62.24)
  BOTTOM w0.102: U49.AP35 217.94,62.24 v1(218.17,62.24)
  BOTTOM w0.14: v1(243.08,57.62) 243.08,57.62 243.08,57.86 243.72,58.5 R1024.1
PCH_SPI1_SI_R: length 2.9
  BOTTOM w0.14: R1043.1 R1042.1 244.17,58.37 R1024.2 244.17,59.02 243.74,59.45 R1014.2
PCH_SPI1_SO: length 28.8
  IN1 w0.086: v1(237.84,54.81) 236.28,56.37 233.45,56.37 233.08,56 231.25,56 230.18,57.07 229.7,57.07 228.96,56.33 227.62,56.33 227.03,56.92 225.09,56.92 223.04,58.97 222.43,58.97 221.36,60.03 220.42,60.03 219.78,60.67 218.75,60.67 v1(218.18,61.23)
  BOTTOM w0.102: U49.AP37 217.72,61.69 v1(218.18,61.23)
  BOTTOM w0.14: R1111.1 236.77,50.82 237.11,51.16 237.11,52 237.33,52.22 237.33,54.3 v1(237.84,54.81)
PCH_SPI1_SO_R: length 2.4
  BOTTOM w0.14: R1110.2 R1131.1 R1132.1 R1111.2
PCH_SPI_CLK_EC: length 111.1
  TOP w0.14: v1(178.11,60.68) 178.11,61.6 178.32,61.82 178.32,63.2 179.17,64.05 179.17,66.06 178.06,67.17 178.06,70.52 178.71,71.17 U23.105
  IN2 w0.089: v1(178.11,60.68) 178.11,60.43 180.73,57.81 180.85,57.81 182.37,56.29 182.89,56.29 186.19,52.98 187.07,52.98 187.24,52.81 187.24,50.3 192.39,45.16 193.81,45.16 194.38,44.58 200.1,44.58 200.7,43.99 204.43,43.99 204.83,43.59 209.41,43.59 209.62,43.38 209.96,43.38 211.39,44.81 222.23,44.81 225.49,48.07 229.36,48.07 229.52,47.91 237.81,47.91 237.96,48.07 241.31,48.07 242.11,48.86 246.65,48.86 247.51,49.73 v1(247.51,49.8)
  BOTTOM w0.14: v1(247.51,49.8) 247.51,50.02 247.88,50.38 247.88,51.31 247.72,51.47 247.72,51.93 248.1,52.32 249.22,52.32 249.41,52.5 249.41,54.77 250.24,55.61 250.24,58.07 248.66,59.65 247.15,59.65 246.28,60.52 245.7,60.52 R1016.2
PCH_SPI_CS0#: length 32.5
  IN1 w0.086: v1(237.8,53.71) 237.34,53.71 236.01,55.04 232.96,55.04 232.93,55.06 230.22,55.06 229.9,55.39 227.24,55.39 226.65,55.98 224.71,55.98 223.7,56.99 221.73,56.99 220.96,57.75 220.38,57.75 219.2,58.93 v1(219.03,58.93)
  BOTTOM w0.102: v1(219.03,58.93) 218.44,58.93 U49.AR42
  BOTTOM w0.14: v1(237.8,53.71) 237.91,53.59 237.91,53.15 238.28,52.78 238.28,52.59 238.01,52.32 238.01,52.12 238.18,51.95 238.37,51.95 238.64,52.22 238.84,52.22 239.01,52.05 239.01,51.85 238.71,51.55 238.71,51.35 238.85,51.21 239.11,51.21 239.38,51.48 239.58,51.48 240.05,51.01 240.8,51.01 240.94,50.87 240.94,50.5 240.8,50.36 238.76,50.36 238.15,50.97 238.15,51.16 237.91,51.39 R1086.1
PCH_SPI_CS0#_R: length 2.3
  BOTTOM w0.14: R1129.1 R1108.1 237.37,49.96 237.23,50.09 237.23,50.55 R1086.2
PCH_SPI_IO2: length 25.1
  TOP w0.14: R568.2 218.64,57.24 v2(218.64,57.25) 218.64,57.83 R562.1
  IN1 w0.086: v2(218.64,57.25) 219.25,57.25 220.07,56.43 220.97,56.43 221.34,56.05 222.7,56.05 224.13,54.63 226.68,54.63 226.85,54.46 229.51,54.46 229.84,54.13 231.33,54.13 231.78,53.68 232.72,53.68 233.14,54.1 235.07,54.1 235.87,53.3 236.12,53.3 v1(236.26,53.16)
  BOTTOM w0.102: U49.AR43 218.56,57.33 v2(218.64,57.25)
  BOTTOM w0.14: R1109.1 235.34,50.66 235.53,50.86 235.53,51.06 236.06,51.59 236.06,52.85 236.26,53.05 v1(236.26,53.16)
PCH_SPI_IO2_R: length 0.8
  BOTTOM w0.14: R1130.1 R1109.2
PCH_SPI_IO3: length 41.1
  TOP w0.14: R547.2 216.85,59.64 v1(217.24,59.25) 217.16,59.16 R558.1
  IN1 w0.086: v1(248.3,57.99) 247.4,57.09 244.48,57.09 242.93,55.54 240.19,55.54 237.89,53.24 237.14,53.24 236.78,53.61 236.78,53.61 235.81,54.57 232.95,54.57 232.52,54.15 231.97,54.15 231.53,54.6 230.03,54.6 229.7,54.93 227.04,54.93 226.79,55.18 224.24,55.18 222.9,56.52 221.53,56.52 221.16,56.89 220.26,56.89 220.02,57.14 220.02,57.45 219.61,57.86 218.84,57.86 218.29,58.41 217.62,58.41 217.44,58.6 217.44,59.05 v1(217.24,59.25)
  BOTTOM w0.102: v1(217.24,59.25) 216.86,58.87 U49.AM42
  BOTTOM w0.14: v1(248.3,57.99) 247.8,58.49 247.08,58.49 247.06,58.48 246.33,58.48 246.31,58.46 R1030.1
PCH_SPI_IO3_R: length 0.6
  BOTTOM w0.14: R1030.2 R1047.1
PCH_SPI_SI_EC: length 115.5
  TOP w0.14: v1(179.82,60.66) 179.82,60.86 179.89,60.92 179.89,62.75 180.26,63.13 180.26,66.44 179.51,67.19 179.51,69.16 179.55,69.19 179.55,70.5 179.42,70.62 179.42,71.66 179.88,72.12 179.91,72.12 U23.102 179.91,74.74 R360.1 ; v1(246.87,49.79) 246.92,49.85 246.92,51.09 243.5,54.52 v1(242.82,54.52) v1(240.7,54.52)
  IN2 w0.089: v1(179.82,60.66) 179.82,60.05 181.12,58.75 181.24,58.75 182.76,57.23 183.28,57.23 186.58,53.92 187.88,53.92 188.18,53.62 188.18,52.97 188.27,52.88 188.48,52.88 188.57,52.79 188.57,52.51 188.47,52.41 188.27,52.41 188.18,52.32 188.18,52.03 188.27,51.94 189.42,51.94 189.55,51.82 189.55,51.56 189.46,51.47 188.27,51.47 188.18,51.38 188.18,50.69 189.18,49.69 189.31,49.69 189.75,50.13 189.97,50.13 190.13,49.97 190.13,49.85 189.64,49.36 189.64,49.24 192.78,46.1 200.4,46.1 201.01,45.49 204.28,45.49 205.25,44.53 206.58,44.53 207.06,45.01 210.26,45.01 211.36,46.11 219.33,46.11 222.22,49.01 222.67,49.01 223.65,48.03 224.12,48.03 225.1,49.01 231.63,49.01 231.85,49.23 233.33,49.23 233.55,49.01 238.23,49.01 238.59,49.37 239.6,49.37 239.68,49.28 239.68,48.63 239.77,48.54 240.07,48.54 240.15,48.63 240.15,49.28 240.24,49.37 240.54,49.37 240.62,49.28 240.62,48.63 240.71,48.54 241.01,48.54 241.09,48.63 241.09,49.28 241.18,49.37 244.25,49.37 244.28,49.33 246.41,49.33 v1(246.87,49.79)
  BOTTOM w0.14: v1(240.7,54.52) 241.16,54.98 241.16,56.27 241.52,56.64 242.26,56.64 242.77,57.14 243.33,57.14 243.57,57.37 R1042.2
PCH_SPI_SO_EC: length 112.1
  TOP w0.14: v1(179.15,60.63) 179.15,60.98 179.37,61.2 179.37,62.97 179.74,63.35 179.74,66.22 178.58,67.38 178.58,67.9 178.72,68.04 178.85,68.04 178.99,68.18 178.99,68.42 178.85,68.56 178.72,68.56 178.58,68.7 178.58,70.38 179.18,70.98 179.18,71.79 179.51,72.12 U23.103 179.51,74.03 179.27,74.26 179.27,74.87 R359.1
  IN2 w0.089: v1(239.11,48.97) 238.69,48.54 233.22,48.54 233,48.76 232.04,48.76 231.67,48.38 230.39,48.38 230.23,48.54 225.29,48.54 224.14,47.38 223.62,47.38 222.53,48.47 222.4,48.47 222.2,48.27 222.2,48.14 223.48,46.86 223.48,46.73 223.24,46.49 223.12,46.49 221.86,47.75 221.63,47.75 221.44,47.56 221.44,47.43 222.57,46.3 222.57,45.94 222.34,45.7 222.04,45.7 221.15,46.59 220.97,46.59 220.77,46.4 220.77,46.2 221.48,45.5 221.48,45.37 221.39,45.28 220.59,45.28 220.51,45.37 220.51,45.81 220.3,46.01 220.15,46.01 220.04,45.89 220.04,45.37 219.95,45.28 219.65,45.28 219.57,45.37 219.57,45.56 219.48,45.64 219.18,45.64 219.1,45.56 219.1,45.37 219.01,45.28 218.71,45.28 218.63,45.37 218.63,45.56 218.54,45.64 218.24,45.64 218.16,45.56 218.16,45.37 218.07,45.28 217.77,45.28 217.69,45.37 217.69,45.56 217.6,45.64 217.3,45.64 217.22,45.56 217.22,45.37 217.13,45.28 216.83,45.28 216.75,45.37 216.75,45.56 216.66,45.64 216.37,45.64 216.28,45.56 216.28,45.37 216.19,45.28 215.9,45.28 215.81,45.37 215.81,45.56 215.72,45.64 215.43,45.64 215.34,45.56 215.34,45.37 215.25,45.28 214.96,45.28 214.87,45.37 214.87,45.56 214.78,45.64 214.49,45.64 214.4,45.56 214.4,45.37 214.31,45.28 214.02,45.28 213.93,45.37 213.93,45.56 213.84,45.64 213.55,45.64 213.46,45.56 213.46,45.37 213.37,45.28 213.08,45.28 212.99,45.37 212.99,45.56 212.9,45.64 212.61,45.64 212.52,45.56 212.52,45.37 212.43,45.28 212.14,45.28 212.05,45.37 212.05,45.56 211.96,45.64 211.56,45.64 210.1,44.19 209.53,44.19 209.4,44.06 208.93,44.06 208.84,44.15 208.84,44.45 208.75,44.54 208.46,44.54 208.37,44.45 208.37,44.15 208.28,44.06 205.05,44.06 204.09,45.02 200.81,45.02 200.21,45.63 199.74,45.63 199.65,45.54 199.65,45.14 199.56,45.05 199.27,45.05 199.18,45.14 199.18,45.54 199.09,45.63 198.8,45.63 198.71,45.54 198.71,45.14 198.62,45.05 198.33,45.05 198.24,45.14 198.24,45.54 198.15,45.63 197.86,45.63 197.77,45.54 197.77,45.14 197.68,45.05 197.39,45.05 197.3,45.14 197.3,45.54 197.21,45.63 196.92,45.63 196.83,45.54 196.83,45.14 196.74,45.05 196.45,45.05 196.36,45.14 196.36,45.54 196.27,45.63 195.98,45.63 195.89,45.54 195.89,45.14 195.8,45.05 195.51,45.05 195.42,45.14 195.42,45.54 195.33,45.63 195.04,45.63 194.95,45.54 194.95,45.14 194.86,45.05 194.57,45.05 194.48,45.14 194.48,45.54 194.39,45.63 192.59,45.63 187.71,50.5 187.71,53.15 187.41,53.45 186.39,53.45 183.08,56.76 182.56,56.76 181.04,58.28 180.92,58.28 178.97,60.24 178.97,60.45 v1(179.15,60.63)
  BOTTOM w0.14: R1132.2 236.77,48.47 237.13,48.11 238.26,48.11 v1(239.11,48.97)
PCH_TBT_PERST#: length 5.6
  TOP w0.14: U28.2 222.78,57.73 222.56,57.94 222.56,58.75 222.67,58.86 R550.2 222.37,59.18 222.1,58.92 R551.1 221.91,58.91 221.48,58.48 221.19,58.48 221,58.3 221,57.47 221.12,57.36 R575.1
PCIE4_RCOMP_N: length 1.1
  TOP w0.14: R103.2 167.49,144.61 v2(167.48,144.6)
  BOTTOM w0.254: v2(167.48,144.6) 167.48,144.56 U42.R26
PCIE4_RCOMP_P: length 1.2
  TOP w0.14: v2(166.81,144.6) 166.87,144.65 167.04,144.82 R103.1
  BOTTOM w0.254: U42.T26 166.81,144.54 v2(166.81,144.6)
PCIE16_RCOMP_N: length 1.3
  TOP w0.14: R106.2 167.31,135.82 v2(167.53,135.61)
  BOTTOM w0.254: v2(167.53,135.61) 167.52,135.61 167.31,135.35 U42.R11
PCIE16_RCOMP_P: length 1.3
  TOP w0.14: v2(166.64,135.61) 166.86,135.82 R106.1
  BOTTOM w0.254: U42.U11 166.39,135.32 166.62,135.6 v2(166.64,135.61)
PCIE_8_PCH_RX_WWAN_TX_C_N: length 4.4
  TOP w0.14: v1(302.71,83.36) 302.71,83.24 302.94,83 303.08,83 303.47,83.39 304.49,83.39 R252.1
  BOTTOM w0.14: v1(302.71,83.36) 302.71,83.35 302.5,83.14 301.93,83.14 301.82,83.25 CN7.41
PCIE_8_PCH_RX_WWAN_TX_C_P: length 4.4
  TOP w0.14: v1(302.71,82.5) 302.72,82.5 302.95,82.74 303.19,82.74 303.58,83.13 304.43,83.13 R260.1
  BOTTOM w0.14: CN7.43 301.79,82.75 301.91,82.87 302.4,82.87 302.71,82.56 v1(302.71,82.5)
PCIE_8_PCH_TX_WWAN_RX_C_N: length 15.4
  BOTTOM w0.14: CN7.47 301.76,81.75 301.87,81.64 302.49,81.64 302.61,81.52 304.07,81.52 304.92,82.37 304.92,84.07 305.51,84.67 305.51,87.36 307.33,89.17 310.17,89.17 C721.1
PCIE_8_PCH_TX_WWAN_RX_C_P: length 15.4
  BOTTOM w0.14: CN7.49 301.77,81.25 301.88,81.37 302.38,81.37 302.5,81.25 304.18,81.25 305.19,82.26 305.19,83.96 305.78,84.56 305.78,87.25 307.44,88.9 310.17,88.9 C723.1
PCIE_CLKREQ6#: length 3.1
  TOP w0.14: v1(221.62,77.15) 221.62,77.09 221.86,76.84 R346.1 221.86,76.17 222.09,75.95 222.72,75.95 222.91,76.14 TPS1.1
  BOTTOM w0.102: U49.BA7 221.61,77.13 221.62,77.14 v1(221.62,77.15)
PCIE_CLKREQ7#: length 2.5
  TOP w0.14: R369.1 218.56,75.41 v1(218.6,75.45) 218.65,75.5 219.49,75.5 TPS2.1
  BOTTOM w0.102: U49.AR11 218.67,75.35 218.6,75.43 v1(218.6,75.45)
PCIE_CLKREQ_LAN#: length 130.1
  IN2 w0.089: v1(227.03,61.35) 227.03,62.06 227.56,62.59 227.56,63.74 228.24,64.42 229.08,64.42 230.14,63.36 231.73,63.36 232.79,62.29 233.59,62.29 234.75,61.13 238.47,61.13 239.14,60.46 239.14,59.74 239.65,59.23 240.42,59.23 241.62,58.03 243.41,58.03 244.22,58.84 244.22,59.1 244.38,59.26 245.07,59.26 245.3,59.03 253.04,59.03 253.13,59.11 260.21,59.11 261.95,60.85 265.48,60.85 266.33,61.7 267.96,61.7 270.38,64.11 271.56,64.11 272.07,64.62 272.07,64.98 273.48,66.39 273.48,69.18 275.62,71.32 275.62,74.15 276.95,75.49 276.95,75.82 277.29,76.16 277.29,77.07 279.26,79.03 281.92,79.03 282.27,79.39 282.27,80.64 284.6,82.96 286.21,82.96 287.01,83.76 289.53,83.76 289.69,83.92 293.31,83.92 294.35,84.97 295.89,84.97 296.28,85.35 297.02,85.35 298.68,87.01 298.68,87.71 301.28,90.31 303.13,90.31 304.61,88.82 305.03,88.82 305.46,88.39 307.36,88.39 308.87,86.88 308.87,84.46 309.59,83.74 310.57,83.74 311.3,84.47 311.78,84.47 312,84.69 312.47,84.69 313.37,85.59 314.31,85.59 314.53,85.37 314.97,85.37 317.04,83.3 317.11,83.3 v1(317.66,82.75)
  BOTTOM w0.102: U49.BC38 222.86,60.47 223.22,60.47 223.36,60.61 223.65,60.61 223.81,60.44 226.3,60.44 227.03,61.17 v1(227.03,61.35) 227.31,61.35 227.35,61.3 R1005.1
  BOTTOM w0.14: v1(317.66,82.75) 317.34,82.43 317.34,80.79 316.96,80.41 CN10.13
PCIE_CLKREQ_SSD1#: length 192.1
  TOP w0.14: v1(103.41,87.98) 104.76,86.63 104.76,82.71 105.94,81.53 105.94,77.27 105.47,76.8 105.47,74.15 105,73.67 105,71.59 104.14,70.74 103.64,70.74 103,70.1 103,66.41 102.87,66.29 102.87,61.62 v1(100.16,58.91) ; v1(173.91,68.85) 174.54,68.22 174.54,66.17 175.85,64.87 175.85,61.92 175.36,61.42 v1(175.36,60.78)
  IN2 w0.089: v1(100.16,58.91) 100.53,59.28 107.79,59.28 110.7,62.18 111.61,62.18 114.02,64.6 119.89,64.6 120.91,65.62 129.54,65.62 133.87,69.96 158.11,69.96 158.77,69.3 164.52,69.3 165.28,68.54 169.36,68.54 169.48,68.42 173.49,68.42 v1(173.91,68.85)
  IN3 w0.089: v1(175.36,60.78) 175.36,60.76 175.75,60.76 176.89,59.62 179.62,59.62 180.27,58.97 181.58,58.97 181.67,58.88 183.48,58.88 185.32,57.04 186.84,57.04 187.43,56.44 190.15,56.44 190.52,56.81 191.37,56.81 191.59,56.59 191.59,56.28 193.6,54.27 194.82,54.27 196.43,52.67 201.57,52.67 202.06,53.16 202.06,53.53 202.6,54.07 206.92,54.07 208.01,55.15 208.01,55.44 208.66,56.09 210.23,56.09 210.84,56.7 213.41,56.7 213.99,57.28 217.91,57.28 218.27,57.64 220.21,57.64 220.32,57.75 220.83,57.75 221.01,57.93 221.01,58.13 221.34,58.46 221.57,58.46 221.97,58.87 223.34,58.87 223.75,58.46 225.35,58.46 226.34,59.45 227.43,59.45 227.97,59.98 227.97,61.8 v1(228.43,62.26)
  BOTTOM w0.102: R997.1 228.89,62.45 228.69,62.26 v1(228.43,62.26) 228.43,62.15 228.24,61.96 226.79,61.96 226.51,61.69 226.18,61.69 225.97,61.47 225.97,61.14 225.67,60.85 223.98,60.85 223.82,61.01 223.41,61.01 U49.BE38
  BOTTOM w0.14: CN6.52 v1(103.41,87.98)
PCIE_CLKREQ_SSD#: length 206.7
  IN4 w0.086: v1(226.44,62.78) 226.44,62.65 227.44,61.65 227.44,59.63 228.09,58.98 228.61,58.98 228.97,58.62 228.97,58.44 229.66,57.76 229.99,57.76 230.53,57.22 230.53,56.62 231.12,56.02 232.1,56.02 233.72,54.39 233.72,51.25 234.52,50.45 234.52,47.26 232.16,44.9 230.84,44.9 230.56,44.62 230.56,42.94 228.72,41.1 220.76,41.1 219.39,39.73 210.09,39.73 209.18,40.64 199.71,40.64 194.75,45.6 191.81,45.6 185.1,52.31 182.45,52.31 180.77,53.99 178.45,53.99 177.39,55.05 177.39,58.51 176.67,59.23 173.01,59.23 172.5,59.74 172.5,60.29 171.9,60.89 171.36,60.89 170.99,61.25 170.13,61.25 169.73,61.65 169,61.65 166.17,64.47 161.9,64.47 161.67,64.25 154.08,64.25 153.74,63.91 152.48,63.91 149.11,60.54 144.94,60.54 144.67,60.81 142.54,60.81 140.44,58.7 136.85,58.7 135.03,56.88 131.77,56.88 130.79,55.9 126.32,55.9 124.42,53.99 122.17,53.99 119.08,50.91 114.34,50.91 113.68,50.24 112.79,50.24 111.74,49.2 111.51,49.2 110.85,48.53 110.55,48.53 109.8,49.28 106.87,49.28 101.43,54.73 95.89,54.73 v1(94.52,56.1)
  BOTTOM w0.102: U49.BC37 222.59,61.5 222.76,61.67 223.8,61.67 224.07,61.94 224.26,61.94 224.43,62.11 225.31,62.11 225.47,62.27 225.75,62.27 226.27,62.78 v1(226.44,62.78) 226.46,62.8 226.46,62.96 226.92,63.42 228.84,63.42 R994.1
  BOTTOM w0.14: v1(94.52,56.1) 97.13,58.71 97.13,62.29 97.77,62.93 CN13.52
PCIE_CLKREQ_VGA#: length 142.6
  TOP w0.14: QG9.3 237.38,117.37 237.58,117.58 239.48,117.58 v1(239.71,117.36)
  IN3 w0.089: v1(225.45,61.26) 225.06,60.87 222.05,60.87 221.21,60.03 220.37,60.03 219.66,60.74 219.13,60.74 218.85,60.46 218.85,60.26 218.31,59.72 217.77,59.72 217.62,59.87 216.72,59.87 216.05,60.54 215.04,60.54 214.58,61 211.77,61 211.35,60.57 211.35,59.53 210.25,58.44 209.45,58.44 206.74,55.73 206.74,55.32 206.49,55.07 206.13,55.07 205.69,55.51 201.41,55.51 199.98,54.08 198.74,54.08 197.58,55.24 195.36,55.24 194.92,55.67 194.92,57.53 196.37,58.98 196.37,64.33 196.67,64.62 196.67,66.39 196.28,66.78 196.28,77.33 196.43,77.48 196.43,87.2 197.45,88.22 197.45,94.18 199.14,95.88 199.14,96.78 201.56,99.2 201.56,101.63 203.84,103.91 204.04,103.91 206.8,106.67 206.8,111.09 211.8,116.08 216.33,116.08 217.45,117.2 225.4,117.2 226.33,118.12 232.59,118.12 233.36,117.36 v1(239.71,117.36)
  BOTTOM w0.102: U49.BF37 223.91,61.24 224.1,61.05 225.24,61.05 v1(225.45,61.26) 225.48,61.3 225.5,61.3 226.1,61.89 226.42,61.89 226.7,62.17 227.36,62.17 R999.1
PCIE_CLKREQ_WLAN#: length 87.8
  TOP w0.14: v1(280.48,80.23) 281.82,80.23 v1(283.14,78.91) 283.14,77.53 284.75,75.92 284.75,75.11 284.95,74.91 285.15,74.91 285.47,74.59 285.47,73.99 284.55,73.07 Q43.1
  IN2 w0.089: v1(280.48,80.23) 279.94,80.23 279.32,79.62 279.32,79.6 279.31,79.59 279.31,79.4 277.08,77.16 277.08,76.25 276.74,75.91 276.74,75.58 275.4,74.24 275.4,71.41 273.26,69.27 273.26,66.48 271.81,65.03 270.63,65.03 268.77,63.16 268.77,62.81 267.87,61.91 266.24,61.91 265.39,61.07 261.86,61.07 260.12,59.33 253.04,59.33 252.95,59.24 245.39,59.24 245.16,59.48 244.29,59.48 244,59.19 244,58.93 243.36,58.29 241.67,58.29 240.51,59.45 239.74,59.45 239.36,59.83 239.36,60.56 239.15,60.76 238.57,61.34 234.84,61.34 233.68,62.51 232.88,62.51 231.75,63.64 231.01,63.64 230.2,64.46 229.76,64.46 229.58,64.64 228.15,64.64 227.35,63.83 227.35,62.94 v1(227.09,62.68)
  BOTTOM w0.102: U49.BD37 222.89,61.46 223.89,61.46 224.18,61.75 224.36,61.75 224.52,61.91 225.82,61.91 226.01,62.09 226.34,62.09 226.62,62.37 226.78,62.37 v1(227.09,62.68) 227.16,62.68 R996.1
PCIE_CLKREQ_WWAN#: length 144.3
  IN2 w0.089: v1(228.71,82.54) 228.84,82.54 229.53,81.85 231.99,81.85 235.2,78.65 247.1,78.65 252.43,73.32 253.95,73.32 254.39,72.88 256.42,72.88 257.22,73.67 260.74,73.67 261.75,74.68 263.96,74.68 264.58,75.3 268.34,75.3 268.44,75.4 270.64,75.4 271.04,75.8 271.04,78.79 269.89,79.95 269.89,82 270.2,82.32 273.19,82.32 275.38,84.5 281.06,84.5 283.94,87.38 286.97,87.38 287.56,87.97 291.93,87.97 293.25,89.29 293.25,91.42 295.8,93.97 298.43,93.97 298.62,93.78 303.49,93.78 304.74,95.03 307.05,95.03 308.91,93.17 308.91,91.96 311.27,89.59 313.61,89.59 314.65,90.63 317,90.63 318.78,88.84 318.78,81.2 318.14,80.56 316.28,80.56 315.74,80.02 312.18,80.02 310.95,81.25 v1(310.05,81.25)
  BOTTOM w0.102: U49.BB3 222.03,78.6 221.94,78.69 221.94,79.34 223.64,81.05 224.98,81.05 225.29,80.74 226.26,80.74 226.89,81.37 227.18,81.37 227.28,81.27 R917.1 227.28,81.04 227.51,80.81 228.47,80.81 228.81,81.14 228.81,82.44 v1(228.71,82.54)
  BOTTOM w0.14: CN7.52 309.31,80.5 v1(310.05,81.25)
PCIE_RXN8_WWAN: length 143
  TOP w0.14: v1(306.6,83.6) 306.34,83.33 305.43,83.33 R252.2
  IN1 w0.086: v1(204.24,68.88) 204.05,68.88 203.95,68.98 203.79,68.98 203.65,68.85 203.65,68.69 202.47,67.51 202.47,63.62 202.6,63.49 202.6,62.03 204.82,59.81 206.2,59.81 207.18,58.83 207.18,58.09 207.03,57.94 207.03,56.84 207.68,56.19 208.92,56.19 209.23,55.87 211.26,55.87 212.26,54.88 213.67,54.88 214.85,53.7 214.85,53.12 215.34,52.63 215.93,52.63 216.36,52.2 218.62,52.2 219.09,51.73 227.21,51.73 227.65,51.29 229.85,51.29 230.37,50.77 240.57,50.77 241,51.2 242.4,51.2 244.82,53.61 251.54,53.61 252.21,54.28 263.33,54.28 264.21,55.17 267.04,55.17 268.36,56.49 270.49,56.49 270.91,56.9 272.73,56.9 274.62,58.78 274.62,59.06 275.18,59.63 275.18,61.43 276.47,62.72 276.47,67.95 278.33,69.81 280.52,69.81 281.04,70.34 282.39,70.34 283.8,71.75 283.8,74.18 284.5,74.88 285.4,74.88 286.2,75.68 286.9,75.68 288.02,76.8 290.93,76.8 291.23,77.1 297.46,77.1 298.08,77.73 300.68,77.73 301.05,78.1 303.63,78.1 306.37,80.83 306.37,82.19 305.99,82.57 305.99,82.97 306.17,83.15 306.57,83.15 306.71,83.29 306.71,83.5 v1(306.6,83.6)
  BOTTOM w0.102: U49.H24 204.99,68.28 204.99,68.64 204.75,68.88 v1(204.24,68.88)
PCIE_RXN_LAN: length 144.9
  IN1 w0.086: v1(205.61,58.75) 205.61,58.28 205.84,58.05 205.84,57 205.5,56.66 205.5,55.46 205.98,54.98 208.18,54.98 208.39,54.77 210.51,54.77 211.06,54.23 211.06,53.12 211.61,52.57 214.18,52.57 214.64,52.11 215.1,52.11 215.56,51.64 218.39,51.64 218.9,51.13 219.87,51.13 220.53,50.47 229.58,50.47 229.98,50.06 233.75,50.06 234.15,49.66 236.06,49.66 236.61,50.21 240.8,50.21 241.22,50.63 242.67,50.63 245.09,53.06 251.78,53.06 252.45,53.73 263.56,53.73 264.41,54.58 267.32,54.58 268.67,55.93 270.72,55.93 271.08,56.28 272.98,56.28 274.95,58.25 275.64,58.25 275.77,58.39 275.77,61.08 277.23,62.54 277.23,67.72 278.22,68.71 282.29,68.71 284.89,71.31 284.89,73.47 286.47,75.05 295.07,75.05 296.53,76.51 298,76.51 298.06,76.56 301.46,76.56 301.67,76.77 302.28,76.77 303,77.49 308.36,77.49 311.03,80.16 314.51,80.16 315.9,81.55 315.9,83.96 315.59,84.27 315.08,84.27 314.84,84.02 314.84,83.62 314.95,83.5 315.15,83.5 315.24,83.59 v1(315.24,83.83)
  BOTTOM w0.102: v1(205.61,58.75) 205.61,59.39 U49.J41
  BOTTOM w0.14: CN10.8 316.1,82.91 315.86,82.68 315.1,82.68 314.85,82.93 314.85,83.64 315.04,83.83 v1(315.24,83.83)
PCIE_RXN_WLAN: length 106.8
  IN1 w0.086: v1(286.58,69.59) 286.26,69.27 284.56,69.27 280.49,65.2 280.49,63.38 278.87,61.77 278.87,59.86 278.14,59.12 278.14,58.4 276.87,57.14 275.41,57.14 273.44,55.17 271.54,55.17 271.19,54.82 269.13,54.82 267.78,53.47 264.93,53.47 264.08,52.61 252.94,52.61 251.99,51.66 249.42,51.66 249,51.24 244.98,51.24 243.12,49.39 241.55,49.39 241.26,49.1 239.99,49.1 239.46,48.57 236.54,48.57 236.44,48.47 233.77,48.47 233.29,48.95 229.52,48.95 229.42,49.05 220.38,49.05 219.41,50.02 218.89,50.02 218.34,49.47 215.47,49.47 213.94,51 213.13,51 212.62,50.48 210.6,50.48 207.21,53.87 204.93,53.87 204.19,54.6 204.19,54.79 202.68,56.3 202.68,57.58 202.59,57.67 202.59,57.9 202.73,58.04 v1(202.86,58.04)
  BOTTOM w0.102: v1(202.86,58.04) 202.69,57.87 U49.D45
  BOTTOM w0.14: CN12.43 284,71.49 284.12,71.37 284.5,71.37 286.01,69.86 286.01,69.43 286.12,69.32 286.31,69.32 v1(286.58,69.59)
PCIE_RXP8_WWAN: length 143
  TOP w0.14: v1(306.6,82.75) 306.29,83.07 305.38,83.07 R260.2
  IN1 w0.086: v1(203.81,69.51) 203.81,69.23 203.49,68.91 203.49,68.75 202.31,67.58 202.31,63.55 202.43,63.42 202.43,61.96 204.75,59.64 206.13,59.64 207.01,58.76 207.01,58.16 206.86,58.01 206.86,56.77 207.61,56.02 208.85,56.02 209.17,55.71 211.19,55.71 212.19,54.71 213.61,54.71 214.68,53.63 214.68,53.06 215.27,52.47 215.86,52.47 216.29,52.03 218.55,52.03 219.02,51.57 227.14,51.57 227.58,51.13 229.78,51.13 230.31,50.6 240.64,50.6 241.07,51.03 242.47,51.03 244.88,53.45 251.61,53.45 252.28,54.12 263.39,54.12 264.28,55 267.11,55 268.43,56.32 270.56,56.32 270.97,56.73 272.8,56.73 274.78,58.71 274.78,58.99 275.34,59.56 275.34,61.36 276.63,62.65 276.63,67.88 278.4,69.65 280.59,69.65 281.11,70.17 282.46,70.17 283.96,71.68 283.96,74.11 284.56,74.72 285.47,74.72 286.27,75.52 286.97,75.52 288.09,76.63 291,76.63 291.3,76.94 297.53,76.94 298.15,77.56 300.75,77.56 301.12,77.93 303.7,77.93 306.53,80.76 306.53,82.26 306.15,82.64 306.15,82.9 306.24,82.98 306.37,82.98 v1(306.6,82.75)
  BOTTOM w0.102: U49.F24 203.82,68.28 203.82,69.49 v1(203.81,69.51)
PCIE_RXP_LAN: length 145
  IN1 w0.086: v1(205.22,58.23) 205.43,58.23 205.68,57.98 205.68,57.07 205.34,56.73 205.34,55.39 205.92,54.81 208.11,54.81 208.32,54.61 210.45,54.61 210.89,54.16 210.89,53.05 211.54,52.4 214.11,52.4 214.57,51.94 215.03,51.94 215.49,51.48 218.32,51.48 218.83,50.97 219.8,50.97 220.47,50.31 229.51,50.31 229.92,49.9 233.68,49.9 234.08,49.5 236.13,49.5 236.67,50.04 240.87,50.04 241.29,50.46 242.73,50.46 245.16,52.89 251.85,52.89 252.52,53.56 263.63,53.56 264.48,54.42 267.39,54.42 268.74,55.76 270.79,55.76 271.15,56.12 273.05,56.12 275.02,58.09 275.7,58.09 275.94,58.32 275.94,61.01 277.4,62.47 277.4,67.65 278.29,68.54 282.36,68.54 285.05,71.24 285.05,73.4 286.54,74.89 295.14,74.89 296.6,76.34 298.07,76.34 298.13,76.4 301.53,76.4 301.74,76.61 302.35,76.61 303.07,77.33 308.42,77.33 311.1,80 314.58,80 316.07,81.49 316.07,84.03 315.66,84.43 315.01,84.43 v1(314.44,83.85)
  BOTTOM w0.102: U49.H42 204.94,58.97 204.83,58.87 204.83,58.67 205.01,58.49 205.01,58.44 v1(205.22,58.23)
  BOTTOM w0.14: v1(314.44,83.85) 314.58,83.71 314.58,82.82 314.99,82.41 CN10.9
PCIE_RXP_WLAN: length 106.8
  IN1 w0.086: v1(202.12,57.6) 202.43,57.6 202.52,57.51 202.52,56.23 204.03,54.72 204.03,54.53 204.86,53.7 207.15,53.7 210.53,50.32 212.68,50.32 213.2,50.83 213.87,50.83 215.4,49.3 218.4,49.3 218.96,49.86 219.34,49.86 220.31,48.88 229.36,48.88 229.45,48.78 233.22,48.78 233.7,48.31 236.51,48.31 236.61,48.4 239.53,48.4 240.06,48.93 241.33,48.93 241.62,49.22 243.19,49.22 245.05,51.08 249.07,51.08 249.49,51.5 252.05,51.5 253,52.45 264.15,52.45 265,53.3 267.85,53.3 269.2,54.65 271.25,54.65 271.61,55 273.51,55 275.48,56.98 276.94,56.98 278.3,58.34 278.3,59.06 279.03,59.79 279.03,61.7 280.65,63.32 280.65,65.13 284.63,69.11 286.28,69.11 v1(286.58,68.8)
  BOTTOM w0.102: U49.C46 202.12,57.4 v1(202.12,57.6)
  BOTTOM w0.14: CN12.41 284,70.99 284.12,71.11 284.39,71.11 285.74,69.75 285.74,69.32 286,69.06 286.33,69.06 v1(286.58,68.8)
PCIE_TXN8_WWAN: length 166.9
  IN1 w0.086: v1(201.23,70.25) 201.32,70.25 201.59,69.98 201.59,69.89 201.75,69.73 201.75,63.22 201.72,63.19 201.72,61.39 203.46,59.65 203.46,57.86 204.38,56.95 204.38,55.45 205.57,54.26 207.63,54.26 208.1,53.79 208.99,53.79 210.18,52.6 210.18,51.56 210.73,51 212.44,51 212.82,51.39 214.72,51.39 215.85,50.26 218.25,50.26 218.4,50.41 219.57,50.41 220.34,49.65 229.38,49.65 229.68,49.34 233.45,49.34 233.92,48.87 236.29,48.87 236.39,48.97 238.46,48.97 238.98,49.49 241.1,49.49 241.45,49.84 242.92,49.84 245.41,52.33 252.08,52.33 252.75,53 263.86,53 264.71,53.86 267.62,53.86 268.97,55.21 271.02,55.21 271.38,55.56 273.28,55.56 275.25,57.53 276.16,57.53 276.49,57.87 276.49,60.68 277.99,62.17 278.71,62.17 279.82,63.28 279.82,65.22 284.95,70.35 287.27,70.35 288.25,69.37 293.42,69.37 294.28,70.23 306.77,70.23 308.06,71.53 308.06,73.55 308.49,73.98 308.49,76.61 311.33,79.44 314.81,79.44 316.62,81.26 316.62,84.26 316.29,84.59 316.29,85.59 316.97,86.27 316.97,87.11 316.39,87.69 316.12,87.69 316.04,87.77 v1(316.04,87.93)
  BOTTOM w0.102: v1(201.23,70.25) 201.51,69.98 201.51,69.66 201.7,69.46 201.7,69.3 U49.A22
  BOTTOM w0.14: v1(316.04,87.93) 315.75,87.64 315.22,87.64 314.35,88.51 312.37,88.51 311.59,89.29 311,89.29 C721.2
PCIE_TXN_LAN: length 160
  IN1 w0.086: v1(197.13,57.69) 197.37,57.45 197.37,56.99 197.79,56.58 197.79,55.65 198.39,55.04 199.97,55.04 200.84,54.18 202.55,54.18 204.14,52.59 206.68,52.59 209.64,49.64 209.64,48.77 210.74,47.67 213.43,47.67 214.77,46.33 219.54,46.33 219.92,45.95 220.58,45.95 222.36,47.73 228.94,47.73 229.47,47.2 237.16,47.2 237.25,47.29 240.09,47.29 240.62,47.82 241.79,47.82 242.08,48.11 248.73,48.11 250.27,49.65 253.73,49.65 255.26,51.18 264.73,51.18 265.73,52.17 270.41,52.17 271.94,53.7 276.36,53.7 282.21,59.55 282.21,62.1 285.33,65.22 285.33,65.89 288.25,68.81 294,68.81 294.87,69.68 307,69.68 308.62,71.3 308.62,73.32 309.18,73.89 309.18,74.79 310.9,76.5 310.9,78.07 311.72,78.89 315.04,78.89 317.18,81.02 317.18,84.49 316.93,84.73 316.93,85.44 317.13,85.64 317.38,85.64 317.62,85.4 v1(317.62,85.26)
  BOTTOM w0.102: 197.87,58.99 197.92,58.99 198.17,59.25 198.75,59.25 199.75,60.24 200.25,60.24 200.72,60.71 201.94,60.71 202.04,60.81 202.56,60.81 202.65,60.71 202.76,60.71 U49.D38
  BOTTOM w0.14: v1(197.13,57.69) 197.32,57.69 197.46,57.83 197.46,58.59 197.87,58.99 ; v1(317.62,85.26) 317.37,85.51 316.92,85.51 316.82,85.41 CN10.3
PCIE_TXN_WLAN: length 110.4
  IN1 w0.086: v1(198.49,56.4) 198.69,56.19 198.69,55.88 198.96,55.61 200.19,55.61 200.99,54.82 202.72,54.82 204.39,53.15 206.92,53.15 210.85,49.21 214.11,49.21 214.78,48.54 214.78,47.27 215.16,46.89 219.61,46.89 221.05,48.32 229.13,48.32 229.7,47.75 236.74,47.75 236.84,47.85 239.76,47.85 240.29,48.38 241.56,48.38 241.85,48.67 245.23,48.67 246.36,49.8 246.36,50.29 246.6,50.52 249.3,50.52 249.72,50.94 254.11,50.94 254.9,51.73 264.22,51.73 265.21,52.73 270.12,52.73 271.76,54.37 273.66,54.37 273.99,54.7 276.25,54.7 279.42,57.87 279.42,58.71 279.85,59.14 280.81,59.14 281.46,59.79 281.46,62.21 284.78,65.54 284.78,66.5 v1(285.01,66.74)
  BOTTOM w0.102: U49.C39 202.16,60.24 200.9,60.24 200.26,59.61 199.97,59.61 199.01,58.65 199.01,57.77 198.84,57.6 198.84,56.56 198.68,56.4 v1(198.49,56.4)
  BOTTOM w0.14: v1(285.01,66.74) 284.78,66.97 284.78,67.22 C766.2
PCIE_TXN_WLAN_C: length 3.7
  BOTTOM w0.14: CN12.37 284.4,69.99 284.98,69.41 284.98,68.06 C766.1
PCIE_TXP8_WWAN: length 166.9
  IN1 w0.086: v1(316.04,87.08) 315.85,87.26 315.85,87.4 315.96,87.52 316.33,87.52 316.8,87.04 316.8,86.34 316.12,85.65 316.12,84.52 316.46,84.19 316.46,81.32 314.74,79.61 311.26,79.61 308.33,76.67 308.33,74.05 307.89,73.62 307.89,71.59 306.7,70.4 294.21,70.4 293.35,69.53 288.32,69.53 287.34,70.51 284.88,70.51 279.65,65.28 279.65,63.35 278.64,62.34 277.92,62.34 276.33,60.75 276.33,57.94 276.09,57.7 275.18,57.7 273.21,55.73 271.31,55.73 270.96,55.37 268.9,55.37 267.55,54.02 264.64,54.02 263.79,53.17 252.68,53.17 252.01,52.5 245.35,52.5 242.85,50.01 241.39,50.01 241.03,49.65 238.91,49.65 238.39,49.14 236.32,49.14 236.22,49.04 233.99,49.04 233.52,49.51 229.75,49.51 229.45,49.81 220.41,49.81 219.64,50.58 218.33,50.58 218.19,50.43 215.92,50.43 214.79,51.55 212.76,51.55 212.37,51.17 210.8,51.17 210.34,51.63 210.34,52.67 209.06,53.95 208.17,53.95 207.7,54.42 205.64,54.42 204.54,55.52 204.54,57.02 203.63,57.93 203.63,59.72 201.88,61.46 201.88,63.12 201.92,63.15 201.92,69.8 201.75,69.96 201.75,70.35 v1(201.86,70.46)
  BOTTOM w0.102: U49.B21 201.71,69.75 201.71,70.31 v1(201.86,70.46)
  BOTTOM w0.14: C723.2 310.87,88.88 311.01,89.02 311.48,89.02 312.26,88.24 314.24,88.24 315.11,87.37 315.89,87.37 315.9,87.37 316.04,87.23 v1(316.04,87.08)
