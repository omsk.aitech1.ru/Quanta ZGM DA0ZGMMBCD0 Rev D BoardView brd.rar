# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PS1_I2C_SDA: length 2.5
  BOTTOM w0.14: U50.A1 277.03,56.36 v1(277.03,57.12) 277.03,57.58 R1033.1 R1032.1
PS1_MBCLK: length 7.2
  TOP w0.14: Q51.3 273.47,57.46 273.75,57.18 275.67,57.18 276.21,57.72 R566.2 277.56,57.72 v1(278.7,58.86)
  BOTTOM w0.14: R1035.2 278.31,58.39 278.68,58.75 278.68,58.83 v1(278.7,58.86)
PS1_MBDATA: length 8.6
  TOP w0.14: R567.2 278.32,57.27 277.8,56.75 276.82,56.75 v1(276.43,56.36) 276.36,56.29 Q51.6
  BOTTOM w0.14: R1032.2 275.91,58.27 275.62,57.98 275.62,57.67 275.76,57.53 276.08,57.53 276.43,57.18 v1(276.43,56.36)
PS1_SENS_CS1: length 12.6
  BOTTOM w0.14: J2.1 269.37,52.59 269.37,52.02 269.87,51.52 272.37,51.52 273.39,52.55 v1(273.39,54.57) 273.66,54.84 274.74,54.84 274.86,54.72 277.01,54.72 277.52,55.23 U50.B3
PS2_I2C_IRQ: length 2.4
  BOTTOM w0.14: R1055.1 R1058.1 282.64,55.61 v1(282.75,55.72) 283.5,55.72 U51.A2
PS2_I2C_SCL: length 3.7
  BOTTOM w0.102: U51.B1 284.01,56.02
  BOTTOM w0.14: 284.01,56.02 284.01,56.04 285.09,57.13 v1(285.09,57.63) 284.31,57.63 R1041.1 R1040.1
PS2_I2C_SDA: length 2.8
  BOTTOM w0.102: U51.A1 283.59,56.02
  BOTTOM w0.14: R1038.1 R1039.1 282.88,57.57 283.26,57.19 v1(283.26,56.89) 283.26,56.35 283.59,56.02
PS2_MBCLK: length 7.1
  TOP w0.14: R506.2 282.8,62.09 282.97,62.27 283.32,62.27 283.58,62.01 Q49.4 283.58,60.37 283.89,60.06 284.6,60.06 284.74,59.92 284.74,59.5 284.38,59.14 283.99,59.14 283.72,58.88 283.72,58.69 v1(283.88,58.53)
  BOTTOM w0.14: v1(283.88,58.53) 283.87,58.54 283.67,58.54 283.49,58.36 R1040.2
PS2_MBDATA: length 14.9
  TOP w0.14: v1(288.09,57.54) 288.09,59.02 286.39,60.72 286.39,62.35 286.19,62.54 R507.2 285.6,62.83 285.12,62.83 284.88,63.07 Q49.1
  BOTTOM w0.14: v1(288.09,57.54) 285.92,57.54 285.19,58.28 285.19,58.95 285,59.14 283.81,59.14 283.73,59.07 283.26,59.07 282.97,58.78 282.97,58.27 R1039.2
PS2_SENS_CS1: length 22.4
  BOTTOM w0.14: U51.B3 283.93,55.14 283.93,53.42 284.15,53.2 285.47,53.2 285.89,53.62 287.39,53.62 287.66,53.35 287.66,52.16 v1(286.97,51.48) 286.75,51.25 274.92,51.25 274.32,51.85 274.32,52.53 J3.1
PS8811_MBCLK: length 4.6
  TOP w0.14: U24.33 23.39,64.5 23.73,64.84 R485.2 24.36,64.84 25.18,65.66 Q47.3
PS8811_MBDATA: length 6.2
  TOP w0.14: U24.32 23.49,64.1 R494.2 24.43,63.56 24.59,63.73 24.87,63.73 25.26,63.34 25.74,63.34 v1(26.1,63.7) 26.18,63.78 Q47.6
PS8817_MBCLK: length 6.4
  TOP w0.102: 318.07,72.32 318.08,72.33
  TOP w0.14: 318.07,72.32 317.46,71.72 v1(317.38,71.72) 317.61,71.49 317.61,71.18 317.63,71.16 317.63,70.85 v1(317.76,70.73) ; 318.08,72.33 318.18,72.43 R396.1 318.43,72.56 318.43,72.78 318.24,72.97 318.24,74.4 318.44,74.6 Q40.1
  BOTTOM w0.14: v1(317.76,70.73) 317.6,70.57 317.01,70.57 316.84,70.41 CN10.33
PS8817_MBDATA: length 6.2
  TOP w0.14: Q40.4 319.39,72.95 R395.1 319.39,71.12 v1(319.41,71.11)
  BOTTOM w0.14: v1(319.41,71.11) 319.16,70.86 318.59,70.86 318.03,70.3 317.12,70.3 316.74,69.91 CN10.34
PS_FBVDD_PGOOD: length 492
  TOP w0.14: UG3.1 237,111.99 237.71,111.28 245.25,111.28 246.24,112.27 DG1.2 245.68,113.04 245.68,114.07 246.6,114.99 247.23,114.99 247.65,114.57 v1(247.67,114.57) ; Q68.2 26.77,13 v1(26.69,13.08)
  IN1 w0.086: v1(26.69,13.08) 26.93,13.31 26.93,15.53 27.24,15.85 27.24,22.01 26.6,22.65 26.6,28.5 23.94,31.17 23.94,36.6 27.36,40.02 29.13,40.02 32.34,43.23 32.94,43.23 33.53,43.82 33.53,44.28 36.22,46.98 36.22,47.78 37.64,49.2 40.12,49.2 42,51.08 46.75,51.08 48.98,53.3 49.82,53.3 50.17,53.65 59.56,53.65 60.94,52.27 62.7,52.27 63.8,51.17 79.41,51.17 v1(81.97,53.73)
  IN2 w0.089: v1(203.11,84.49) 202.39,85.21 201.09,85.21 200.74,84.85 200.09,84.85 195.89,80.65 192.46,80.65 191.65,81.46 190.02,81.46 188.78,80.22 168.16,80.22 167.6,79.66 166.29,79.66 166.29,79.66 151.77,79.66 150.5,78.39 149.71,78.39 148.41,77.09 145.2,77.09 145.05,77.25 142.94,77.25 142.79,77.09 139.29,77.09 136.84,79.55 130.79,79.55 v1(130.34,79.11)
  IN3 w0.089: v1(129.67,62.29) 128.7,61.32 123.15,61.32 122.23,60.4 112.78,60.4 111.46,59.09 102.67,59.09 100.5,56.91 97.5,56.91 94.32,53.73 v1(81.97,53.73) ; v1(247.67,114.57) 247.92,114.82 250.87,114.82 251.52,115.47 253.56,115.47 254.05,114.97 255.57,114.97 256.66,116.06 258.07,116.06 258.72,115.41 259.74,115.41 259.97,115.64 259.97,116.06 261.77,117.86 261.77,119.31 261.93,119.47 262.84,119.47 263.1,119.72 264.93,119.72 266.26,121.06 266.26,121.21 267.67,122.62 267.97,122.62 274.41,129.06 277.44,129.06 280.24,131.86 280.24,152.56 281.68,154 281.68,186.56 277.95,190.29 272.84,190.29 270.45,192.68 270.45,198.21 269.89,198.78 269.89,202.27 269.24,202.91 269.24,206.97 268.1,208.12 268.1,210.66 266.7,212.05 265.8,212.05 265.56,212.29 264.78,212.29 264.45,212.62 264.07,212.62 261.19,209.74 259.59,209.74 259.19,209.34 255.82,209.34 v1(255.78,209.39)
  IN4 w0.086: v1(203.11,84.49) 203.11,85.92 201.58,87.44 200.75,87.44 200.41,87.78 200.41,94.09 204.2,97.87 204.2,100.19 202.72,101.67 202.72,102.84 201.36,104.2 201.36,105.2 198.77,107.79 198.77,110.21 200.13,111.57 203.42,111.57 204.54,112.7 245.8,112.7 v1(247.67,114.57)
  BOTTOM w0.14: v1(129.67,62.29) 125.01,66.95 125.01,78.77 126.09,79.85 129.6,79.85 v1(130.34,79.11)
  BOTTOM w0.203: v1(255.78,209.39) 255.78,210.25 254.64,211.39 PR388.2
PTP_PWR_EN#: length 36.2
  TOP w0.14: C551.1 204.14,39.63 204.56,40.06 Q60.2 204.29,40.82 v1(204.29,42.28) ; v1(178.94,55.62) 178.94,55.25 178.52,54.83 R593.1
  IN4 w0.086: v1(178.94,55.62) 178.94,55.09 179.46,54.57 184.06,54.57 192.17,46.46 195.11,46.46 199.88,41.69 203.7,41.69 v1(204.29,42.28)
PULSAR_38P4M_REFCLK: length 1.7
  BOTTOM w0.14: TP146.1 273.85,76.74 CN12.64
PWM_OUT_EN: length 239.6
  TOP w0.14: v1(284.68,174.48) 283.76,174.48 R83.2 ; TP80.1 210.49,52.08 v1(210.49,53.99) 210.49,54.61 R597.1
  IN2 w0.089: v1(284.68,174.48) 285.48,173.68 285.48,173.48 286.21,172.75 286.21,166.36 285.62,165.77 285.62,154.72 282.4,151.5 282.4,143 286.72,138.68 286.72,136.61 282.21,132.1 282.21,124.98 284.13,123.06 287.28,123.06 287.92,122.43 289.51,122.43 290.57,121.37 291.48,121.37 292.33,120.51 292.33,117.52 289.75,114.95 280.81,114.95 277.86,112.01 250.81,112.01 250.12,112.7 249.6,112.7 249.13,112.22 226.56,112.22 221.62,117.16 215.11,117.16 211.89,113.93 v1(211.89,110.54)
  IN3 w0.089: v1(211.89,110.54) 211.89,110.08 211.43,109.62 211.43,109.11 211.71,108.83 211.71,106.98 211.11,106.38 211.11,104.58 210.56,104.03 210.56,101.01 202.67,93.12 202.67,90.06 202.11,89.5 202.11,88.74 202.78,88.08 202.78,85.52 202.54,85.28 202.54,81.82 203.42,80.95 203.42,79.4 202.67,78.66 202.67,77.38 202.22,76.93 202.22,74.89 202.54,74.57 202.54,72.68 202.31,72.45 200.36,72.45 199.93,72.02 199.93,71.69 200.19,71.43 200.19,68.88 200.59,68.48 200.59,66.51 200.23,66.15 200.23,65.39 199.2,64.36 199.2,61.85 v1(199.42,61.63)
  IN4 w0.086: v1(199.42,61.63) 200,61.63 202.4,59.23 202.93,59.23 203.75,58.41 203.75,57.8 204.67,56.88 208.25,56.88 210.49,54.63 v1(210.49,53.99)
  BOTTOM w0.102: v1(210.49,53.99) 210.49,54.74 210.69,54.93 210.69,55.52 211.03,55.86 U49.Y48
PWM_OUT_EN_EC: length 0.7
  TOP w0.14: R85.2 282.82,173.22 R86.1
PWM_OUT_EN_EC_R: length 457.3
  TOP w0.14: v1(171.32,70.62) 171.32,70.93 170.71,71.54 U23.125 ; v1(284.17,174.02) 283.83,173.68 R84.2 283.55,173.67 R86.2
  IN2 w0.089: v1(284.17,174.02) 283.71,174.48 283.71,175.82 283.04,176.48 281.42,176.48 279.08,178.83 v1(278.33,178.83) ; v1(213.41,186.52) 213.41,186.9 214.73,188.23 219.75,188.23 220.79,187.19 223.04,187.19 223.53,187.67 231.09,187.67 231.13,187.71 261.78,187.71 264.58,184.9 266.4,184.9 267.61,186.11 269.34,186.11 270.34,185.11 273.12,185.11 273.93,184.3 273.93,181.08 v1(272.69,179.84) ; v1(196.81,108.52) 193.64,108.52 179.8,122.35 126.29,122.35 123.54,125.1 114.41,125.1 114.26,125.25 v1(113.91,125.25) ; v1(135.31,72.79) 135.63,72.79 137.04,71.38 141.75,71.38 141.93,71.56 146.37,71.56 146.55,71.38 150.45,71.38 150.79,71.72 156.65,71.72 156.66,71.71 159.07,71.71 159.37,71.41 161.1,71.41 161.74,70.77 164.4,70.77 165,71.36 166.95,71.36 167.97,70.35 171.04,70.35 v1(171.32,70.62)
  IN3 w0.089: v1(213.41,186.52) 213.41,186.4 210.84,183.83 209.09,183.83 205.73,180.47 198.98,180.47 194.01,175.5 194.01,168.68 190.33,165 190.33,153.49 191.06,152.76 191.06,112.22 194.77,108.52 v1(196.81,108.52) ; v1(113.91,125.25) 113.44,124.78 113.44,123.87 111.55,121.99 111.55,117.46 114.72,114.3 114.72,111.1 111.5,107.89 107.61,107.89 106.19,106.47 106.19,104.3 104.9,103 104.9,99.35 99.35,93.8 99.35,90.51 98.38,89.54 97.13,89.54 95.79,88.19 91.4,88.19 90.49,87.28 87.72,87.28 87.18,87.82 85.61,87.82 84.8,87 78.18,87 78.13,87.06 77.1,87.06 76.79,86.75 76.45,86.75 75.33,85.63 75.33,78.16 77.5,75.99 91.65,75.99 92.18,76.52 105.7,76.52 107.31,74.91 108.33,74.91 108.83,75.41 114.47,75.41 117.99,71.89 129.45,71.89 130.91,73.34 134.76,73.34 v1(135.31,72.79) ; v1(272.69,179.84) 273.73,180.88 275.85,180.88 277.9,178.83 v1(278.33,178.83)
PWM_SW_SELECT: length 35
  TOP w0.14: v1(266.55,120.53) 266.79,120.53 268.18,119.14 268.53,119.14 269.98,117.69 269.98,116.42 270.77,115.63 270.77,113.12 TP21.1
  IN4 w0.086: v1(266.55,120.53) 267.52,120.53 268.51,121.51 268.51,123.34 266.8,125.04 263.79,125.04 261.57,127.26 261.57,127.54 260.35,128.76 v1(260.35,129.21)
  BOTTOM w0.102: 258.97,131.21 258.07,132.12 257.46,132.12 257,132.58 255,132.58 254.65,132.23 UG6.BJ4
  BOTTOM w0.14: 258.97,131.21 260.35,129.83 v1(260.35,129.21) ; RG172.1 266.54,118.21 266.42,118.33 RG166.1 266.55,119.35 v1(266.55,120.53)
PWM_SW_SELECT_Q: length 83
  TOP w0.14: TP6.1 284.74,181.83 v1(284.61,181.71) 284.48,181.71 284.35,181.84 TP5.1 283.64,181.77 283.64,181.3 283.78,181.16 R80.1
  IN3 w0.089: v1(267.48,115.7) 268.58,115.7 269.29,116.41 270.4,116.41 270.99,115.81 277.24,115.81 281,119.58 281,151.84 283.25,154.09 283.25,173.8 284.02,174.57 284.02,179.5 284.61,180.1 v1(284.61,181.71)
  BOTTOM w0.14: v1(267.48,115.7) 267.48,115.5 267.99,115 UG10.4
PWR_LEVEL: length 22.9
  TOP w0.14: v1(260.98,124.12) 261.01,124.09 261.01,123.4 262.09,122.32 263.31,122.32 263.39,122.4 263.76,122.4 264.13,122.04 264.13,121.59 262.17,119.64 v1(262.17,118.98)
  BOTTOM w0.102: 258.97,129.03 258.97,129.03 256.82,131.18 256.39,131.18 UG6.BK2
  BOTTOM w0.14: v1(262.17,118.98) 262.57,118.98 RG168.2 262.82,118.31 262.89,118.24 DG2.2 262.89,117.62 262.21,117.62 262.09,117.5 RG174.1 261.52,117.23 261.28,116.99 QG24.1 ; 258.97,129.03 259.35,128.65 259.35,125.6 259.49,125.46 259.49,124.61 259.99,124.12 v1(260.98,124.12)
PWRLED#: length 259.7
  TOP w0.14: R528.2 162.68,62.1 v1(162.59,62.2) ; D3.1 267.88,192.5 267.42,192.04 v1(267.42,191.35) 267.22,191.55 CN1.21
  IN3 w0.089: v1(267.42,191.35) 267.42,189.97 268.58,188.8 273.6,188.8 273.94,189.14 277.47,189.14 280.52,186.08 280.52,154.48 278.97,152.92 278.97,139.78 276.25,137.06 276.25,135.62 271.45,130.82 268.88,130.82 266.56,128.51 262.17,128.51 261.49,127.83 261.49,127.23 260.59,126.33 260.59,125.58 259.68,124.66 258.24,124.66 257.3,123.72 256.15,123.72 255.73,124.14 254.16,124.14 253.06,123.05 253.06,122.69 252.63,122.26 252.63,121.26 250.63,119.25 247.55,119.25 246.5,120.31 245.7,120.31 245.35,120.66 244.08,120.66 243.07,121.67 240.97,121.67 237.25,125.38 226.81,125.38 223.52,122.09 215.22,122.09 214.02,120.89 209.36,120.89 201.93,113.46 201.93,107.25 202.53,106.65 202.53,105.87 202.02,105.35 201.01,105.35 199.07,103.4 198.38,103.4 197.14,102.17 196.08,102.17 195.54,101.63 195.54,89.01 194.52,87.99 194.52,78.27 194.38,78.12 194.38,64.93 194.88,64.42 194.88,62.24 195.38,61.74 195.38,60.39 194.34,59.34 193.01,59.34 191.96,58.3 189.93,58.3 189.26,57.62 187.92,57.62 186.91,58.64 185.4,58.64 184.16,59.87 182.29,59.87 181.84,60.32 181.4,60.32 181.28,60.43 181.28,61.05 180.86,61.47 177.8,61.47 176.22,63.05 174.01,63.05 172.51,61.55 170.98,61.55 170.78,61.35 170.22,61.35 169.33,62.24 168.64,62.24 168.27,62.61 163,62.61 v1(162.59,62.2)
R_CTL: length 734
  TOP w0.254: R651.1 41.1,36.48 41.33,36.7 Q65.5 42.47,36.7 42.73,36.45 42.73,35.74 42.98,35.48 46.35,35.48 v1(47.22,36.35) ; v1(299.72,77.03) 300.21,76.54 300.75,76.54 301.01,76.8 R340.1 301.01,77.55 300.82,77.74 Q34.5
  IN1 w0.254: v1(134.12,216.65) 134.52,216.65 137.7,213.48 137.7,212.43 138.33,211.8 140.49,211.8 142.57,213.88 143.89,213.88 144.15,213.63 144.15,212.71 142.34,210.9 142.34,205.2 143.2,204.34 145.49,204.34 147.29,202.54 149.77,202.54 150.23,202.08 151.99,202.08 152.46,201.61 v1(152.74,201.61) 152.74,202.08 154.14,203.47 154.44,203.47 156.59,205.63 v1(156.59,206.39) ; v1(250.16,216.9) 250.16,216.89 249.71,216.45 249.71,216.18 249.33,215.8 248.59,215.8 247.92,216.48 247.32,216.48 246.66,215.81 246.66,215.08 246.97,214.77 246.97,213.85 247.93,212.89 247.93,211.76 247.29,211.12 246.99,211.12 243.88,208.01 242.17,208.01 240.71,206.55 237.1,206.55 235.77,207.88 v1(235.39,207.88)
  IN2 w0.254: v1(47.22,36.35) 47.22,37.26 46.66,37.81 46.66,44.57 48.39,46.3 56.47,46.3 60.09,42.69 69.85,42.69 70.81,41.72 71.58,41.72 72.64,40.66 86.27,40.66 90.25,44.64 90.25,47.28 94.44,51.47 101.15,51.47 103.86,54.17 111.28,54.17 113.36,56.25 116.03,56.25 117.35,57.57 118.89,57.57 120.03,58.71 123.22,58.71 124.51,60 132.91,60 133.57,60.66 145.31,60.66 145.44,60.79 149.94,60.79 150.84,61.69 157.46,61.69 157.76,61.38 158.13,61.38 160.71,58.79 162.61,58.79 164.35,57.06 164.84,57.06 165.91,55.99 168.93,55.99 170.58,54.34 170.58,53.8 171.12,53.27 171.93,53.27 172.52,52.67 177.46,52.67 180.13,49.99 180.13,48.32 184.02,44.44 185.72,44.44 187.11,43.05 187.11,41.6 188.43,40.28 189.87,40.28 190.17,39.98 195.79,39.98 196.03,40.22 201.85,40.22 202.32,39.75 205.89,39.75 205.93,39.71 209.2,39.71 209.49,39.42 219.69,39.42 221.15,40.88 227.44,40.88 229.49,42.94 229.49,44.27 229.99,44.77 237.75,44.77 238.04,44.48 240.05,44.48 241.22,43.31 242.39,43.31 244.13,45.04 244.7,45.04 245,44.74 245,40.17 246.19,38.98 246.19,38.56 247.18,37.58 248.73,37.58 250.08,36.23 255.54,36.23 259.39,40.08 259.39,42.82 259.94,43.37 261.46,43.37 261.74,43.09 267.16,43.09 269.45,45.38 269.45,45.84 271.82,48.22 274.85,48.22 279.11,52.47 281.44,52.47 282.96,53.99 282.96,54.57 286,57.61 286,61.1 284.84,62.26 284.84,63.08 283.68,64.24 283.68,67.55 286.13,70 286.13,70.57 287.24,71.68 287.24,74.03 287.75,74.54 293.88,74.54 295.69,76.34 297.11,76.34 297.29,76.16 298.65,76.16 299.03,76.54 299.24,76.54 v1(299.72,77.03) ; v1(156.59,206.39) 158.02,206.39 158.6,206.97 159.48,206.97 163.13,210.62 163.13,213.19 165.03,215.08 165.03,215.94 166.06,216.97 168.05,216.97 168.88,216.15 170.07,216.15 170.54,216.62 171.99,216.62 172.24,216.37 172.24,205.99 174.33,203.9 176.15,203.9 176.2,203.95 185.14,203.95 185.81,204.62 188.79,204.62 189.02,204.39 193.09,204.39 194.39,205.69 194.39,206.54 195.91,208.06 199.7,208.06 201.87,205.89 201.87,205.13 202.49,204.51 212.75,204.51 213.33,205.09 219.44,205.09 220.02,204.51 224.01,204.51 225.67,206.17 225.67,207.21 226.7,208.24 231.42,208.24 231.46,208.28 233.43,208.28 233.59,208.12 234.19,208.12 234.43,207.88 v1(235.39,207.88)
  IN3 w0.254: v1(285.94,114.26) 283.3,116.9 282.63,116.9 282.38,117.15 282.38,151.27 286.34,155.23 286.34,183.22 285.67,183.89 285.67,184.99 286.34,185.66 286.34,199.54 284.3,201.57 284.3,204.31 283.83,204.78 283.83,208.86 281.92,210.78 279.88,210.78 278.65,212.01 277.53,212.01 277.28,212.26 277.28,213.45 276.91,213.81 276.91,215.69 276.39,216.21 274.02,216.21 273.11,217.12 272.85,217.12 272.33,217.64 267.21,217.64 267.01,217.84 265.69,217.84 264.91,217.07 264.64,217.07 263.11,215.55 260.09,215.55 259.85,215.31 258.6,215.31 258.27,215.64 258.27,216.52 257.41,217.39 252.93,217.39 251.24,215.69 249.96,215.69 249.71,215.95 249.71,216.45 250.16,216.89 v1(250.16,216.9)
  IN4 w0.254: v1(299.72,77.03) 300.93,77.03 301.9,78 303.88,78 308.3,82.42 308.3,85.69 309.38,86.76 310.43,86.76 312.58,88.91 312.81,88.91 314.31,90.41 316.88,90.41 320.13,93.66 320.13,97.39 317.54,99.97 313.08,99.97 312.85,100.2 310.78,100.2 310.57,99.99 306.33,99.99 305.82,100.49 305.47,100.49 305.19,100.78 304.7,100.78 302.57,102.91 301.32,102.91 299.88,104.36 299.88,106.64 297.95,108.57 293.59,108.57 291.2,110.96 291.2,111.26 289.08,113.38 287.32,113.38 287.1,113.6 286.6,113.6 v1(285.94,114.26)
  BOTTOM w0.254: v1(134.12,216.65) 134.5,216.27 R687.1 135.36,216.27 135.64,216.55 Q73.5 ; Q78.6 152.82,203.15 153.01,202.97 153.01,202.61 152.74,202.34 152.12,202.34 151.87,202.08 R721.2 151.87,201.86 152.12,201.61 v1(152.74,201.61)
R_CTL_LOGO: length 20.2
  TOP w0.14: v1(150.55,207.35) 149.79,206.59 U1.32 ; Q126.5 165.28,202.01 164.96,202.32 164.42,202.32 164.29,202.45 163.38,202.45 162.94,202.02 R1215.1 162.72,201.79 162.44,202.07 161.67,202.07 v1(160.91,202.83)
  IN2 w0.089: v1(160.91,202.83) 160.91,203.29 160,204.2 160,204.81 158.89,205.92 156.22,205.92 155.39,206.74 151.16,206.74 v1(150.55,207.35)
R_CTL_LOGO_C: length 123.1
  TOP w0.508: v1(173.87,203.67) 173.87,202.63 v1(170.76,199.52) 170.11,198.87 R1212.1
  IN3 w0.508: v1(265.26,193.59) 264.93,193.26 264.29,193.26 262.89,194.65 262.89,202.65 264.95,204.71 264.95,205.93 264.32,206.57 261.22,206.57 260.1,205.45 258.83,205.45 258.32,205.96 254.51,205.96 254.13,205.58 237.87,205.58 236.2,207.25 236.2,208.62 235.46,209.36 232.16,209.36 231.88,209.64 228.48,209.64 225.81,206.97 225.81,205.96 225.17,205.32 223.65,205.32 221.75,203.42 219.46,203.42 218.95,203.92 216.16,203.92 215.65,203.42 199.9,203.42 199.33,203.99 198.57,203.99 197.74,204.81 196.17,204.81 195.24,203.89 195.24,202.97 194.79,202.53 189.29,202.53 188.51,203.31 178.29,203.31 177.93,203.67 v1(173.87,203.67)
R_CTL_MCU: length 8.8
  TOP w0.203: U1.21 147.4,202.25
  TOP w0.254: 147.4,202.25 147.4,202.25 147.4,201.47 147.54,201.33 v1(147.54,201.29)
  IN3 w0.254: v1(149.16,203.27) 149.16,202.91 v1(147.54,201.29)
  BOTTOM w0.254: v1(149.16,203.27) 149.5,203.61 R717.2 149.89,203.61 150.08,203.8 Q78.2 151.24,203.8 151.56,203.48 151.56,202.49 151.42,202.35 R721.1
R_CTL_TURBO: length 1.2
  BOTTOM w0.254: Q81.5 274.88,196.94 274.73,196.78 R726.1
R_CTL_TURBO_C: length 148
  TOP w0.203: U1.27 150.06,204.59
  TOP w0.254: CN1.15 267.39,194.55 v1(267.44,194.5) ; v1(158.74,205.08) 158.17,205.08 157.38,204.29 156.94,204.29 v1(156.81,204.42) 156.68,204.29 153.48,204.29 153.18,204.59 150.06,204.59
  IN1 w0.254: v1(158.74,205.08) 158.74,205.84 161.3,208.4 169.72,208.4 170.39,207.74 170.39,206.59 171.94,205.04 171.94,204.04 173.3,202.68 173.3,200.74 175.96,198.08 176.94,198.08 179.65,195.38 181.42,195.38 181.84,194.96 186.77,194.96 191.91,189.82 200,189.82 201.07,190.89 206.6,190.89 208.53,188.97 211.34,188.97 212.4,190.03 219.37,190.03 219.8,190.46 222.98,190.46 223.61,189.83 237.31,189.83 237.58,190.09 241.11,190.09 241.79,190.77 250.27,190.77 250.91,190.13 261.01,190.13 264.14,193.25 264.14,194.45 264.85,195.16 266.37,195.16 267.04,194.49 267.4,194.49 267.41,194.5 v1(267.44,194.5) 267.47,194.5 267.54,194.43 267.92,194.43 268.16,194.19 270.29,194.19 270.72,193.76 273.16,193.76 275.05,195.66 v1(275.76,195.66)
  BOTTOM w0.254: v1(275.76,195.66) 275.42,195.32 R730.1
R_CTRL_LEFT: length 63.1
  TOP w0.508: R289.1 298.89,81.42 v1(299.12,81.65)
  IN3 w0.508: v1(260.29,49.8) 260.29,50 261,50.71 261.14,50.71 263.26,52.82 265.13,52.82 265.99,53.69 266.93,53.69 268.11,54.86 269.8,54.86 270.75,53.91 272.77,53.91 273.19,53.5 276.45,53.5 279.92,56.96 280.61,56.96 282.74,59.1 282.74,64.01 282.39,64.37 282.39,67.72 282.95,68.28 283.38,68.72 283.38,68.99 286.9,72.5 286.9,74.03 287.38,74.51 289.06,74.51 290.2,75.65 290.2,75.96 292.28,78.04 292.28,78.63 294.36,80.71 298.18,80.71 v1(299.12,81.65)
  BOTTOM w0.508: v1(260.29,49.8) 259.65,50.44 CN14.2
R_CTRL_RIGHT: length 5.6
  TOP w0.508: v1(43.18,38.23) 43.3,38.11 v1(44.08,38.11) 44.62,38.65 46.21,38.65 46.54,38.32 R649.1
  BOTTOM w0.508: v1(43.18,38.23) 43.18,38.03 43,37.85 CN22.2
R_SPK+: length 70
  IN4 w0.762: 309.91,71.13 309.91,70.3 308.89,69.28 303.38,69.28 303.18,69.48 298.95,69.48 298.39,70.04 294.62,70.04 293.76,69.18 288.66,69.18 285.09,65.6 285.09,59.96 285.58,59.48 285.58,58.46 285.57,58.46 285.57,57.44 282.21,54.07 282.21,53.61 281.45,52.84 278.92,52.84 274.99,48.91 271.73,48.91 270.44,47.62 270.44,46.8 267.42,43.78 262.44,43.78 261.67,44.54 261.67,46.04 261.95,46.32 261.95,47.21
  vias: v1(261.61,48.4) v1(262.28,48.4) v1(310.07,72.57) v1(310.05,71.91)
R_SPK+_C: length 2.6
  BOTTOM w0.762: 261.76,44.53 261.76,44.53 261.76,43.89 v1(262,43.65) 262.66,43 CN20.4
R_SPK-: length 73.2
  IN4 w0.762: 311,71.16 310.82,70.98 310.82,69.92 309.27,68.37 303,68.37 302.8,68.56 298.58,68.56 298.01,69.13 295,69.13 294.14,68.26 289.04,68.26 286,65.22 286,60.34 286.49,59.86 286.49,58.08 286.49,57.06 283.13,53.7 283.13,53.23 281.83,51.93 279.3,51.93 275.37,48 272.11,48 271.35,47.24 271.35,46.42 267.8,42.86 262.06,42.86 260.76,44.16 260.76,45.91 260.45,46.22 260.45,47.21
  vias: v1(260.1,48.4) v1(260.75,48.4) v1(310.91,72.68) v1(310.87,71.97)
R_SPK-_C: length 6.9
  BOTTOM w0.762: 260.65,44.61 260.64,44.6 v1(260.64,43.62) 262.58,41.68 264.21,41.68 264.65,42.12 CN20.3
RCOMP_1P8: length 4.1
  BOTTOM w0.102: R936.2 227.57,76.31 224.06,76.31 U49.BF8
REGN6V: length 12.7
  TOP w0.14: v1(38.75,47.93) 38.61,47.79 PR313.1
  TOP w0.178: PC264.1 42.16,40.56 v1(41.75,40.97) 41.75,41.21 41.99,41.44 41.99,42.16 41.81,42.34 41.15,42.34 41.14,42.36 PU18.24
  BOTTOM w0.14: v1(38.75,47.93) 39.51,47.17 39.51,44.31 41.75,42.07 v1(41.75,40.97)
RESETB: length 4
  TOP w0.14: v1(13.85,62.95) 13.95,63.06 R497.2
  TOP w0.178: U24.16 16.27,63.7 16.06,63.92 C460.1 14.61,63.51 R497.2
REXT: length 1.9
  TOP w0.14: U24.29 21.7,62.9 22.66,61.94 R515.1
RF_EN: length 127.1
  TOP w0.14: C507.1 186.44,57.58 186.79,57.23 R574.1 186.79,56.18 188.58,54.38 v1(188.58,53.45) v1(188.58,50.99)
  IN3 w0.089: v1(274.04,75.86) 274.25,75.65 274.25,75.17 273.92,74.84 273.92,66.08 272.82,64.98 272.82,64.22 272.3,63.69 271.03,63.69 270.54,63.2 270.54,61.94 271.05,61.44 271.05,59.83 269.83,58.61 265.05,58.61 263.51,57.07 262.43,57.07 259.97,54.61 257.78,54.61 257.47,54.92 251.47,54.92 250.81,55.58 246.77,55.58 246.11,54.92 239.59,54.92 238.58,53.91 238.58,53.39 238.09,52.9 237.1,52.9 236.31,52.11 235.39,52.11 235.01,52.48 230.06,52.48 229.32,51.74 227.8,51.74 227.56,51.98 224.67,51.98 223.01,50.31 222.79,50.31 221.76,49.28 220.59,49.28 219.86,50.01 218.69,50.01 217.96,49.27 215.45,49.27 215.36,49.18 215.36,47.88 214.82,47.34 212.65,47.34 212.4,47.59 209.26,47.59 209.15,47.71 204.93,47.71 203.65,46.43 198.6,46.43 198.4,46.63 195.56,46.63 194.44,47.75 193.27,47.75 192.61,48.41 190.65,48.41 188.58,50.47 v1(188.58,50.99)
  BOTTOM w0.14: CN12.56 274.55,74.74 274.3,74.99 274.3,75.62 274.07,75.86 v1(274.04,75.86) 274.02,75.88 273.84,75.88 273.15,76.58 272.58,76.58 272.41,76.74 R933.1 272.41,77.92 R926.1 R926.2 R922.1
RF_EN_PCH: length 87
  TOP w0.14: v1(219.12,62.96) 219.49,62.96 R501.1
  IN1 w0.086: v1(271.43,63.24) 271.44,63.23 271.44,62.35 271.07,61.98 271.07,60.4 269.41,58.73 266.83,58.73 266.05,57.95 262.87,57.95 262.46,57.54 261.19,57.54 260.95,57.79 254.58,57.79 254.18,57.39 251.41,57.39 251.16,57.65 251.16,58.66 250.86,58.96 245.91,58.96 245.06,58.1 232.05,58.1 231.95,58.01 226.69,58.01 226.04,58.66 224.67,58.66 223.53,59.8 223.53,60.06 222.6,60.99 222.09,60.99 221.82,61.25 221.82,61.56 221.48,61.91 221.15,61.91 220.9,61.66 219.2,61.66 218.94,61.92 218.94,62.44 219.12,62.62 v1(219.12,62.96)
  IN3 w0.089: v1(271.43,63.24) 271.45,63.22 272.1,63.22 273.01,64.14 273.01,64.9 274.11,66.01 274.11,74.76 274.44,75.09 274.44,76.27 274.22,76.49 272.9,76.49 272.11,77.28 272.11,79.49 v1(270.54,81.07)
  BOTTOM w0.102: v1(219.12,62.96) 219.23,62.84 U49.AU34
  BOTTOM w0.14: R922.2 272.01,79.6 v1(270.54,81.07)
RINRVP: length 1.2
  TOP w0.14: 304.92,63.13 304.92,63.7 304.79,63.83 U21.25
RIP:
  vias: v1(296.65,74.28) v1(297.31,74.28) v1(297.95,72.48) v1(304.1,62.45)
ROM_CS: length 33.5
  TOP w0.102: 258.97,130.17 258.86,130.17 256.67,127.98 253.34,127.98 v2(252.92,128.4)
  TOP w0.14: v1(268.71,135.75) 268.04,135.75 265.53,133.24 265.53,132.83 266.98,131.38 267.31,131.38 268.43,132.5 270.39,132.5 271.09,131.8 271.09,131.6 270.23,130.75 268.38,130.75 267.87,130.24 265.13,130.24 264.62,130.75 263.04,130.75 262.39,130.09 260.59,130.09 260.52,130.17 258.97,130.17
  BOTTOM w0.102: v2(252.92,128.4) 252.6,128.72 UG6.BP7
  BOTTOM w0.14: RG121.1 v1(268.71,135.75)
ROM_CS_R: length 3.9
  BOTTOM w0.14: RG116.2 270.07,136.3 RG121.2 270.07,135.64 270.35,135.35 TPG52.1 270.35,134.3 269.84,133.79 UG7.1
ROM_SCLK: length 24.8
  IN1 w0.086: v1(254.6,122.84) 255,122.84 255.81,123.65 257.56,123.65 258.26,124.35 259.81,124.35 260.94,123.22 v1(269.93,123.22)
  BOTTOM w0.127: UG6.BT7 252.55,125.85 254.24,124.16 254.24,123.21
  BOTTOM w0.14: v1(269.93,123.22) 270.05,123.35 RG143.1 271.35,123.87 RG142.2 272.03,124.01 RG135.1 ; 254.24,123.21 v1(254.6,122.84)
ROM_SCLK_R: length 2.4
  BOTTOM w0.14: UG7.6 TPG53.1 272.44,125.66 RG135.2
ROM_SI: length 32.3
  IN1 w0.086: v1(254.66,123.49) 255.38,123.49 255.73,123.84 257.48,123.84 258.18,124.54 259.89,124.54 260.87,123.56 268.7,123.56 271.69,126.55 v1(274.37,126.55)
  BOTTOM w0.127: UG6.BR7 252.9,127.67 252.9,125.88 254.66,124.11
  BOTTOM w0.14: v1(275.59,127.22) 274.7,127.22 274.37,126.88 v1(274.37,126.55) 274.37,125.39 274.29,125.32 RG134.1 274.29,124.07 RG138.2 274.13,124.06 273.98,124.21 273.77,124.42 RG136.1 ; 254.66,124.11 v1(254.66,123.49)
ROM_SI_R: length 2.4
  BOTTOM w0.14: RG136.2 273.58,125.59 TPG54.1 273.69,126.21 273.65,126.25 UG7.5
ROM_SO: length 29.8
  IN1 w0.086: v1(270.44,131.75) 267.32,128.63 261.31,128.63 259.62,126.95 258.08,126.95 256.67,125.54 254.39,125.54 v1(253.05,124.2)
  BOTTOM w0.102: UG6.BT8 251.85,125.05 252.7,124.2 v1(253.05,124.2)
  BOTTOM w0.14: RG117.1 271.24,136 TPG50.1 271.23,135.99 RG123.2 271.23,134.26 271.11,134.14 UG7.2 271.11,132.16 270.71,131.75 v1(270.44,131.75)
RSMRST#: length 60.6
  TOP w0.14: TP81.1 207.77,51.39 207.77,50.87 207.91,50.73 R617.2 C523.1 208.87,50.73 209.01,50.87 209.01,52.39 v1(209.33,52.72) ; U23.112 175.91,72.2 175.45,71.74 175.45,66.07 176.31,65.21 v1(176.31,64.88)
  IN4 w0.086: v1(176.31,64.88) 176.74,64.45 183.65,64.45 184.77,63.33 186.58,63.33 187.28,62.63 187.28,60.55 187.66,60.17 187.66,58.07 189.08,56.65 189.52,56.65 192,54.17 192.59,54.17 194.21,52.55 199.49,52.55 200.88,53.94 207.47,53.94 208.69,52.72 v1(209.33,52.72)
  BOTTOM w0.102: U49.AA45 211.43,57.52 211.43,56.69 211.28,56.54 211.28,56.01 211.51,55.78 211.51,54.99 210.92,54.4 210.92,53.85 210.66,53.59 210.2,53.59 v1(209.33,52.72)
RSVD_TP_15: length 1.4
  TOP w0.14: v2(166.81,143.68) 166.99,143.86 TP15.1
  BOTTOM w0.102: v2(166.81,143.68) 166.81,143.47 U42.R24
RT_I2C_INT: length 68.4
  TOP w0.079: 35.92,86.7 36.05,86.83 36.5,86.83 37.25,87.58 U9.A10 ; U16.A10 32.68,70.31 31.89,69.52 31.26,69.52
  TOP w0.14: 31.26,69.52 31.26,69.52 30.64,68.89 v1(30.64,68.72) 30.23,68.31 R443.1 ; v1(70.19,85.67) 70.19,86.27 69.32,87.14 Q25.1 68.78,87.46 68.14,87.46 67.82,87.14 R206.1 ; 35.92,86.7 v1(35.21,85.99) 34.8,85.58 R217.1
  IN1 w0.086: v1(70.19,85.67) 69.28,84.76 61.43,84.76 60.08,86.1 44.22,86.1 43.48,86.85 40.3,86.85 39.82,86.36 35.58,86.36 v1(35.21,85.99)
  IN2 w0.089: v1(30.64,68.72) 30.64,70.9 31.49,71.75 31.49,75.04 32.54,76.09 33.26,76.09 35.56,78.4 35.56,81.88 35.06,82.39 35.06,83.4 34.62,83.83 34.62,85.4 v1(35.21,85.99)
RT_I2C_INT#_D: length 9.3
  TOP w0.14: U11.B1 62.6,87.23 62.87,86.96 62.87,86.8 63.31,86.36 63.9,86.36 64.83,85.43 R214.1 64.83,85.04 65.18,84.69 66.08,84.69 66.97,85.58 TP38.1 67.22,86.06 R206.2 68.28,86.06 68.58,85.76 Q25.3
RT_I2C_SCL: length 69.6
  TOP w0.079: U9.C9 v2(37.24,88.76) ; v2(32.68,71.48) 32.68,71.5 U16.C9
  TOP w0.14: v1(68.22,82.15) 68.22,82.38 69.1,83.26 Q29.1 70.12,83.26 70.3,83.08 R254.1
  IN2 w0.089: v2(37.24,88.76) 37.12,88.76 36.31,87.95 36.31,86.69 36.1,86.48 36.1,83.88 36.58,83.4 36.96,83.4 37.24,83.12 37.24,82.54 36.96,82.26 36.71,82.26 36.33,81.88 36.33,79.34 36.84,78.83 36.84,77.52 34.61,75.29 32.67,75.29 32.23,74.85 32.23,71.93 v2(32.68,71.48)
  IN4 w0.086: v1(68.22,82.15) 67.74,81.68 66.81,81.68 65.99,82.5 65.99,84.34 66.84,85.19 66.84,85.71 66.42,86.13 65.39,86.13 65.15,85.89 63.09,85.89 62.37,86.62 60.52,86.62 59.23,85.32 50.61,85.32 50.43,85.14 47.38,85.14 47.19,84.95 43.58,84.95 40.76,87.78 37.86,87.78 37.24,88.4 v2(37.24,88.76)
  BOTTOM w0.14: R866.1 36.56,87.42 36.62,87.42 37.13,87.92 v1(37.26,87.92) 37.26,88.74 v2(37.24,88.76) ; v2(32.68,71.48) 32.59,71.39 32.59,70.52 32.26,70.19 R961.1
RT_I2C_SCL_D: length 22.8
  TOP w0.14: v1(71.42,83.85) R254.2 71.42,82.88 70.86,82.33 69.3,82.33 67.33,80.35 U14.6 63.9,80.35 TP43.1 63.71,81.6 63.71,82.36 64.69,83.34 64.69,84.19 R230.1 64.59,84.45 64.24,84.8 64.24,85.22 63.57,85.89 63.06,85.89 62.13,86.83 U11.A2 ; v2(67.91,82.69) Q29.6
  BOTTOM w0.14: v1(71.42,83.85) 70.26,82.69 v2(67.91,82.69)
RT_I2C_SDA: length 69.5
  TOP w0.079: v2(37.89,88.73) 37.89,89.41 U9.E7 ; U16.E7 33.36,72.18 v2(33.36,71.46)
  TOP w0.14: Q29.4 66.99,84.56 66.59,84.16 66.59,83.11 R255.1 67.52,82.19 v1(67.52,82.15)
  IN2 w0.089: v2(37.89,88.73) 37.76,88.73 36.8,87.78 36.8,86.16 36.58,85.94 36.58,84.16 36.83,83.91 37.34,83.91 38.2,83.05 38.2,82.54 37.87,82.21 37.87,76.89 36.44,75.45 36.44,72.97 36.11,72.64 33.96,72.64 33.36,72.03 v2(33.36,71.46)
  IN4 w0.086: v2(37.89,88.73) 37.89,88.46 38.02,88.32 40.87,88.32 43.77,85.42 46.99,85.42 47.18,85.61 50.23,85.61 50.41,85.79 59.03,85.79 60.33,87.08 62.56,87.08 63.29,86.36 64.96,86.36 65.2,86.6 66.61,86.6 67.31,85.9 67.31,85 66.46,84.15 66.46,82.69 67.01,82.15 v1(67.52,82.15)
  BOTTOM w0.14: R867.1 37.24,87.34 37.47,87.34 37.89,87.76 v2(37.89,88.73) ; v2(33.36,71.46) 33.36,70.53 33.03,70.19 R962.1
RT_I2C_SDA_D: length 16.1
  TOP w0.102: U11.B2 U11.A1
  TOP w0.14: Q29.3 68.95,84.56 68.49,85.02 67.05,85.02 66.31,84.28 66.31,83.43 R255.2 65.91,81.78 65.75,81.62 U14.5 64.14,81.62 64.01,81.75 64.01,82 TP41.1 65.05,83.04 65.05,83.86 65.34,84.14 R231.1 65.18,84.29 64.52,84.96 64.52,85.28 63.66,86.14 63.15,86.14 62.52,86.78 U11.A1
RT_PWR_EN_P1: length 17.8
  TOP w0.14: U5.C2 53.35,99.53 v1(53.09,99.78) v1(52.33,99.78) R121.1
  IN3 w0.089: v1(52.33,99.78) 54.49,99.78 55.76,98.51 57.92,98.51 60.58,95.85 60.58,94.58 v1(62.36,92.8)
  BOTTOM w0.14: R842.1 61.17,92.36 61.61,92.8 v1(62.36,92.8)
RT_PWR_EN_P1_C: length 3.7
  TOP w0.079: U11.G6 60.72,89.43 60.72,90.06 60.67,90.11 60.67,91 v1(60.78,91.11)
  BOTTOM w0.14: R842.2 60.83,91.16 v1(60.78,91.11) 60.78,90.71 60.58,90.51 v1(60.58,90.39)
RT_PWR_EN_P2: length 16.9
  TOP w0.14: v1(48.19,81.8) 47.91,81.8 46.7,83.01 R256.1 46.33,81.34 45.98,80.99 U13.C2
  IN1 w0.086: v1(56.39,84.18) 54.78,84.18 52.39,81.8 v1(48.19,81.8)
  BOTTOM w0.14: R881.1 59.28,84.42 56.62,84.42 v1(56.39,84.18)
RT_PWR_EN_P2_C: length 3.1
  TOP w0.079: U11.B6 60.72,87.03 60.72,86.03 v1(60.78,85.97)
  BOTTOM w0.14: v1(60.78,85.97) 60.38,85.97 v1(60.14,85.73) R881.2
RT_RESET_P1: length 41.5
  TOP w0.14: v1(33.12,94.64) 33.12,95.08 32.73,95.48 32.25,95.48 32.24,95.47 R153.2
  IN4 w0.086: v1(33.12,94.64) 33.18,94.58 33.18,84.19 33.89,83.48 33.89,82.68 34.06,82.5 43.1,82.5 43.39,82.79 47.74,82.79 48.03,82.5 51.63,82.5 52.66,83.53 v1(56.39,83.53)
  BOTTOM w0.14: R882.1 59.77,84.14 57,84.14 v1(56.39,83.53)
RT_RESET_P1_C: length 3.9
  TOP w0.102: U11.B3 61.72,87.63 v2(61.66,87.68)
  BOTTOM w0.14: R882.2 60.5,85.02 61.56,86.08 v1(61.56,86.99) 61.56,87.59 v2(61.66,87.68)
RT_RESET_P2: length 62
  TOP w0.14: R324.2 27.82,78.61 v1(28.04,78.61)
  IN4 w0.086: v1(66.29,85.56) 65.48,85.56 64.22,84.3 57.78,84.3 56.58,83.11 55.71,83.11 55.48,83.34 52.74,83.34 51.71,82.31 47.95,82.31 47.66,82.6 43.47,82.6 43.17,82.31 33.99,82.31 33.7,82.6 33.7,83.24 32.41,84.52 30.93,84.52 27.47,87.98 24.96,87.98 24.54,87.57 23.73,87.57 22.43,86.27 22.43,82.95 24.54,80.83 25.83,80.83 v1(28.04,78.61)
  BOTTOM w0.14: R870.1 66.01,85.56 v1(66.29,85.56)
RT_RESET_P2_C: length 4.2
  TOP w0.079: v1(63.51,86.76) 63.5,86.77 63.41,86.77 62.75,87.43 62.32,87.43 U11.C2
  BOTTOM w0.14: R870.2 64.8,86.15 64.31,85.67 v1(64.04,85.67) 63.84,85.87 63.84,86.14 63.51,86.47 63.51,86.76 v1(63.51,86.76)
RTC_RST#: length 25.1
  TOP w0.14: v1(218.22,53.47) 218.62,53.47 219.74,52.35 225.73,52.35 v1(227.08,51.01)
  BOTTOM w0.102: U49.AM45 216.7,57.43 216.54,57.27 216.54,56.11 216.33,55.9 216.33,54.98 216.64,54.68 217.19,54.13 217.19,53.82 217.19,53.47 217.43,53.23 217.97,53.23 v1(218.22,53.47)
  BOTTOM w0.14: v1(227.08,51.01) 227.08,51.61 J4.1 227.83,51.09 229.14,51.09 229.7,51.66 229.7,52.1 229.99,52.38 C825.1 230.49,52.38 230.59,52.29 Q112.3 232.72,52.29 233.33,51.68 R1103.2
RTC_X1: length 5.7
  BOTTOM w0.102: 219.29,53.25 219.29,53.27 217.55,55.01 217.55,55.73 217.39,55.88 217.39,56.38 217.24,56.54 217.24,56.87 U49.AM46
  BOTTOM w0.14: R1070.2 219.29,52.8 219.29,53.25
RTC_X1_C: length 4.4
  BOTTOM w0.14: Y4.1 218.51,49.52 219.38,50.39 C829.2 219.38,51.12 219.34,51.16 R1083.1 219.34,51.96 R1070.1
RTC_X2: length 4.3
  BOTTOM w0.102: U49.AM48 217.19,55.96 217.19,55.8 217.35,55.64 217.35,54.93 218.77,53.5 218.77,53.25
  BOTTOM w0.14: R1069.2 218.77,53.25
RTC_X2_C: length 5.8
  BOTTOM w0.14: R1069.1 218.89,52.02 R1083.2 218.89,51.19 218.85,51.15 C828.2 218.85,50.43 v1(217.99,49.57) 217.62,49.2 216.41,49.2 216.01,48.8 Y4.2
RVN: length 11.6
  IN3 w0.762: 298.63,73.55 298.63,72.49 299.22,71.91 299.22,71.25 301.95,68.51 302.61,68.51 303.58,67.54 303.58,66.28 304.93,64.94
  vias: v1(299.24,74.34) v1(305.31,64.15)
S5_ON: length 436.7
  TOP w0.14: v1(68.76,50.22) PR306.1 ; 65.99,68.65 66.31,68.33 PQ26.2 ; 65.99,68.65 70.97,68.65 74.8,64.82 89.6,64.82 90.26,65.48 v1(90.26,66.78) ; 65.99,68.65 65.19,69.46 62.28,69.46 60.79,67.96 53.6,67.96 53.29,68.26 53.29,68.87 53.44,69.02 PR262.2 ; v1(146.21,69.15) 146.21,69.68 PR258.2 ; v1(128.93,70.04) 128.99,70.1 PR252.2 ; R361.1 180.83,75.05 180.55,74.77 180.55,74.57 v1(180.43,74.45) 180.71,74.18 U23.100 ; v1(258.46,60.71) 258.46,60.09 260.67,57.89 260.85,57.89 261.33,57.41 PU16.1 261.33,56.52 262.06,55.79 264.62,55.79 268.2,52.21 269.29,52.21 269.67,51.82 269.67,50.95 265.35,46.63 262.22,46.63 261.36,45.76 261.36,41.11 258.96,38.71 v1(258.96,37.4)
  IN2 w0.089: v1(151.46,75) 152.28,75.81 153.61,75.81 154.32,76.52 157.34,76.52 157.88,75.99 157.88,75.53 159.34,74.06 160.15,74.06 160.45,73.76 167.88,73.76 168.27,73.37 173.34,73.37 174,74.03 180.02,74.03 v1(180.43,74.45) ; v1(128.93,70.04) 123.86,70.04 119.43,65.62 96.44,65.62 95.27,66.78 v1(90.26,66.78)
  IN3 w0.089: v1(68.76,50.22) 69.21,49.77 72.59,49.77 72.85,50.03 72.85,51.27 77.07,55.49 v1(90.29,55.49) 94.59,55.49 97.8,58.7 99.39,58.7 100.11,59.43 100.94,59.43 102.29,60.78 111,60.78 111.36,61.14 111.6,61.14 111.72,61.27 121.87,61.27 122.86,62.25 124.33,62.25 125.44,63.37 140.51,63.37 142.98,65.84 146.23,65.84 148.64,68.24 153.37,68.24 154.46,67.15 159.76,67.15 160.56,67.95 161.51,67.95 162.22,68.66 164.73,68.66 165.07,68.32 170.94,68.32 171.24,68.02 v1(171.26,68.02) ; v1(128.93,70.04) 128.93,70.3 130.83,72.21 138.17,72.21 139.68,73.72 149.38,73.72 150.66,75 v1(151.46,75)
  IN4 w0.086: v1(181.51,52.65) 182.14,52.02 184.98,52.02 192.64,44.36 193.42,44.36 195.65,42.13 197.37,42.13 199.15,40.35 209.06,40.35 209.97,39.44 219.51,39.44 220.88,40.81 224.89,40.81 228.23,37.48 239.01,37.48 239.13,37.6 239.92,37.6 240.22,37.9 243.99,37.9 244.57,37.31 245.25,37.31 245.91,36.65 258.21,36.65 v1(258.96,37.4)
  BOTTOM w0.14: v1(128.93,70.04) 129.38,70.5 144.87,70.5 v1(146.21,69.15) ; v1(90.26,66.78) 90.29,66.75 v1(90.29,55.49) ; v1(171.26,68.02) 171.26,64.19 171.98,63.46 171.98,63.46 172.22,63.22 172.23,63.21 172.23,62.39 172.39,62.23 172.39,58.39 174.02,56.76 175.83,56.76 176.99,55.61 176.99,55.56 178.4,54.15 180.51,54.15 181.51,53.15 v1(181.51,52.65) ; PR618.2 260.45,60.39 259.71,61.14 258.89,61.14 v1(258.46,60.71)
S5_ON_R: length 47.4
  TOP w0.203: v1(68.49,51.94) 68.76,51.66 PR306.2 ; v1(68.49,51.94) 68.13,51.58 68.13,51.51 PC227.1 ; v1(68.49,51.94) 68.5,51.95 PU17.3 ; v1(72.42,51.65) 71.75,51.65 PC226.1 71.67,51.58 71.19,52.06 69.65,52.06 69.3,52.41 PU17.5
  IN4 w0.086: v1(56.62,60.4) 58.77,58.25 73.71,58.25 74.89,57.07 74.89,53.8 72.74,51.65 v1(72.42,51.65) 68.77,51.65 v1(68.49,51.94)
  BOTTOM w0.14: v1(56.62,60.4) 56.62,60.82 54.57,62.88 54.57,69.19 v1(55.11,69.73)
SATA_LED#: length 384.5
  TOP w0.14: v1(206.2,56.29) 206.2,56.28 206.2,56.28 206.2,56.23 205.91,55.94 R582.1 ; v1(269,191.12) 268.82,191.3 268.71,191.3 D5.1 268.05,191.3 267.58,190.83 267.17,190.83 266.95,191.05 CN1.22 ; v1(103.51,72.14) 103,72.14 101.66,70.79 101.66,66.93 101.56,66.83 101.56,62.16 98.55,59.15 98.55,58.88 97.11,57.44 97.11,54.44 v1(97.42,54.14)
  IN2 w0.089: v1(201.53,53.54) 201.53,54.38 199.96,55.96 199.96,57.17 198.52,58.61 198.29,58.61 196.7,60.2 193.48,60.2 193.15,60.52 192.53,60.52 191.77,61.28 188.87,61.28 187.07,63.08 187.07,63.74 185.18,65.64 184.38,65.64 183.64,66.37 182.25,66.37 181.9,66.03 179.74,66.03 179.05,66.73 178.25,66.73 177.36,67.62 172.49,67.62 172.3,67.43 165.81,67.43 164.35,68.89 158.6,68.89 157.94,69.55 134.04,69.55 129.7,65.22 124.85,65.22 122.34,62.7 113.11,62.7 112.19,61.78 110.87,61.78 106.54,57.46 103.99,57.46 100.21,53.68 97.87,53.68 v1(97.42,54.14)
  IN3 w0.089: v1(269,191.12) 271.74,191.12 272.76,190.1 277.87,190.1 281.49,186.48 281.49,154.08 280.05,152.63 280.05,131.94 277.36,129.26 274.33,129.26 267.89,122.81 267.59,122.81 266.07,121.29 266.07,121.13 264.85,119.91 263.02,119.91 262.76,119.66 261.85,119.66 261.48,119.29 261.48,117.84 259.78,116.14 259.78,115.72 259.66,115.6 258.8,115.6 258.15,116.25 256.58,116.25 255.49,115.16 254.13,115.16 253.64,115.66 251.44,115.66 250.79,115.01 248.81,115.01 247.88,115.94 244.61,115.94 243.56,114.89 240.45,114.89 240.17,114.6 231.64,114.6 231.08,115.17 230.41,115.17 229.95,114.71 212.37,114.71 208.18,110.51 208.18,105.92 207.18,104.93 207.18,101.66 206.14,100.61 205.53,100.61 204.1,99.18 204.1,98.37 202.77,97.04 202.3,97.04 198.89,93.63 198.89,87.58 197.97,86.66 197.97,80.83 197.82,80.69 197.82,76.94 197.65,76.77 197.65,68.74 197.81,68.58 197.81,67.67 198.04,67.43 198.04,64.29 198.45,63.88 198.45,61.86 197.88,61.29 197.88,60.95 198.3,60.53 201.62,60.53 203.45,58.7 203.45,57.56 204.3,56.71 205.72,56.71 206.14,56.29 v1(206.2,56.29)
  BOTTOM w0.102: U49.L47 206.21,56.29 v1(206.2,56.29) 206.2,56.28 206.2,56.28 206.2,56.16 205.64,55.6 205.64,55.18 205.05,54.59 204.51,54.59 203.98,54.07 202.06,54.07 v1(201.53,53.54)
  BOTTOM w0.14: v1(97.42,54.14) 97.42,53.45 98.58,52.28 R1072.2 ; v1(269,191.12) 268.46,191.66 267.82,191.66 267.57,191.91 EC1.2 ; v1(103.51,72.14) 103.53,72.14 103.67,72.28 103.67,73.43 102.87,74.23 100.74,74.23 99.75,75.22 99.75,76.98 99.85,77.08 R930.2
SATA_RXN0_CN: length 8.3
  BOTTOM w0.14: CN18.16 279.87,40.45 279.84,40.48 277.33,40.48 276.59,41.21 274.17,41.21 273.43,41.95 273.43,42.41 C848.1
SATA_RXN0_HDD: length 100.9
  IN1 w0.086: v1(267.82,51.25) 267.87,51.3 268,51.3 268.17,51.14 268.17,50.37 266.98,49.19 258.27,49.19 257.7,48.62 250.69,48.62 249.14,47.07 246.04,47.07 245.12,46.15 244.32,46.15 243.67,46.8 242.71,46.8 241.87,45.96 240.97,45.96 240.85,45.84 237.97,45.84 237.64,46.17 229.05,46.17 228.51,46.7 223.96,46.7 222.18,44.93 219.43,44.93 219.05,45.31 214.35,45.31 213.01,46.65 210.32,46.65 207.57,49.39 205.57,49.39 203.81,51.14 199.88,51.14 198.36,52.66 197.18,52.66 196.78,53.05 196.78,53.8 197.01,54.03 v1(197.01,54.03)
  BOTTOM w0.102: U49.H38 204.58,60.83 204.58,60.72 204.71,60.6 204.71,60.15 204.49,59.93 203.99,59.93 203.79,59.73 203.39,59.73 203,59.34 202.81,59.27 202,59.27 201.77,59.5 201.14,59.5 200.34,58.7 200.34,56.34 199.7,55.7 198.54,55.7 198.08,55.23 198.08,55.18 198.06,55.17
  BOTTOM w0.14: v1(267.82,51.25) 267.94,51.25 268.08,51.12 268.08,50.83 268.38,50.54 269.72,50.54 269.81,50.63 271.04,50.63 271.18,50.49 271.92,50.49 272.11,50.68 272.69,50.68 272.88,50.87 273.29,50.87 273.43,50.73 273.43,50.49 273.29,50.35 C831.2 ; v1(197.01,54.03) 196.77,54.27 196.77,54.49 197.1,54.81 197.7,54.81 198.06,55.17
SATA_RXN_IN: length 1.6
  BOTTOM w0.14: C831.1 273.42,49.67 273.42,49.14 273.3,49.03 U55.4
SATA_RXN_OUT: length 1.9
  BOTTOM w0.14: C848.2 273.62,43.3 273.62,43.43 273.42,43.64 273.42,43.97 273.3,44.09 U55.12
SATA_RXP0_CN: length 8.3
  BOTTOM w0.14: C849.1 273.85,42.54 273.7,42.38 273.7,42.06 274.28,41.48 276.7,41.48 277.44,40.74 279.64,40.74 279.85,40.95 CN18.15
SATA_RXP0_HDD: length 101
  IN1 w0.086: v1(268.53,51.3) 268.33,51.09 268.33,50.3 267.05,49.02 258.34,49.02 257.77,48.46 250.76,48.46 249.21,46.91 246.11,46.91 245.19,45.99 244.26,45.99 243.61,46.64 242.78,46.64 241.94,45.8 241.04,45.8 240.92,45.68 237.9,45.68 237.57,46.01 228.98,46.01 228.45,46.54 224.03,46.54 222.25,44.76 219.36,44.76 218.98,45.14 214.28,45.14 212.94,46.48 210.25,46.48 207.5,49.23 205.5,49.23 203.74,50.98 199.81,50.98 198.29,52.49 197.11,52.49 196.62,52.98 196.62,53.73 v1(196.34,54.01)
  BOTTOM w0.102: U49.G39 204.38,60.63 204.5,60.51 204.5,60.24 204.4,60.14 203.91,60.14 203.7,59.93 203.3,59.93 202.89,59.52 202.77,59.48 202.08,59.48 201.85,59.7 201.06,59.7 200.14,58.78 200.14,56.42 199.61,55.9 198.46,55.9 197.93,55.37 197.89,55.37 197.87,55.35
  BOTTOM w0.14: v1(196.34,54.01) 196.51,54.17 196.51,54.6 196.99,55.08 197.59,55.08 197.87,55.35 ; v1(268.53,51.3) 268.49,51.3 268.35,51.16 268.35,50.94 268.49,50.8 269.61,50.8 269.7,50.89 271.15,50.89 271.29,50.75 271.8,50.75 272,50.95 272.58,50.95 272.77,51.14 273.4,51.14 273.69,50.84 273.69,50.6 C832.2
SATA_RXP_IN: length 1.6
  BOTTOM w0.14: U55.5 273.8,49.05 273.68,49.17 273.68,49.64 C832.1
SATA_RXP_OUT: length 1.9
  BOTTOM w0.14: C849.2 273.89,43.29 273.89,43.54 273.68,43.75 273.68,43.95 273.8,44.07 U55.11
SATA_TXN0_CN: length 10.8
  BOTTOM w0.14: C847.1 272.1,42.54 271.94,42.37 271.94,41.89 273.16,40.67 276.51,40.67 277.96,39.22 279.63,39.22 279.86,39.45 CN18.18
SATA_TXN0_HDD: length 93.9
  IN1 w0.086: v1(266.9,50.79) 266.67,50.79 266.59,50.88 266.59,51.23 266.31,51.51 265.84,51.51 264.96,50.62 256.91,50.62 255.47,49.19 250.47,49.19 248.91,47.63 242.75,47.63 241.77,46.64 240,46.64 239.82,46.82 237.57,46.82 237.47,46.73 229.28,46.73 228.75,47.26 223.52,47.26 221.74,45.48 219.69,45.48 219.3,45.87 214.58,45.87 213.24,47.2 210.55,47.2 209.17,48.58 209.17,49.44 207.82,50.79 205.94,50.79 204.61,52.12 199.84,52.12 198.73,53.23 198.73,53.96 197.81,54.89 196.87,54.89 196.3,55.45 196.3,56.38 196.2,56.48 196.2,57.09 v1(196.54,57.43)
  BOTTOM w0.102: 197.87,60.08 197.89,60.08 197.93,60.11 198.93,60.11 199.37,60.55 200.14,60.55 200.54,60.95 201.88,60.95 201.94,61.01 202.39,61.01 U49.C38
  BOTTOM w0.14: C833.2 268.65,50.08 268.65,49.88 268.51,49.74 267.65,49.74 267.47,49.57 266.8,49.57 266.59,49.78 266.59,50.65 266.73,50.79 v1(266.9,50.79) ; v1(196.54,57.43) 196.33,57.64 196.33,58.37 196.63,58.67 196.63,59.17 197.53,60.08 197.87,60.08
SATA_TXN_IN: length 4.5
  BOTTOM w0.14: C833.1 269.21,49.98 271.86,49.98 272.3,49.54 U55.2
SATA_TXN_OUT: length 1.8
  BOTTOM w0.14: C847.2 272.15,43.25 272.15,43.8 272.3,43.94 U55.14
SATA_TXP0_CN: length 10.8
  BOTTOM w0.14: C846.1 271.67,42.4 271.67,41.78 273.04,40.4 276.4,40.4 277.85,38.95 CN18.19
SATA_TXP0_HDD: length 93.9
  IN1 w0.086: v1(195.69,57.43) 196.03,57.09 196.03,56.41 196.14,56.31 196.14,55.39 196.8,54.73 197.74,54.73 198.57,53.89 198.57,53.16 199.77,51.96 204.54,51.96 205.87,50.62 207.76,50.62 209.01,49.37 209.01,48.51 210.48,47.04 213.17,47.04 214.51,45.7 219.23,45.7 219.62,45.32 221.81,45.32 223.59,47.1 228.68,47.1 229.21,46.56 237.54,46.56 237.63,46.66 239.75,46.66 239.93,46.48 241.84,46.48 242.82,47.46 248.98,47.46 250.53,49.02 255.54,49.02 256.98,50.46 265.03,50.46 265.91,51.34 266.25,51.34 266.42,51.17 266.42,50.93 266.29,50.8 v1(266.15,50.8)
  BOTTOM w0.102: 197.87,60.34 197.89,60.34 197.93,60.31 198.85,60.31 199.29,60.75 200.05,60.75 200.46,61.16 201.8,61.16 201.85,61.22 202.06,61.22 U49.B37
  BOTTOM w0.14: v1(195.69,57.43) 195.82,57.43 196.07,57.68 196.07,58.48 196.36,58.78 196.36,59.29 197.42,60.34 197.87,60.34 ; v1(266.15,50.8) 266.32,50.63 266.32,49.67 266.69,49.3 267.58,49.3 267.76,49.47 268.5,49.47 C835.2
SATA_TXP_IN: length 4.4
  BOTTOM w0.14: C835.1 269.06,49.36 269.06,49.56 269.21,49.71 271.75,49.71 272.03,49.43 272.03,49.23 271.8,49 U55.1
SATA_TXP_OUT: length 1.8
  BOTTOM w0.14: C846.2 271.88,43.34 271.88,43.86 271.8,43.94 U55.15
SIM_DET: length 226.2
  TOP w0.14: R430.1 164.97,70.25 165.17,70.45 165.17,70.89 v1(165.13,70.93) ; R258.1 312.07,83.12 312.21,83.26 312.25,83.26 312.5,83.5 R250.1 312.8,83.99 312.8,85.28 QG16.3 312.63,85.56 313.36,86.3 313.36,86.86 313.66,87.15 313.66,87.37 v1(313.96,87.67) ; v1(171.17,54.06) 171.03,54.06 170.1,54.98 R585.1
  IN3 w0.089: v1(171.17,54.06) 171.33,54.06 172.39,53 173.13,53 173.48,53.34 177.15,53.34 179.3,51.2 182.05,51.2 182.32,50.93 183.06,50.93 183.7,50.29 183.7,50.2 184.66,49.24 187.68,49.24 191.14,45.78 194.27,45.78 194.93,45.12 197.77,45.12 197.97,44.92 205.12,44.92 205.13,44.9 208.98,44.9 210.07,45.99 211.73,45.99 212,45.73 218.57,45.73 218.71,45.87 220.3,45.87 220.75,46.32 220.75,47.04 221.4,47.68 222.43,47.68 223.45,48.71 223.67,48.71 224.81,49.85 229.74,49.85 230.15,50.26 232.75,50.26 232.91,50.42 236.89,50.42 237.77,51.3 238.78,51.3 239.55,52.07 241.98,52.07 243.23,53.32 246.77,53.32 247.43,53.98 249.78,53.98 250.78,52.98 251.85,52.98 252.38,53.51 256.89,53.51 257.2,53.2 260.55,53.2 263.01,55.66 264.36,55.66 265.71,57.01 270.88,57.01 271.65,56.24 273.6,56.24 274.48,57.11 276.01,57.11 276.59,57.69 277.56,57.69 278.11,58.24 278.11,59.12 278.78,59.79 278.78,61.52 277.35,62.95 277.35,69.11 278.29,70.04 279.13,70.04 279.64,70.55 279.64,70.92 279.03,71.53 279.03,72.26 279.68,72.91 281.38,72.91 281.94,73.47 281.94,74.77 283.7,76.52 283.7,76.9 284.36,77.56 285.32,77.56 287.91,80.15 287.91,81.72 291.02,84.82 292.11,84.82 293.65,86.36 293.65,87.38 294.4,88.14 296.49,88.14 296.92,88.57 296.92,89.91 299.85,92.84 299.85,96.29 301.57,98.01 304.8,98.01 305.1,97.71 308.42,97.71 309.53,96.6 309.66,96.6 311.28,94.98 312.17,94.98 313.31,93.84 313.31,89.32 313.96,88.67 v1(313.96,87.67)
  BOTTOM w0.14: v1(165.13,70.93) 166.69,69.37 166.69,62.54 164.34,60.19 164.34,58.63 165.68,57.3 169.68,57.3 170.85,56.13 170.85,54.35 171.14,54.06 v1(171.17,54.06)
SIO_EXT_SCI#: length 7.8
  TOP w0.14: v1(221.39,66.49) 221.49,66.59 TP61.1
  BOTTOM w0.102: R975.1 226.93,67.12 224.8,67.12 224.42,66.74 223.34,66.74 223.24,66.84 223.24,66.89 223.21,66.92 223.21,66.93 222.94,67.2 222.05,67.2 U49.BB26 221.77,66.87 v1(221.39,66.49)
SKTOCC_N: length 6
  BOTTOM w0.079: U42.CR3 128.46,129.58 128.46,129.02 128.34,128.89 127.8,128.89 127.18,128.27 126.86,128.27
  BOTTOM w0.14: TP112.1 126.86,128.27
SLP_A#: length 5.1
  BOTTOM w0.102: 213.55,53.25 213.55,53.59 213.77,53.82 213.77,54.6 213.62,54.75 213.62,56.12 213.85,56.36 213.85,56.57 U49.AF46
  BOTTOM w0.14: R1081.1 213.55,52.09 213.55,53.25
SLP_S5#: length 6.6
  BOTTOM w0.102: 216.23,53.25 216.23,53.38 216,53.61 216,54.45 215.72,54.73 215.72,55.76 215.63,55.86 U49.AJ47
  BOTTOM w0.14: R1106.1 216.34,50.64 216.54,50.85 TP167.1 216.23,51.52 216.23,52.11 216.05,52.29 216.05,52.83 216.23,53.01 216.23,53.25
SLP_SUS#_EC: length 205.5
  TOP w0.14: PU16.2 261.98,56.5 262.35,56.13 264.76,56.13 268.34,52.55 269.43,52.55 270.02,51.97 270.02,50.8 265.5,46.28 262.37,46.28 261.71,45.62 261.71,40.97 259.62,38.88 v1(259.62,37.38) ; v1(170.31,63.15) 171.41,62.04 171.41,61.64 171.74,61.31 171.74,59.95 170.89,59.09 169.68,59.09 169.16,58.58 169.16,57.16 R576.2 168.82,56.49 169.09,56.22 170.16,56.22 170.31,56.37 U23.35
  IN2 w0.089: v1(170.31,63.15) 170.31,63.72 170.62,64.03 170.98,64.03 171.57,63.43 172,63.43 172.2,63.24 173.85,63.24 173.96,63.35 174.61,63.35 175.32,62.64 177.95,62.64 178.6,63.29 180.81,63.29 181.26,63.75 181.91,63.75 182.37,63.29 182.37,62.88 182.69,62.56 182.7,62.56 183.86,61.4 183.86,59.89 185.1,58.64 185.97,58.64 188.06,56.55 190.07,56.55 192.22,54.4 192.22,54.09 197.09,49.22 200.86,49.22 202.08,50.44 209.05,50.44 211.16,52.56 v1(211.72,53.11)
  IN4 w0.086: v1(180.86,52.63) 180.86,52.51 181.64,51.73 184.86,51.73 186.06,50.53 186.06,49.52 186.54,49.04 187.55,49.04 191.71,44.88 192.52,44.07 193.3,44.07 195.53,41.84 197.25,41.84 199.03,40.06 208.94,40.06 209.85,39.15 219.63,39.15 221,40.52 224.77,40.52 228.11,37.19 239.13,37.19 239.25,37.31 240.04,37.31 240.34,37.61 241.38,37.61 241.68,37.31 244.17,37.31 244.45,37.03 245.13,37.03 245.79,36.36 258.6,36.36 v1(259.62,37.38)
  BOTTOM w0.102: U49.AD46 212.9,56.57 212.57,56.24 212.57,56.22 212.47,56.12 212.47,54.62 212.35,54.51 212.35,53.79 211.72,53.16 v1(211.72,53.11) 211.55,52.95 C822.1 211.17,52.65 211.15,52.62 R1068.1
  BOTTOM w0.14: v1(170.31,63.15) 170.31,62.81 171.41,61.71 171.41,61.05 171.91,60.55 171.91,60.14 171.46,59.69 171.46,58.83 173.88,56.42 174.5,56.42 175.96,54.96 177.1,54.96 178.26,53.81 179.68,53.81 v1(180.86,52.63)
SLP_WLAN#_R: length 59.1
  TOP w0.14: v1(174.63,55.62) 174.63,55.38 175.47,54.54 175.47,53.06 175.33,52.92 Q55.2
  IN3 w0.089: v1(174.63,55.62) 174.63,55.08 175,54.71 175.44,54.71 175.95,55.22 177.15,55.22 177.51,54.86 177.78,54.86 179.29,53.34 182.04,53.34 182.84,52.55 184.38,52.55 185.53,51.39 190.81,51.39 193,49.2 194.07,49.2 195.87,47.39 198.71,47.39 198.92,47.19 202.44,47.19 203.08,47.84 203.43,47.84 203.95,48.36 203.95,48.63 204.5,49.18 208.12,49.18 208.82,48.47 209.46,48.47 209.58,48.36 212.2,48.36 212.62,48.78 213.94,48.78 v1(214.38,48.33)
  BOTTOM w0.102: U49.AJ46 215.2,56.82 215.2,55.71 215.31,55.6 215.31,54.75 215.2,54.63 215.2,54.32 215.14,54.26 215.14,54.05 215.51,53.68 215.64,53.68 215.95,53.38 215.95,53.25
  BOTTOM w0.14: 215.95,53.25 215.95,53.17 215.88,53.1 215.88,53.05 215.77,52.94 215.77,52.18 215.9,52.04 215.9,50.74 215.77,50.61 R1107.1 215.77,50.28 215.3,49.8 215.12,49.8 TP176.1 214.52,49.2 214.38,49.06 v1(214.38,48.33)
SLP_WLAN_PWR#: length 4.4
  TOP w0.14: R588.1 171.63,54.98 172.28,54.33 172.28,53.85 172.32,53.8 R611.1 172.32,53.14 172.56,52.9 R614.2 172.75,52.56 Q55.3
SM_INTRUDER#: length 6
  BOTTOM w0.102: U49.AE47 213.41,56.38 213.41,54.67 213.57,54.51 213.57,53.9 213.2,53.54 213.2,53.25
  BOTTOM w0.14: R1105.1 212.74,50.95 213.12,51.33 213.12,52.53 213.2,52.61 213.2,53.25
SM_RCOMP_2: length 5.1
  BOTTOM w0.102: U42.D2 174.19,129.06 174.55,128.7 174.55,128.47 174.82,128.2 175.26,128.2 177.31,126.16 R815.2
SMB1_CLK_D: length 11.2
  TOP w0.079: U11.E2 62.32,88.23 62.87,88.23 63.12,88.48 63.44,88.48 v1(63.44,88.47)
  BOTTOM w0.14: v1(63.44,88.47) 63.45,88.47 63.67,88.25 TP129.1 64.44,88.25 64.67,88.48 R858.1 64.8,88.22 64.94,88.08 65.64,88.08 66.28,88.72 66.28,89.41 67.49,90.62 68.23,90.62 68.72,90.12 R848.2 69.22,90.01 69.47,89.75 69.47,88.99 69.36,88.88 Q106.1
