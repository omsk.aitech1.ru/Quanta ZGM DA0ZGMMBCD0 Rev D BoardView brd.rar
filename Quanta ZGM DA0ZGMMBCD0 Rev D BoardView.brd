# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Nets (continued)
+3VPCU_ECPLL: C373.2 L7.1 U23.127
+3VSPI: C796.1 R579.1 R580.1 U53.8
+5V: C326.2 C327.2 C328.2 C341.2 C380.2 C384.1 C389.2 C399.1 C549.1 C550.1 C773.2 D23.1 L5.1 L8.1 PR208.2 PR209.2 PR270.1 Q110.3 R273.1 R283.1 R629.1 R641.1 R818.1 R819.1 R1002.2 U21.41 U21.42 U21.43 U21.44 U31.3
+5V_HDD: C528.1 C529.1 C530.1 C531.1 C532.2 C533.2 CN18.3 CN18.4 CN18.5 CN18.6 R641.2
+5V_HDMIC: C553.1 CN23.18 R1177.1 R1178.1 RV2.1 U31.1(OUT)
+5V_KB: C542.1 CN19.10 CN19.11 CN19.12 R619.2 R643.2 U54.5
+5V_LED: C575.2 C576.2 D51.1(CATHODE) Q1.1 Q1.4(S) Q3.1 Q3.4(S) Q5.1(S) Q74.1 Q74.4(S) Q79.1 Q79.4(S) Q85.1(S) Q125.1(S) R2.2 R3.2 R6.2 R9.2 R27.2 R689.2 R701.1 R702.1 R703.2 R719.2 R720.2 R733.2 R1211.2
+5V_LIGHT: C548.1 CN21.1 CN21.2 CN21.3 CN21.4 R646.2
+5V_MCU: C592.2 C593.2 D52.1(CATHODE) Q77.1(S) Q78.1 Q78.4(S) R43.2 R45.2 R46.1 R711.1 R712.1 R716.1 R717.1 U1.8
+5V_PVDD: C351.2 C353.2 C362.2 C372.2 L5.2 Q110.1(S) U20.41 U20.46
+5V_S5: C543.1 C547.1 PC26.1 PC365.1 PC366.1 PC367.1 PC368.1 PC369.1 PC370.1 PC400.1 PC429.1 PC430.1 PC443.1 PC444.1 PC445.1 PC446.1 PC447.1 PC448.1 PR30.1 PR33.1 PR36.1 PR37.2 PR146.1 PR185.1 PR191.1 PR196.1 PR202.1 PR210.1 PR214.1 PR222.1 PR225.1 PR229.2 PR230.1 PR232.1 PR236.1 PR243.1 PR355.2 PR378.2 PR402.1 PR438.2 PR439.2 PR440.2 PR441.2 PR442.2 PR443.2 PR446.1 PR448.1 PR450.1 PR452.1 PR454.1 PR456.1 PR526.1 PR550.1 PR551.1 PR552.1 PR553.1 PR554.1 PR555.1 PR556.1 PR557.1 PR624.1 PR626.2 PU4.12 PU21.29 PU22.29 PU23.29 PU24.29 PU25.29 PU26.29 PU28.1(VCC) PU29.4 PU30.4 PU31.4 PU32.4 PU33.4 PU34.4 PU35.4 PU36.4 Q58.1(S) Q61.1(S) R400.2 R628.1 R631.1 R634.1 R642.1 R644.1 R701.2 R702.2 R711.2
+5V_S5_TYPEC: C193.1 C205.1 C214.1 C226.1 C287.1 C301.1 C311.1 C320.1 C711.1 C713.2 C719.1 PR219.1 PR220.1 PR298.1 PR620.1 U11.A7 U11.B7 U11.C7 U11.D7 U11.E7 U11.F7 U11.G7 U11.H7
+5V_S5_TYPEC_R: C761.2 C763.1 C764.1 PC186.1 PC187.1 PC215.1 PC216.1 PR219.2 PR220.2 PR298.2 PR620.2 PU13.8 PU13.9(VOUT2#2) PU13.13 PU13.14 PU17.8 PU17.9(VOUT2#2) PU17.13 PU17.14
+5V_TP_LED: C534.1 CN17.9 R628.2 R629.2
+5VA: C397.2 C405.2 C749.2 C762.2 L8.2 U20.40
+5VPCU: C21.1 C22.1 C175.1 C187.1 C758.1 C759.2 C760.1 C817.1 CN1.1 CN1.2 PJ2.2 PJ3.2 PJ16.1 PR254.2 PR255.2 PR257.1 PR259.2 PR260.2 PR261.2 PR263.2 PR301.2 PR303.2 PR305.2 PR613.1 R167.1 R168.1 R172.1 R173.1 R182.1 R454.1 R740.1 R750.1 R1113.2 R1114.2 R1159.1 R1172.1 TP182.1 U6.1 U7.1 U52.1
+12V_FAN: PC11.1 PR48.1 PR115.1 PR136.2 PR137.1 PU1.8 R215.2 R821.2
+12V_FAN1: C692.2 CN3.1 R821.1
+12V_FAN2: C285.2 CN8.1 R215.1
+19V_VIN1: C24.1 C25.1 C26.2 PC312.1 PC315.1 PC318.1 PC322.1 PC330.2 PD6.1 PJ8.1 PQ48.5 PR401.2 PR410.1 PR428.2
+19V_VIN2: C18.2 C19.1 C20.1 PC293.2 PC296.1 PC300.1 PC304.1 PC306.1 PD7.1 PJ9.1 PQ45.5 PQ47.5 PR84.2 PR90.1 PR98.2
+A3VPCU: C464.1 C465.2 L14.2 U23.74
+V3.3DX_RT_TCP0: C201.2 C202.2 L1.1 U5.A1 U5.B1(VOUT#2)
+V3.3DX_RT_TCP1: C348.2 C349.2 L4.1 U13.A1 U13.B1(VOUT#2)
+VCC0P9_LC_TCP0: C712.2 U9.J3
+VCC0P9_LC_TCP1: C750.2 U16.J3
+VCC0P9_LVR_TCP0: C701.2 C704.2 U9.L6 U9.M6
+VCC0P9_LVR_TCP1: C742.2 C744.2 U16.L6 U16.M6
+VCC0V9_SVR_TCP0: C188.2 C195.1 C216.2 C710.1 C717.2 C718.2 C722.2 C724.2 L2.2 U9.E3 U9.E9 U9.F6 U9.G3 U9.G6 U9.G9
+VCC0V9_SVR_TCP0_PHASE: L2.1 U9.L1 U9.M1
+VCC0V9_SVR_TCP1: C334.2 C338.1 C359.2 C747.1 C752.2 C753.2 C754.2 C756.2 L6.2 U16.E3 U16.E9 U16.F6 U16.G3 U16.G6 U16.G9
+VCC0V9_SVR_TCP1_PHASE: L6.1 U16.L1 U16.M1
+VCC1.05_OUT_FET: C436.1 C611.1 C617.1 Q89.3 Q91.3 U49.W20 U49.W22 U49.W23 U49.W25
+VCC3P3_ANA_TCP0: C708.2 U9.L2
+VCC3P3_ANA_TCP1: C746.2 U16.L2
+VCC3P3_LC_TCP0: C715.1 R225.1 R227.1 R249.1 R864.1 U9.E5
+VCC3P3_LC_TCP1: C751.1 R451.1 R453.1 R466.1 R963.1 U16.E5
+VCC3V3_SX_TCP0: C185.1 C194.1 C204.1 L1.2 R128.2 R149.2 R223.1 R240.2 R241.2 R247.2 R248.2 R832.2 R1226.2 U9.E6 U9.M4 U9.M5
+VCC3V3_SX_TCP0_DBRONLY: R128.1 U9.J5
+VCC3V3_SX_TCP1: C324.1 C339.1 C344.1 L4.2 R276.2 R313.2 R449.1 R467.2 R470.2 R471.2 R476.2 R921.2 R1227.2 U16.E6 U16.M4 U16.M5
+VCC3V3_SX_TCP1_DBRONLY: R276.1 U16.J5
+VCC3V3A_SX_TCP0: C700.2 C702.2 C706.2 R832.1 U9.J7
+VCC3V3A_SX_TCP1: C741.2 C743.2 C745.2 R921.1 U16.J7
+VCC_CORE: C62.1 C63.1 C64.1 C65.1 C66.1 C67.1 C69.1 C70.1 C71.1 C73.1 C74.1 C76.1 C78.1 C79.1 C80.1 C81.1 C82.1 C83.1 C88.1 C91.1 C92.1 C96.1 C101.1 C102.1 C103.1 C104.1 C106.1 C107.1 C114.1 C115.1 C117.1 C120.2 C121.2 C122.1 C123.1 C124.1 C129.1 C131.1 C132.1 C133.1 C135.1 C137.1 C139.1 C622.1 C623.1 C624.2 C629.2 C630.1 C631.1 C633.2 C644.2 C645.2 C648.2 C653.2 C654.2 C658.1 C659.1 C660.2 C661.2 C662.2 C663.2 PC63.1 PC64.1 PC65.1 PC66.1 PC67.1 PC68.1 PC71.1 PC72.1 PC73.1 PC74.1 PC75.1 PC76.1 PC77.1 PC78.1 PC79.1 PC80.1 PC81.1 PC82.1 PC86.1 PC87.1 PC88.1 PC89.1 PC90.1 PC91.1 PL7.2 PL8.2 PL9.2 PL10.2 PL11.2 PL12.2 PR356.1 PR494.1 PR495.2 PR496.2 PR497.2 PR498.2 PR499.2 U42.AB11 U42.AC11 U42.AC12 U42.AD11 U42.AD12 U42.AV33 U42.AV34 U42.AV35 U42.AW34 U42.BA34 U42.BA35 U42.BB34 U42.BD33 U42.BD34 U42.BE34 U42.BE35 U42.BG34 U42.BG35 U42.BH33 U42.BH34 U42.BH35 U42.BJ34 U42.BJ35 U42.BK34 U42.BK35 U42.BL33 U42.BL34 U42.BL35 U42.BN34 U42.BN35 U42.BP34 U42.BP35 U42.BR33 U42.BR34 U42.BR35 U42.BT11 U42.BT34 U42.BT35 U42.BU34 U42.BU35 U42.BV11 U42.BV12 U42.BV33 U42.BW11 U42.BW12 U42.BW33 U42.BW34 U42.BW35 U42.BY12 U42.BY34 U42.BY35 U42.CA14 U42.CA16 U42.CA18 U42.CA20 U42.CA22 U42.CA23 U42.CA25 U42.CA27 U42.CA30 U42.CA31 U42.CB12 U42.CB13 U42.CB14 U42.CB16 U42.CB17 U42.CB18 U42.CB20 U42.CB21 U42.CB22 U42.CB23 U42.CB24 U42.CB25 U42.CB27 U42.CB28 U42.CB30 U42.CB31 U42.CB33 U42.CB34 U42.CB35 U42.CC12 U42.CC13 U42.CC14 U42.CC16 U42.CC17 U42.CC18 U42.CC20 U42.CC21 U42.CC22 U42.CC23 U42.CC24 U42.CC25 U42.CC27 U42.CC28 U42.CC30 U42.CC31 U42.CC33 U42.CC34 U42.CC35 U42.CD12 U42.CD14 U42.CD16 U42.CD18 U42.CD20 U42.CD22 U42.CD23 U42.CD25 U42.CD27 U42.CD30 U42.CD31 U42.CD34 U42.CD35 U42.CE12 U42.CE13 U42.CE14 U42.CE16 U42.CE18 U42.CE20 U42.CE22 U42.CE23 U42.CE25 U42.CE27 U42.CE30 U42.CE31 U42.CE34 U42.CE35 U42.CF13 U42.CF14 U42.CF16 U42.CF17 U42.CF18 U42.CF20 U42.CF21 U42.CF22 U42.CF23 U42.CF24 U42.CF25 U42.CF27 U42.CF28 U42.CF30 U42.CF31 U42.CF33 U42.CF34 U42.CF35 U42.CF36 U42.CF38 U42.CF39 U42.CF40 U42.CF41 U42.CG14 U42.CG16 U42.CG17 U42.CG18 U42.CG20 U42.CG21 U42.CG22 U42.CG23 U42.CG24 U42.CG25 U42.CG27 U42.CG28 U42.CG30 U42.CG31 U42.CG33 U42.CG34 U42.CG35 U42.CG36 U42.CG37 U42.CG38 U42.CG39 U42.CG40 U42.CG41 U42.CH24 U42.CH27 U42.CH28 U42.CH33 U42.CH34 U42.CH38 U42.CH39 U42.CJ24 U42.CJ27 U42.CJ28 U42.CJ30 U42.CJ31 U42.CJ33 U42.CJ34 U42.CJ35 U42.CJ36 U42.CJ38 U42.CJ39 U42.CJ40 U42.CJ41 U42.CK24 U42.CK25 U42.CK27 U42.CK28 U42.CK30 U42.CK31 U42.CK33 U42.CK34 U42.CK35 U42.CK36 U42.CL27 U42.CL28 U42.CL33 U42.CL34 U42.CL38 U42.CL39 U42.CL40 U42.CL41 U42.CM27 U42.CM28 U42.CM30 U42.CM31 U42.CM33 U42.CM34 U42.CM35 U42.CM36 U42.CM38 U42.CM39 U42.CN27 U42.CN28 U42.CN30 U42.CN31 U42.CN33 U42.CN34 U42.CN35 U42.CN36 U42.CN38 U42.CN39 U42.CN40 U42.CN41 U42.CP28 U42.CP30 U42.CP33 U42.CP34 U42.CP38 U42.CP39 U42.CP40 U42.CP41 U42.CR28 U42.CR30 U42.CR31 U42.CR32 U42.CR33 U42.CR34 U42.CR35 U42.CR36 U42.CR38 U42.CR39 U42.CT28 U42.CT30 U42.CT31 U42.CT32 U42.CT33 U42.CT34 U42.CT35 U42.CT36 U42.CT38 U42.CT39 U42.CT40 U42.CT41 U42.CU28 U42.CU30 U42.CU33 U42.CU34 U42.CU38 U42.CU39 U42.T18 U42.U18 U42.U20 U42.V12 U42.V13 U42.V15 U42.V17 U42.V18 U42.V20 U42.W11 U42.W13 U42.W15 U42.W17 U42.W18 U42.W20 U42.Y11 U42.Y12 U42.Y13 U42.Y15 U42.Y18 U42.Y20
+VCC_V1P05EXT_1P05: R480.1 U49.AN28
+VCC_VNNEXT_1P05: R487.1 U49.AN29
+VCCDPHY_1P24: C737.1 U49.BD1 U49.BD2 U49.BE1
+VCCIN_AUX: C41.1 C42.1 C43.1 C44.2 C59.1 C60.1 C61.1 C68.1 C72.1 C77.1 C87.1 C89.2 C90.2 C94.1 C95.1 C97.1 C98.2 C99.2 C100.2 C105.1 C109.2 C110.2 C111.2 C112.2 C113.1 C116.1 C118.1 C128.2 C130.2 C655.1 C656.1 C657.1 PC61.1 PC62.1 PC69.1 PC70.1 PC83.1 PC84.1 PC85.1 PC385.1 PC386.1 PC389.1 PC390.1 PC391.1 PL6.2 PR9.1 PR88.2 PR484.1 U42.AA34 U42.AA36 U42.AA39 U42.AB33 U42.AD34 U42.AE33 U42.AF33 U42.AF34 U42.AG34 U42.AG35 U42.AH33 U42.AJ33 U42.AJ34 U42.AK34 U42.AK35 U42.AL34 U42.BH11 U42.BK11 U42.BK12 U42.BL11 U42.BL12 U42.BM11 U42.U24 U42.U28 U42.U31 U42.V24 U42.V26 U42.V28 U42.V29 U42.V31 U42.V33 U42.V34 U42.V35 U42.V38 U42.W24 U42.W26 U42.W28 U42.W29 U42.W31 U42.W33 U42.W34 U42.W35 U42.W36 U42.W37 U42.W38 U42.W39 U42.W40 U42.W41 U42.Y24 U42.Y28 U42.Y29 U42.Y33 U42.Y34 U42.Y35 U42.Y36 U42.Y37 U42.Y38 U42.Y39 U42.Y40 U42.Y41
+VCCIO_OUT: R98.2 R100.2 R101.2 R772.2 R774.2 U42.G35
+VCCPRIM_1P05_OUT: C409.2 C424.1 C438.2 U49.AJ20 U49.AK21 U49.AK22
+VCCST: C108.1 C119.1 PR350.2 Q98.3 R102.2 R402.1 R746.1 R747.1 R789.1 R791.2 R793.1 R802.2 R811.1 U42.P20 U42.R20 U42.R22
+VCCSTG: C84.1 C86.1 C93.1 Q48.2 R89.2 R738.1 R743.1 R764.2 R765.2 R766.1 R767.2 R773.2 R883.1 R884.1 RS1.2 U42.L34 U42.M34 U42.N34 U42.P34
+VCCSTG_12: R104.2 U42.P17 U42.R17
+VCCSTG_OUT_1: R104.1 R105.1 U42.T17
+VCCSTG_OUT_23456: C134.2 R105.2 U42.P13 U42.R13 U42.R15 U42.T13 U42.T15
+VDD_DCI: C767.1 R981.2 U24.5
+VDDQ: PC511.1 PR652.1
+VIN: C29.2 C30.1 C31.1 C873.1 PC25.1 PC229.1 PC230.1 PC231.2 PC232.1 PC237.1 PC498.1 PC502.1 PJ10.2 PJ11.2 PJ13.2 PJ14.1 PJ18.2 PJ20.2 PQ36.5 PQ60.5 PQ69.5 PR138.2 PR139.1 PR286.1 PR287.1 PR299.1 PR304.1 PR310.1 PR344.1 PR486.2 PR487.2 PR501.1 PR508.1 PR669.1 R728.1 R744.1 R752.1 R753.1 R985.1 R1228.1
+VIN_GPU_TOTAL: PC17.1 PC18.1 PC19.1 PC21.1 PC22.1 PC23.1 PC27.1 PC28.1 PC332.1 PC333.1 PQ41.3 PQ41.4 PQ41.9 PQ42.3 PQ42.4 PQ42.9 PQ43.3 PQ43.4 PQ43.9 PQ44.3 PQ44.4 PQ44.9 PR352.1 PR435.2 PR437.2 R64.1
+VIN_PANEL_R: C607.1 C610.1 C613.2 C614.1 C615.1 CN2.37 CN2.38 CN2.39 CN2.40 R744.2 R1228.2
+VIN_SRC: C603.2 C604.1 C605.1 PC382.1 PC383.1 PC384.1 PD3.1 PQ49.5 PQ50.5 PQ58.5 PR316.1 PR507.1
+VIN_VCC_CORE: PC40.1 PC41.1 PC42.1 PC43.1 PC44.1 PC45.1 PC319.1 PC347.1 PC348.1 PC349.1 PC350.1 PC351.1 PC352.1 PC354.1 PC355.1 PC356.1 PC357.1 PC358.1 PC359.1 PC371.1 PC372.1 PC373.1 PC374.1 PC375.1 PC376.1 PJ10.1 PR376.1 PU21.8 PU21.9 PU22.8 PU22.9 PU23.8 PU23.9 PU24.8 PU24.9 PU25.8 PU25.9 PU26.8 PU26.9
+VIN_VCCIN_AUX: PC32.1 PC35.1 PC361.1 PC362.1 PJ11.1 PQ52.3 PQ52.4 PQ52.9
+VIN_VGACORE: PC126.1 PC127.1 PC128.1 PC129.1 PC130.1 PC131.1 PC132.1 PC133.1 PC137.1 PC138.1 PC139.1 PC140.1 PC141.1 PC142.1 PC143.1 PC144.1 PC147.1 PC148.1 PC156.1 PC195.1 PC425.1 PC426.1 PC427.1 PC428.2 PC431.2 PC432.1 PC433.2 PC434.1 PC435.2 PC436.1 PC437.2 PC438.1 PC439.2 PC440.1 PC441.1 PC442.1 PC449.1 PC450.1 PC451.1 PC452.1 PC453.1 PC454.1 PC455.1 PC456.1 PC457.1 PC458.1 PC459.1 PC460.1 PC461.1 PC462.1 PC463.2 PC464.2 PC522.2 PR102.2 PR238.2 PR437.1 PR444.2 PR474.2 PR479.1 PU29.25 PU29.30 PU30.25 PU30.30 PU31.25 PU31.30 PU32.25 PU32.30 PU33.25 PU33.30 PU34.25 PU34.30 PU35.25 PU35.30 PU36.25 PU36.30
DVDD_IO: C463.2 Q37.2 Q37.5 R377.1 R378.1 R517.1 U21.12
