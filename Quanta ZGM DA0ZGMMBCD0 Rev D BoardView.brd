# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DMI_RXP7: length 84.1
  BOTTOM w0.079: U42.C14 175.44,137.3 176.79,137.3 176.97,137.48 177.52,137.48 177.84,137.16 178.09,137.16 179.76,135.49 179.76,134.2 180.98,132.98 180.98,131.54 181.52,130.99 181.6,130.99 181.61,130.98
  BOTTOM w0.102: U49.C25 201.9,67.7 201.9,67.87 201.66,68.11 201.56,68.11 200.37,69.31 200.37,69.9 200.18,70.09 200.18,71.08 199.18,72.08 199.18,72.12 199.16,72.14
  BOTTOM w0.14: 181.61,130.98 181.93,130.67 183.49,130.67 185.5,128.66 185.5,125.41 189.47,121.45 189.47,115.83 195.68,109.61 195.68,95.57 196.18,95.07 196.18,85.07 197.95,83.31 197.95,73.36 199.16,72.14
DMI_TXN0: length 87.9
  TOP w0.079: 175.53,130.69 175.53,130.71 175.47,130.77 175.47,131.02 175.06,131.43 174.7,131.43 174.63,131.51 174.63,131.62 v2(174.7,131.69)
  TOP w0.14: 175.53,130.69 175.53,130.13 176.01,129.65 176.58,129.65 183.58,122.64 183.58,113.56 190.72,106.43 190.72,106.43 190.8,106.35 190.8,91.84 191.09,91.56 191.09,89.54 193.35,87.28 193.35,72.29 196.3,69.34 196.3,67.33 198.05,65.57 198.05,64.82 199.47,63.4 200.36,63.4 200.8,63.84 203.38,63.84 203.44,63.78 204.69,63.78 204.92,64.01 205.86,64.01 206.04,64.19 206.04,64.4 205.89,64.55 v1(205.73,64.55)
  BOTTOM w0.102: U42.C6 175.01,131.8 174.9,131.69 v2(174.7,131.69) ; U49.L31 206.04,64.24 v1(205.73,64.55)
DMI_TXN1: length 85.6
  TOP w0.079: 176.24,130.69 176.24,130.71 176.18,130.77 176.18,131.05 175.01,132.22 174.64,132.22 174.58,132.28 174.58,132.4 174.66,132.48 v2(174.68,132.48)
  TOP w0.14: v1(205.07,64.59) 205.01,64.53 204.82,64.53 204.39,64.96 203.32,64.96 203.02,64.65 200.52,64.65 199.06,66.11 198.53,66.11 197.04,67.59 197.04,69.65 194.21,72.48 194.21,88.27 192.35,90.14 192.35,91.33 191.51,92.17 191.51,106.64 184.47,113.68 184.47,122.76 176.87,130.36 176.43,130.36 176.24,130.55 176.24,130.69
  BOTTOM w0.102: U42.D8 174.51,132.87 174.68,132.7 v2(174.68,132.48) ; v1(205.07,64.59) 205.07,64.78 U49.H30
DMI_TXN2: length 87.6
  TOP w0.079: 177.23,130.69 177.2,130.72 177.2,130.8 176.71,131.29 176.71,131.73 174.91,133.53 174.04,133.53 173.96,133.45 173.96,133.34 v2(174.03,133.27)
  TOP w0.14: v1(205.84,65.83) 205.67,65.66 205.67,65.33 205.37,65.03 204.94,65.03 204.74,65.23 202.75,65.23 202.62,65.09 200.71,65.09 199.09,66.71 198.55,66.71 197.49,67.77 197.49,69.89 194.66,72.72 194.66,88.55 192.79,90.41 192.79,91.76 191.95,92.6 191.95,106.84 185.05,113.74 185.05,122.87 177.23,130.69
  BOTTOM w0.102: v1(205.84,65.83) 205.88,65.83 U49.L29 ; U42.E9 173.87,133.66 174.03,133.5 v2(174.03,133.27)
DMI_TXN3: length 88.5
  TOP w0.079: 177.74,131.2 177.73,131.21 177.73,131.26 175.61,133.38 175.61,133.76 174.86,134.51 173.89,134.51 173.73,134.35 173.73,134.06 173.88,133.91 174,133.91 174.07,133.99 v2(174.07,134.06)
  TOP w0.14: 177.74,131.2 185.92,123.02 185.92,113.91 192.67,107.16 192.67,92.94 193.5,92.1 193.5,91 195.37,89.13 195.37,73.02 198.21,70.17 198.21,69.77 202.22,65.76 204.56,65.76 205.11,66.3 205.11,66.74 205.35,66.99 205.92,66.99 206.06,66.85 206.06,66.66 205.85,66.44 v1(205.77,66.44)
  BOTTOM w0.102: v2(174.07,134.06) 174.07,134.35 174.18,134.45 U42.D10 ; v1(205.77,66.44) 205.55,66.66 U49.J26
DMI_TXN4: length 89.8
  TOP w0.079: v2(169.46,135.74) 169.25,135.52 169.25,135.45 169.33,135.37 170.28,135.37 170.46,135.19 172.28,135.19 172.46,135.37 174.87,135.37 176.36,133.88 176.36,133.63 177.72,132.26 178.04,132.26 178.37,131.94 178.44,131.94 178.46,131.92
  TOP w0.14: 178.46,131.92 187.03,123.35 187.03,114.21 193.64,107.6 193.64,93.35 194.48,92.51 194.48,91.42 196.35,89.56 196.35,73.53 199.23,70.65 199.23,70.14 202.09,67.27 203.77,67.27 204.08,66.97 204.08,66.67 v1(204.28,66.47)
  BOTTOM w0.102: U42.L11 169.6,135.6 v2(169.46,135.74) ; v1(204.28,66.47) 204.33,66.47 U49.H26
DMI_TXN5: length 92.4
  TOP w0.079: v2(171.83,135.57) 171.83,135.6 171.9,135.68 172.02,135.68 172.14,135.56 175.08,135.56 176.58,134.06 176.97,134.06 177.34,133.69 177.34,133.4 178.18,132.55 178.47,132.55 178.52,132.5 178.54,132.5
  TOP w0.14: v1(208.88,66.54) 208.84,66.58 208.64,66.58 208.49,66.43 208.49,66.09 208.19,65.8 207.76,65.8 206.87,66.69 206.87,67.14 206.5,67.51 202.48,67.51 199.72,70.28 199.72,70.8 196.81,73.71 196.81,89.72 195.05,91.48 195.05,92.57 194.09,93.53 194.09,107.81 187.59,114.31 187.59,123.55 178.64,132.5 178.54,132.5
  BOTTOM w0.102: v1(208.88,66.54) 208.83,66.54 U49.R26 ; v2(171.83,135.57) 171.83,135.38 172.04,135.16 U42.G11
DMI_TXN6: length 95.4
  TOP w0.079: v2(169.9,136.81) 169.9,136.85 169.82,136.93 169.66,136.93 169.54,136.81 169.54,136.49 169.74,136.3 172.21,136.3 172.43,136.07 175.35,136.07 176.76,134.66 177.23,134.66 178.27,133.62 178.47,133.62 178.52,133.68 178.54,133.68
  TOP w0.14: v1(207.27,69.25) 207.5,69.25 207.66,69.09 207.66,68.75 207.48,68.57 206.58,68.57 206.31,68.29 203.03,68.29 202.71,68.6 202.71,69.23 202.59,69.35 202.59,72 201.98,72.61 199.29,72.61 197.79,74.11 197.79,90.6 196.14,92.24 196.14,93.1 195.08,94.16 195.08,108.25 188.7,114.63 188.7,124.35 179.38,133.68 178.54,133.68
  BOTTOM w0.102: v2(169.9,136.81) 169.68,136.59 169.68,136.33 U42.L13 ; v1(207.27,69.25) 207.67,68.85 U49.P22
DMI_TXN7: length 89.3
  TOP w0.079: v2(172.03,136.66) 171.99,136.7 171.99,136.84 172.07,136.92 174.84,136.92 175.39,136.38 175.39,136.38 176.18,135.59 177.18,135.59 177.56,135.21 177.56,134.9 178.24,134.22 178.48,134.22 178.53,134.16 178.54,134.16
  TOP w0.14: v1(205.71,68.71) 205.57,68.58 205.23,68.58 204.47,69.34 204.47,72.84 204.9,73.27 204.9,74.71 205.06,74.88 205.06,75.83 204.87,76.02 204.87,76.3 204.42,76.75 204.42,78.35 203.59,79.18 203.59,80.83 202.63,81.79 201.49,81.79 200.9,82.39 200.9,84.19 200.41,84.67 200.03,84.67 198.24,86.46 198.24,91.27 196.78,92.72 196.78,93.42 195.53,94.66 195.53,108.67 189.25,114.95 189.25,124.76 179.85,134.16 178.54,134.16
  BOTTOM w0.102: v2(172.03,136.66) 172.03,136.5 171.81,136.28 U42.H13 ; v1(205.71,68.71) 205.86,68.57 205.86,68.09 205.98,67.96 206.19,67.96 U49.L24
DMI_TXP0: length 88
  TOP w0.079: 175.26,130.69 175.26,130.71 175.32,130.77 175.32,130.95 175,131.28 174.59,131.28 174.18,131.69 v2(174.03,131.69)
  TOP w0.14: 175.26,130.69 175.26,130.02 175.9,129.38 176.47,129.38 183.32,122.53 183.32,113.45 190.53,106.24 190.53,91.73 190.82,91.44 190.82,89.43 193.08,87.17 193.08,72.18 196.03,69.23 196.03,67.22 197.79,65.46 197.79,64.71 199.36,63.14 200.47,63.14 200.91,63.57 203.27,63.57 203.33,63.51 204.8,63.51 205.03,63.74 205.91,63.74 v1(206.03,63.62)
  BOTTOM w0.102: U49.J32 205.65,64.01 v1(206.03,63.62) ; v2(174.03,131.69) 174.36,132.01 U42.D6
DMI_TXP1: length 85.7
  TOP w0.079: v2(174.03,132.48) 174.16,132.48 174.58,132.06 174.94,132.06 176.03,130.98 176.03,130.77 175.97,130.71 175.97,130.69
  TOP w0.14: v1(204.42,64.31) 204.42,64.55 204.28,64.69 203.44,64.69 203.13,64.38 200.41,64.38 198.95,65.84 198.42,65.84 196.77,67.48 196.77,69.54 193.94,72.37 193.94,88.16 192.08,90.03 192.08,91.22 191.24,92.06 191.24,106.53 184.21,113.57 184.21,122.65 176.76,130.09 176.32,130.09 175.97,130.43 175.97,130.69
  BOTTOM w0.102: v2(174.03,132.48) 173.85,132.66 173.71,132.81 U42.E8 ; v1(204.42,64.31) 204.42,64.5 U49.F30
DMI_TXP2: length 87.6
  TOP w0.079: v2(173.38,133.27) 173.51,133.27 173.93,133.69 174.97,133.69 176.86,131.79 176.86,131.36 177.34,130.88 177.41,130.88
  TOP w0.14: v1(205.19,65.78) 205.26,65.78 205.41,65.64 205.41,65.44 205.26,65.3 205.05,65.3 204.86,65.49 202.64,65.49 202.51,65.36 200.82,65.36 199.2,66.98 198.66,66.98 197.76,67.88 197.76,70 194.92,72.83 194.92,88.66 193.06,90.52 193.06,91.87 192.22,92.71 192.22,106.95 185.32,113.85 185.32,122.98 177.41,130.88
  BOTTOM w0.102: U49.J29 205.19,65.59 v1(205.19,65.78) ; U42.F9 173.05,133.59 v2(173.38,133.27)
DMI_TXP3: length 88.5
  TOP w0.079: v2(173.36,134.08) 173.57,134.29 173.57,134.42 173.83,134.67 174.93,134.67 175.77,133.83 175.77,133.44 177.8,131.41 177.91,131.41 177.93,131.39
  TOP w0.14: v1(206.42,66.42) 206.31,66.53 206.33,66.55 206.33,66.96 206.04,67.25 205.24,67.25 204.84,66.85 204.84,66.41 204.45,66.03 202.33,66.03 198.48,69.88 198.48,70.29 195.63,73.13 195.63,89.24 193.77,91.11 193.77,92.21 192.93,93.05 192.93,107.27 186.19,114.02 186.19,123.13 177.93,131.39
  BOTTOM w0.102: U49.L26 206.31,66.52 v1(206.42,66.42) ; U42.E10 173.71,134.42 v2(173.36,134.08)
DMI_TXP4: length 89.8
  TOP w0.079: v2(168.75,135.72) 168.89,135.72 169.09,135.52 169.09,135.38 169.26,135.21 170.22,135.21 170.39,135.03 172.35,135.03 172.53,135.21 174.8,135.21 176.2,133.82 176.2,133.56 177.66,132.1 177.98,132.1 178.26,131.83 178.26,131.75 178.27,131.74
  TOP w0.14: 178.27,131.74 186.77,123.24 186.77,114.1 193.38,107.49 193.38,93.24 194.22,92.4 194.22,91.31 196.08,89.45 196.08,73.42 198.96,70.54 198.96,70.03 201.98,67.01 203.66,67.01 203.81,66.86 203.81,66.66 203.66,66.51 v1(203.59,66.51)
  BOTTOM w0.102: v1(203.59,66.51) 203.59,66.58 203.93,66.92 U49.F26 ; U42.N11 168.83,135.64 v2(168.75,135.72)
DMI_TXP5: length 92.3
  TOP w0.079: v2(171.11,135.56) 171.29,135.56 171.67,135.94 171.98,135.94 172.21,135.71 175.15,135.71 176.64,134.22 177.03,134.22 177.49,133.76 177.49,133.46 178.25,132.71 178.47,132.71 178.52,132.77 178.54,132.77
  TOP w0.14: 178.54,132.77 178.75,132.77 187.86,123.66 187.86,114.42 194.35,107.92 194.35,93.64 195.32,92.68 195.32,91.59 197.08,89.83 197.08,73.82 199.98,70.91 199.98,70.39 202.59,67.78 206.61,67.78 207.14,67.25 207.14,66.8 207.87,66.07 208.08,66.07 208.22,66.21 208.22,66.37 v1(208.04,66.54)
  BOTTOM w0.102: v2(171.11,135.56) 171.11,135.45 U42.H11 ; v1(208.04,66.54) 207.67,66.91 U49.P26
DMI_TXP6: length 95.4
  TOP w0.079: 178.54,133.41 178.52,133.41 178.47,133.46 178.2,133.46 177.17,134.5 176.69,134.5 175.28,135.91 172.37,135.91 172.14,136.14 169.67,136.14 169.39,136.42 169.39,136.57 v2(169.17,136.78)
  TOP w0.14: 178.54,133.41 179.27,133.41 188.44,124.24 188.44,114.52 194.82,108.14 194.82,94.05 195.87,92.99 195.87,92.13 197.52,90.49 197.52,74 199.18,72.34 201.87,72.34 202.32,71.89 202.32,69.24 202.44,69.12 202.44,68.49 202.92,68.02 206.42,68.02 206.69,68.3 207.59,68.3 207.93,68.63 207.93,69.14 v1(208.05,69.26)
  BOTTOM w0.102: v1(208.05,69.26) 208.45,68.87 U49.R22 ; v2(169.17,136.78) 169.08,136.69 U42.M13
DMI_TXP7: length 89.2
  TOP w0.079: 178.54,134.43 178.52,134.43 178.47,134.37 178.31,134.37 177.72,134.96 177.72,135.27 177.25,135.75 176.24,135.75 174.91,137.08 171.96,137.08 v2(171.27,136.7)
  TOP w0.14: 178.54,134.43 179.96,134.43 189.52,124.87 189.52,115.06 195.8,108.78 195.8,94.77 197.05,93.53 197.05,92.83 198.5,91.38 198.5,86.57 200.14,84.94 200.52,84.94 201.16,84.3 201.16,82.5 201.6,82.06 202.74,82.06 203.85,80.95 203.85,79.29 204.69,78.46 204.69,76.86 205.14,76.42 205.14,76.13 205.33,75.94 205.33,74.77 205.17,74.6 205.17,73.16 204.74,72.73 204.74,69.45 204.97,69.22 v1(205.34,69.22)
  BOTTOM w0.102: U42.J13 171.04,136.47 v2(171.27,136.7) ; v1(205.34,69.22) 205.3,69.18 205.3,68.33 U49.J24
DMIC_CLK: length 181
  TOP w0.14: R464.1 307.26,66.42 v1(307.2,66.36) 306.89,66.05 306.89,65.99 C450.1 ; v1(279.95,192.88) 280.29,192.88 280.84,192.33 280.84,191.22 280.61,191 R62.1
  IN1 w0.086: v1(279.95,192.88) 280.12,192.7 280.12,188.59 285.42,183.29 285.42,172.75 284.95,172.28 284.95,166.21 285.42,165.74 285.42,157.38 281.61,153.56 281.61,137.84 281.46,137.7 281.46,119.79 283.01,118.24 283.31,118.24 285.4,116.15 285.4,116.02 285.66,115.76 286.87,115.76 287.92,114.72 287.92,113.98 v1(288.04,113.86)
  IN2 w0.089: v1(288.04,113.86) 288.84,113.86 291.08,111.61 291.08,111.19 293.79,108.48 295.64,108.48 298.1,106.01 298.1,105.72 299.41,104.41 301.19,104.41 305.68,99.91 309.93,99.91 310.27,100.24 317.57,100.24 318.86,98.96 318.86,98.1 321.2,95.76 321.2,72.5 320.71,72.01 319.56,72.01 319.24,72.33 318.77,72.33 318.7,72.26 318.33,72.26 317.74,71.67 316.86,71.67 316.25,72.27 316.25,74.64 315.85,75.04 313.99,75.04 313.74,75.29 310.48,75.29 309.65,74.47 309.65,68.7 307.32,66.36 v1(307.2,66.36)
DMIC_CLK0: length 8.2
  TOP w0.14: U17.4 226.84,69.9 226.6,69.66 R432.2 225.79,69.66 225.3,69.18 v1(225.3,68.9)
  BOTTOM w0.102: v1(225.3,68.9) 224.84,68.43 222.53,68.43 221.37,69.59 220.43,69.59 U49.AW21
DMIC_CLK_C: length 11.8
  TOP w0.14: R62.2 R61.2 279.23,191.45 279.12,191.56 277.63,191.56 D4.1 277.01,192.19 275.8,192.19 v1(275.59,191.99) 275.39,192.19 273.81,192.19 273.49,191.87 273.49,191.21 273.12,190.85 271.02,190.85 CN2.26
DMIC_CLK_U: length 1.7
  TOP w0.14: U20.5 308.75,67.03 308.54,67.25 308.15,67.25 R464.2
DMIC_DAT: length 178.4
  TOP w0.14: C447.1 306.89,66.71 v1(307.2,67.01) 307.4,67.22 R457.1 ; v1(279.33,192.02) 279.34,192.03 R60.1
  IN1 w0.086: v1(279.33,192.02) 279.78,191.57 279.78,188.45 285.08,183.15 285.08,180.56 284.45,179.94 284.45,179.32 285.08,178.69 285.08,172.89 284.61,172.42 284.61,166.07 285.08,165.59 285.08,157.52 281.26,153.7 281.26,137.98 281.12,137.84 281.12,119.65 282.5,118.27 282.5,118.27 282.87,117.9 283.17,117.9 285.06,116.01 285.06,115.88 285.52,115.42 286.41,115.42 287.26,114.56 v1(287.26,114.06)
  IN2 w0.089: v1(287.26,114.06) 287.26,113.73 287.74,113.25 288.96,113.25 290.74,111.47 290.74,110.82 291.04,110.52 293.43,108.14 295.49,108.14 297.76,105.87 297.76,105.57 299.27,104.06 301.05,104.06 305.54,99.57 310.01,99.57 310.37,99.21 312.26,99.21 312.96,99.9 317.43,99.9 318.51,98.82 318.51,97.96 319.3,97.17 319.3,92.57 318.87,92.14 318.87,90.59 320.08,89.38 320.08,74.32 320.86,73.54 320.86,72.65 320.57,72.36 319.7,72.36 319.44,72.61 318.21,72.61 317.6,72.01 317,72.01 316.6,72.41 316.6,74.78 315.99,75.39 314.14,75.39 313.89,75.64 310.33,75.64 309.31,74.61 309.31,69.12 v1(307.2,67.01)
DMIC_DAT0: length 8.4
  TOP w0.14: U19.4 225.07,66.18 R478.1 224.61,66.51 224.62,66.51 R461.2 R460.2 v1(222.88,66.82) 222.13,67.58 222.13,68.49 221.49,69.12 v1(221.19,69.12)
  BOTTOM w0.102: v1(221.19,69.12) 220.92,69.39 220.21,69.39 220.08,69.51 U49.AU21
DMIC_DAT_U: length 1.4
  TOP w0.14: R457.2 308.6,67.54 308.71,67.43 U20.4
DMIC_DATA_C: length 11
  TOP w0.14: R60.2 R59.2 277.53,193.01 D2.1 277.42,192.9 276.08,192.9 v1(275.59,193.38) 274.79,192.59 273.65,192.59 273.08,192.01 273.08,191.36 272.89,191.17 270.73,191.17 270.55,191.35 CN2.25
DNBSWON#: length 59.2
  TOP w0.14: v1(172.24,70.62) 172.24,70.97 171.51,71.71 U23.123
  IN2 w0.089: v1(172.24,70.62) 172.9,70.62 173.1,70.82 174.71,70.82 175.91,69.62 178.18,69.62 178.99,68.81 181.33,68.81 181.78,68.37 184.47,68.37 184.75,68.09 185.81,68.09 187.44,66.46 188.18,66.46 188.88,65.75 190.32,65.75 190.59,65.48 192.14,65.48 193.19,64.43 194.93,64.43 196.18,63.17 198.56,63.17 198.92,63.52 200.59,63.52 200.75,63.69 201.33,63.69 201.7,63.31 201.7,63.12 205.29,59.53 206.42,59.53 207.14,58.81 207.14,58.05 207.01,57.91 207.01,57.13 208.07,56.06 211.99,56.06 212.52,55.54 214.85,55.54 215.14,55.24 215.14,54.84 v1(214.79,54.49)
  BOTTOM w0.102: U49.AH47 214.8,56.53 215,56.33 215,55.62 215.11,55.51 215.11,54.96 214.79,54.64 v1(214.79,54.49) 214.79,54.16 214.85,54.09 214.85,53.4 215.01,53.25
  BOTTOM w0.14: 215.01,53.25 215.05,53.2 215.05,52.86 TP161.1
DP_D0: length 305.9
  IN1 w0.086: v2(246.6,129.77) 246.6,129.99 246.69,130.09 246.82,130.09 246.99,129.91 246.99,129.46 246.39,128.85 246.39,126.5 246,126.12 246,122.29 246.7,121.6 246.7,120.98 245.25,119.53 243.57,119.53 239.69,115.66 237.71,115.66 237.31,116.07 232.89,116.07 232.55,115.73 231.71,115.73 230.95,116.49 227.43,116.49 226.67,115.73 221.18,115.73 220.55,116.36 212.12,116.36 205.81,110.05 205.81,105.13 204.74,104.06 204.74,100.62 203.88,99.76 203.88,98.62 198.96,93.7 198.96,81.36 197.85,80.25 197.85,79.7 188.52,70.37 187.45,70.37 185.84,68.76 179.5,68.76 179,68.25 175.14,68.25 174.4,67.51 171.21,67.51 170.76,67.95 166.14,67.95 165.03,66.84 153.87,66.84 153.17,67.54 151.47,67.54 150.21,66.27 147.58,66.27 146.4,65.1 142.63,65.1 141.72,64.18 134.23,64.18 133.89,64.52 123.21,64.52 123.05,64.68 110.65,64.68 109.81,63.84 85.25,63.84 84.53,63.12 65.32,63.12 64.56,62.36 62.62,62.36 61.77,61.51 52.55,61.51 48.27,57.23 47.36,57.23 44.56,54.43 40.41,54.43 38.82,52.84 35.95,52.84 30.8,47.69 28.87,47.69 26.17,44.99 26.05,44.99 25.67,45.36 25.33,45.36 24.96,45 24.96,44.7 25.36,44.3 25.36,44.18 25.03,43.85 24.69,43.85 24.32,44.22 23.98,44.22 23.6,43.84 23.6,43.51 24.49,42.62 24.49,42.41 24.28,42.2 24.07,42.2 23.24,43.02 22.97,43.02 22.4,42.46 22.4,42.18 23.36,41.22 23.36,41.1 19.97,37.71 19.97,32.06 19.67,31.76 19.67,29.72 18.95,28.99 18.95,28.63 18.75,28.44 v1(18.5,28.44)
  BOTTOM w0.102: UG6.BM16 v2(246.6,129.77)
  BOTTOM w0.14: C850.1 18.81,27.55 18.81,28.13 v1(18.5,28.44)
DP_D0#: length 305.9
  IN1 w0.086: v1(19.4,28.44) 19.28,28.44 19.13,28.58 19.13,28.92 19.85,29.64 19.85,31.68 20.15,31.98 20.15,37.63 23.55,41.02 23.55,41.3 22.59,42.26 22.59,42.38 23.04,42.83 23.17,42.83 23.99,42.01 24.36,42.01 24.68,42.33 24.68,42.7 23.78,43.59 23.78,43.76 24.06,44.03 24.24,44.03 24.62,43.66 25.11,43.66 25.55,44.1 25.55,44.38 25.15,44.78 25.15,44.92 25.4,45.17 25.6,45.17 25.97,44.8 26.25,44.8 28.95,47.5 30.88,47.5 36.02,52.65 38.9,52.65 40.49,54.24 44.64,54.24 47.44,57.04 48.35,57.04 52.63,61.32 61.85,61.32 62.7,62.17 64.63,62.17 65.4,62.93 84.61,62.93 85.33,63.66 109.89,63.66 110.73,64.49 122.97,64.49 123.13,64.33 133.82,64.33 134.16,63.99 141.8,63.99 142.71,64.91 146.48,64.91 147.65,66.08 150.29,66.08 151.55,67.35 153.1,67.35 153.79,66.66 165.11,66.66 166.22,67.77 170.68,67.77 171.13,67.32 174.47,67.32 175.22,68.06 179.08,68.06 179.58,68.57 185.92,68.57 187.53,70.18 188.6,70.18 198.04,79.62 198.04,80.17 199.15,81.28 199.15,93.62 204.07,98.54 204.07,99.68 204.93,100.55 204.93,103.98 206,105.05 206,109.97 212.2,116.17 220.48,116.17 221.1,115.54 226.75,115.54 227.51,116.3 230.88,116.3 231.63,115.54 232.62,115.54 232.96,115.88 237.23,115.88 237.64,115.47 239.77,115.47 243.64,119.35 245.33,119.35 246.89,120.91 246.89,121.68 246.19,122.37 246.19,126.04 246.57,126.42 246.57,128.78 247.18,129.38 247.18,129.99 246.89,130.28 246.8,130.28 v2(246.61,130.46)
  BOTTOM w0.102: v2(246.61,130.46) 246.25,130.82 UG6.BL16
  BOTTOM w0.14: v1(19.4,28.44) 19.13,28.16 19.13,27.62 C851.1
DP_D1: length 305.9
  IN1 w0.086: v2(247.3,131.17) 247.3,131.35 247.39,131.44 247.62,131.44 247.8,131.26 247.8,130.33 247.43,129.97 247.43,127.43 247.94,126.93 248.22,126.93 249.85,125.3 249.85,124.3 248.99,123.44 248.99,123.09 247.72,121.82 247.72,120.22 247.57,120.07 247.32,120.07 242.17,114.92 231.59,114.92 230.81,115.7 228.12,115.7 227.3,114.89 211.58,114.89 206.47,109.78 206.47,103.67 206.8,103.34 206.8,100.51 205.3,99.02 205.24,99.02 199.62,93.39 199.62,81.09 198.51,79.98 198.51,79.43 195.33,76.25 195.33,76 194.51,75.18 194.51,74.82 191.44,71.74 191.44,70.94 191.03,70.52 189.6,70.52 187.64,68.56 187.02,68.56 186.56,68.1 184.02,68.1 183.35,67.43 179.83,67.43 179.73,67.53 175.35,67.53 174.67,66.85 170.93,66.85 170.49,67.3 166.41,67.3 164.83,65.72 163.48,65.72 163.35,65.85 160.53,65.85 160.36,66.02 150.88,66.02 150.48,65.62 147.85,65.62 146.61,64.38 142.86,64.38 142,63.53 133.42,63.53 133.08,63.87 122.93,63.87 122.77,64.03 116.28,64.03 115.71,63.46 110.63,63.46 110.36,63.19 85.52,63.19 84.8,62.46 65.59,62.46 64.68,61.56 62.94,61.56 62.24,60.86 61.63,60.86 60.56,59.79 55.76,59.79 48.93,56.96 45.66,53.7 40.61,53.7 38.83,51.92 35.96,51.92 31.07,47.04 29.14,47.04 27.55,45.44 27.55,45.16 27.77,44.95 27.77,44.83 27.47,44.53 27.35,44.53 27.13,44.74 26.85,44.74 26.41,44.3 26.41,44.02 26.76,43.68 26.76,43.56 26.43,43.22 26.3,43.22 26.01,43.52 25.73,43.52 25.33,43.11 25.33,42.83 25.63,42.52 25.63,42.4 20.62,37.39 20.62,36.37 20.82,36.17 21.19,36.17 21.28,36.09 21.28,35.66 21.19,35.58 20.82,35.58 20.62,35.38 20.62,31.79 20.46,31.63 20.46,28.6 20.37,28.51 v1(20.05,28.51)
  BOTTOM w0.102: UG6.BL14 v2(247.3,131.17)
  BOTTOM w0.14: v1(20.05,28.51) 20.37,28.19 20.37,27.59 C852.1
DP_D1#: length 305.9
  IN1 w0.086: v1(20.95,28.51) 20.79,28.51 20.65,28.65 20.65,31.55 20.81,31.71 20.81,35.3 20.89,35.39 21.27,35.39 21.47,35.59 21.47,36.16 21.27,36.36 20.89,36.36 20.81,36.45 20.81,37.31 25.82,42.32 25.82,42.6 25.51,42.91 25.51,43.03 25.81,43.33 25.93,43.33 25.96,43.3 26.23,43.04 26.5,43.04 26.95,43.48 26.95,43.76 26.6,44.1 26.6,44.22 26.93,44.56 27.05,44.56 27.27,44.34 27.55,44.34 27.95,44.75 27.95,45.03 27.74,45.24 27.74,45.36 29.22,46.85 31.15,46.85 36.03,51.73 38.91,51.73 40.68,53.51 45.74,53.51 49.04,56.8 55.79,59.6 60.64,59.6 61.71,60.67 62.32,60.67 63.02,61.37 64.76,61.37 65.67,62.28 84.88,62.28 85.6,63 110.44,63 110.71,63.27 115.79,63.27 116.36,63.84 122.7,63.84 122.86,63.68 133,63.68 133.34,63.34 142.08,63.34 142.94,64.2 146.69,64.2 147.93,65.43 150.56,65.43 150.96,65.83 160.28,65.83 160.45,65.67 163.27,65.67 163.41,65.53 164.91,65.53 166.49,67.11 170.41,67.11 170.86,66.66 174.75,66.66 175.43,67.34 179.65,67.34 179.75,67.25 183.43,67.25 184.1,67.91 186.63,67.91 187.09,68.37 187.72,68.37 189.68,70.34 191.11,70.34 191.63,70.86 191.63,71.67 194.7,74.74 194.7,75.1 195.52,75.92 195.52,76.17 198.7,79.35 198.7,79.9 199.81,81.01 199.81,93.31 205.32,98.83 205.38,98.83 206.99,100.44 206.99,103.42 206.66,103.75 206.66,109.7 211.66,114.7 227.38,114.7 228.2,115.51 230.73,115.51 231.52,114.73 242.25,114.73 247.4,119.88 247.65,119.88 247.91,120.14 247.91,121.75 249.17,123.01 249.17,123.36 250.04,124.23 250.04,125.38 248.3,127.12 248.01,127.12 247.62,127.51 247.62,129.89 247.98,130.25 247.98,131.34 247.7,131.63 247.54,131.63 v2(247.31,131.86)
  BOTTOM w0.102: UG6.BK14 v2(247.31,131.86)
  BOTTOM w0.14: v1(20.95,28.51) 20.69,28.25 20.69,27.59 C853.1
DP_D2: length 306.2
  IN1 w0.086: v2(248.71,131.86) 248.49,131.86 248.41,131.95 248.41,132.91 249,133.51 249.32,133.51 249.53,133.29 249.53,133.16 249.68,132.82 249.73,132.77 250.25,130.18 250.25,128.46 251.39,125.71 251.39,123.98 250.61,123.21 250.61,122.76 251.46,121.91 251.46,121.05 250.63,120.21 246.66,117.56 242.68,113.58 212.25,113.58 209.77,111.1 209.77,110.47 209.42,110.13 208.74,110.13 207.93,109.32 207.93,105.26 208.53,104.66 208.53,103.5 208.16,103.13 208.16,100.02 206.84,98.7 206.84,97.55 202.96,93.67 202.96,90.01 202.42,89.47 202.42,86.98 202.45,86.92 202.59,86.58 202.59,85.39 202.18,83.36 202.18,82.79 201.07,80.1 201.07,79.15 200.03,78.11 199.04,78.11 197.27,76.34 197.27,76.09 195.82,74.64 195.82,73.34 191.7,69.21 190.21,69.21 188.25,67.25 187.56,67.25 186.43,66.12 175.79,66.12 175.21,65.54 170.39,65.54 169.94,65.99 167.71,65.99 166.73,65.01 165.27,64.41 164.5,64.41 164.36,64.26 162.7,63.58 160.43,63.58 159.73,64.28 158.33,64.28 158.3,64.31 148.39,64.31 147.16,63.07 143.47,63.07 142.61,62.22 132.76,62.22 132.44,61.9 122.62,61.9 121.99,61.27 113.35,61.27 112.1,61.52 112.04,61.54 110.89,61.77 110.28,61.77 108.8,61.15 66.14,61.15 64.26,59.28 62.03,59.28 60.23,57.47 55.35,57.47 48.42,54.6 46.21,52.39 41.15,52.39 39.27,50.51 37.09,50.51 32.9,46.32 32.9,46.3 31.78,44.63 29.67,42.52 27.61,42.52 22.63,37.54 22.63,31.4 22.22,29.32 22.12,29.08 22.12,28.61 21.96,28.45 21.67,28.45 v1(21.6,28.52)
  BOTTOM w0.102: UG6.BJ13 v2(248.71,131.86)
  BOTTOM w0.14: C854.1 21.9,27.6 21.9,28.22 v1(21.6,28.52)
DP_D2#: length 306.2
  IN1 w0.086: v2(248.01,131.86) 248.22,132.07 248.22,132.99 248.92,133.69 249.4,133.69 249.72,133.37 249.72,133.2 249.84,132.93 249.91,132.86 250.43,130.2 250.43,128.5 250.76,127.72 251.57,125.75 251.57,123.91 250.8,123.13 250.8,122.84 251.65,121.99 251.65,120.97 250.75,120.06 246.78,117.41 242.76,113.39 212.33,113.39 209.95,111.02 209.95,110.4 209.5,109.94 208.82,109.94 208.12,109.24 208.12,105.34 208.71,104.74 208.71,103.42 208.35,103.05 208.35,99.95 207.02,98.62 207.02,97.47 203.15,93.59 203.15,89.93 202.61,89.39 202.61,87.02 202.77,86.62 202.77,85.37 202.37,83.34 202.37,82.75 201.26,80.06 201.26,79.07 200.11,77.92 199.12,77.92 197.46,76.26 197.46,76.01 196.01,74.56 196.01,73.26 191.78,69.03 190.29,69.03 188.33,67.06 187.64,67.06 186.51,65.93 175.87,65.93 175.29,65.35 170.31,65.35 169.87,65.8 167.79,65.8 166.84,64.85 165.31,64.22 164.58,64.22 164.46,64.1 162.74,63.39 160.35,63.39 159.65,64.09 158.25,64.09 158.22,64.12 148.47,64.12 147.24,62.88 143.54,62.88 142.69,62.03 132.84,62.03 132.52,61.71 122.69,61.71 122.06,61.08 113.33,61.08 112.04,61.33 111.99,61.36 110.87,61.58 110.32,61.58 108.84,60.97 66.21,60.97 64.34,59.09 62.11,59.09 60.31,57.28 55.39,57.28 48.53,54.44 46.29,52.2 41.23,52.2 39.35,50.32 37.17,50.32 33.06,46.21 33.06,46.21 31.93,44.51 29.75,42.33 27.69,42.33 22.82,37.46 22.82,31.38 22.4,29.26 22.3,29.04 22.3,28.72 v1(22.5,28.52)
  BOTTOM w0.102: UG6.BK13 v2(248.01,131.86)
  BOTTOM w0.14: v1(22.5,28.52) 22.22,28.23 22.22,27.58 C855.1
DP_D3: length 305.8
  IN1 w0.086: v2(248.69,129.78) 248.69,129.96 248.57,130.09 248.43,130.09 248.31,129.97 248.31,129.57 248.55,129.33 249.4,129.33 249.78,128.95 249.78,126.96 250.78,125.96 250.78,124.03 250.14,123.4 250.14,121.03 249.69,120.58 249.18,120.58 248.81,120.21 248.81,120.05 247.94,119.18 247.62,119.18 242.49,114.04 211.93,114.04 207.33,109.45 207.33,104.05 207.64,103.74 207.64,100.17 200.46,92.98 200.46,86.51 201.2,85.77 201.2,85.07 201.02,84.89 201.02,81.29 199.91,80.19 199.91,79.49 199.17,78.75 199.03,78.75 196.22,75.95 196.22,75.69 195.36,74.83 195.36,73.53 191.5,69.68 190.01,69.68 188.04,67.72 187.37,67.72 186.85,67.21 184.52,67.21 183.91,66.59 175.6,66.59 175.02,66.01 170.59,66.01 170.14,66.46 166.76,66.46 165.18,64.88 163.28,64.88 163.09,64.68 160.51,64.68 160.01,65.18 159.38,65.18 158.97,64.77 148.2,64.77 146.96,63.54 143.25,63.54 142.39,62.68 132.95,62.68 132.8,62.84 116.64,62.84 116.04,62.23 109.32,62.23 108.71,61.62 101.41,61.62 100.76,62.27 99.64,62.27 99,61.62 65.94,61.62 64.33,60.01 62.11,60.01 60.36,58.27 54.92,58.27 48.96,55.8 46.01,52.85 40.96,52.85 39.08,50.97 36.43,50.97 31.9,46.44 31.9,46.24 30.73,45.07 30.46,45.07 29.88,45.65 29.73,45.65 29.44,45.37 29.44,45.25 30.04,44.65 30.04,44.37 29.59,43.93 28.36,43.93 22.16,37.74 22.16,31.45 21.91,31.19 21.35,31.19 21.26,31.1 v1(21.26,30.68)
  BOTTOM w0.102: UG6.BM13 v2(248.69,129.78)
  BOTTOM w0.14: v1(21.26,30.68) 21.55,30.97 22.52,30.97 23.66,29.83 23.66,28.32 23.43,28.09 23.43,27.6 C856.1
DP_D3#: length 305.8
  IN1 w0.086: v2(248.7,130.47) 248.51,130.27 248.35,130.27 248.13,130.05 248.13,129.49 248.47,129.14 249.32,129.14 249.59,128.87 249.59,126.88 250.59,125.88 250.59,124.11 249.96,123.48 249.96,121.11 249.61,120.76 249.1,120.76 248.62,120.29 248.62,120.13 247.86,119.37 247.54,119.37 242.41,114.23 211.85,114.23 207.14,109.52 207.14,103.98 207.46,103.66 207.46,100.24 200.28,93.06 200.28,86.43 201.01,85.69 201.01,85.15 200.83,84.97 200.83,81.37 199.73,80.27 199.73,79.57 199.09,78.94 198.95,78.94 196.03,76.02 196.03,75.77 195.17,74.91 195.17,73.61 191.43,69.87 189.93,69.87 187.97,67.91 187.29,67.91 186.78,67.39 184.45,67.39 183.83,66.78 175.52,66.78 174.94,66.2 170.66,66.2 170.22,66.64 166.68,66.64 165.1,65.06 163.2,65.06 163.01,64.87 160.59,64.87 160.09,65.37 159.3,65.37 158.89,64.96 148.12,64.96 146.89,63.73 143.17,63.73 142.31,62.87 133.03,62.87 132.88,63.03 116.56,63.03 115.96,62.42 109.25,62.42 108.63,61.81 101.49,61.81 100.84,62.45 99.56,62.45 98.92,61.81 65.86,61.81 64.25,60.2 62.03,60.2 60.29,58.46 54.89,58.46 48.85,55.96 45.94,53.04 40.88,53.04 39,51.16 36.36,51.16 31.72,46.52 31.72,46.32 30.66,45.26 30.53,45.26 29.95,45.84 29.65,45.84 29.25,45.45 29.25,45.17 29.85,44.57 29.85,44.45 29.52,44.12 28.28,44.12 21.97,37.81 21.97,31.53 21.83,31.38 21.47,31.38 v1(21.26,31.58)
  BOTTOM w0.102: v2(248.7,130.47) UG6.BL13
  BOTTOM w0.14: v1(21.26,31.58) 21.55,31.29 22.65,31.29 23.98,29.96 23.98,28.19 23.75,27.95 23.75,27.58 C857.1
DP_HPD: length 7.6
  TOP w0.14: v1(16.03,11.54) 15.96,11.48 15.96,10.81 16.46,10.32 ESD1.7 ESD1.4 18.4,10.32 18.69,10.61 C559.1 19.49,10.93 19.31,11.11 R672.2
  BOTTOM w0.14: CN24.2 16.29,12.46 16.43,12.32 16.43,11.95 v1(16.03,11.54)
DP_HPD_PCH: length 400.3
  TOP w0.14: RG61.2 CG365.1 277.36,127.38 277.7,127.04 v1(278.04,127.04) ; R665.2 21.88,18.31 v1(21.88,18.26) ; R672.1 19.07,12 v1(18.77,12.3) ; v1(219.65,83.76) 219.65,83.97 220.04,84.37 220.59,84.37 Q28.3 220.72,85.53 v1(220.5,85.53)
  IN1 w0.086: v1(278.04,127.04) 278.72,126.35 278.72,118.48 283.73,113.48 283.73,113.42 286.05,111.1 287.23,111.1 287.69,110.64 287.69,109.94 292.35,105.28 292.35,95.81 292.17,95.63 292.17,94.96 292.18,94.95 292.18,90.23 290.69,88.74 287.42,88.74 286.96,89.2 286.12,89.2 285.33,89.99 283.56,89.99 280.52,86.96 279.54,86.96 278.94,87.56 272.07,87.56 271.97,87.46 265.02,87.46 264.38,86.82 259.32,86.82 258.64,87.5 253.17,87.5 249.87,84.2 249.87,83.13 246.83,80.09 245.98,80.09 245.41,79.52 237.1,79.52 236.3,80.32 234.79,80.32 232.68,82.44 232.68,83.14 230.91,84.91 226.24,84.91 224.79,86.36 221.32,86.36 v1(220.5,85.53)
  IN2 w0.089: v1(200.19,62.67) 199.27,62.67 198.85,62.25 194.87,62.25 193.71,63.41 192.33,63.41 191.37,62.45 189.55,62.45 188.59,63.41 188.51,63.41 188.24,63.68 188.24,63.92 186.01,66.15 186.01,66.41 185.38,67.05 184.32,67.05 184.03,67.33 181.85,67.33 181.51,66.98 180.14,66.98 179.44,67.68 178.65,67.68 177.75,68.58 175.48,68.58 174.34,69.72 173.47,69.72 172.94,69.18 169.8,69.18 169.68,69.3 165.6,69.3 164.84,70.06 159.29,70.06 158.63,70.72 134.75,70.72 134.27,71.2 123.53,71.2 119,66.67 110.21,66.67 103.66,73.22 102.85,73.22 102.12,72.5 70.82,72.5 60.64,62.32 59.79,62.32 57.69,60.21 57.69,58.28 56.49,57.09 54.56,57.09 49.89,52.41 48.47,52.41 47.24,51.18 42.88,51.18 42.02,50.32 42.02,49.77 41.15,48.9 40.47,48.9 38.92,47.35 36.67,47.35 36.07,46.75 35.3,46.75 34.82,46.27 33.21,46.27 32.55,45.6 32.55,45.39 27.76,40.6 27.76,40.58 23.55,36.37 23.55,25.68 23.92,25.31 23.92,20.8 23.35,20.24 23.35,19.74 v1(21.88,18.26) 21.47,18.26 20.84,17.63 20.84,15.95 19.91,15.02 19.38,15.02 18.61,14.25 18.61,12.46 v1(18.77,12.3)
  IN3 w0.089: v1(200.19,62.67) 200.19,62.92 200.21,62.94 200.21,63.46 203.19,66.43 203.19,66.67 203.66,67.14 203.66,69.03 203.41,69.28 203.41,69.73 205.01,71.33 205.01,72.05 205.42,72.46 205.93,72.46 206.18,72.71 206.18,73.4 206.89,74.11 206.89,74.77 206.24,75.42 206.24,76.38 205.77,76.85 205.77,77.43 207.23,78.89 207.23,81.49 207.66,81.92 208.65,81.92 209.65,82.93 211.63,82.93 212.48,83.77 214.49,83.77 215.24,83.02 218.91,83.02 v1(219.65,83.76)
DP_HPD_PCH_Q: length 13.2
  TOP w0.14: v1(219.68,81.09) R271.2 220.09,81.61 220.09,81.61 v1(220.74,81.61) 221.66,81.61 221.89,81.85 221.89,82.2 222.19,82.49 Q28.1
  BOTTOM w0.102: U49.AT13 218.34,73.73 218.34,74.87 218.19,75.02 218.19,75.55 218.01,75.73 218.01,76.67 218.26,76.92 218.26,79.24 218.55,79.53 218.55,80.05 218.95,80.45 219.33,80.45 219.73,80.85 219.73,81.04 v1(219.68,81.09)
DP_TXN0_R: length 2.2
  BOTTOM w0.14: U56.10 19.62,25.59 19.57,25.63 19.57,25.96 19.17,26.37 19.17,26.7 C851.2
DP_TXN1_R: length 2.1
  BOTTOM w0.14: C853.2 20.68,26.69 20.68,26.42 20.78,26.33 20.78,25.62 20.82,25.58 U56.13
DP_TXN2_R: length 2.1
  BOTTOM w0.14: C855.2 22.21,26.69 22.21,26.23 21.97,26 21.97,25.57 22.02,25.52 U56.16
DP_TXN3_R: length 2.3
  BOTTOM w0.14: C857.2 23.73,26.69 23.73,26.26 23.17,25.7 23.17,25.59 23.22,25.54 U56.19
DP_TXP0_R: length 2.2
  BOTTOM w0.14: U56.9 19.22,25.6 19.26,25.64 19.26,25.83 18.85,26.23 18.85,26.69 C850.2
DP_TXP1_R: length 2.1
  BOTTOM w0.14: U56.12 20.42,25.58 20.46,25.63 20.46,26.2 20.37,26.29 20.37,26.69 C852.2
DP_TXP2_R: length 2.1
  BOTTOM w0.14: C854.2 21.89,26.69 21.89,26.36 21.66,26.13 21.66,25.58 21.62,25.54 U56.15
DP_TXP3_R: length 2.3
  BOTTOM w0.14: C856.2 23.41,26.7 23.41,26.39 22.85,25.83 22.85,25.6 22.82,25.57 U56.18
DPEQ0_A1_DP: length 2.9
  TOP w0.14: R656.2 21.22,26.94 v1(21.22,26.2) 21.13,26.12 R659.2
  BOTTOM w0.14: U56.14 v1(21.22,26.2)
DPEQ1_DP: length 2.9
  BOTTOM w0.14: U56.2 16.98,22.08 R1186.2 16.69,22.72 16.75,22.78 R1183.2
DPIHPD: length 108
  TOP w0.14: v1(218.63,82.25) 218.63,82.16 218.6,82.13 218.6,81.78 217.94,81.12 R288.1
  IN2 w0.089: v1(218.63,82.25) 218.57,82.31 218.57,84.08 217.77,84.88 217.77,85.46 217.13,86.1 217.13,86.89 216.91,87.12 216.91,88.53 216.37,89.06 216.37,94.63 212.07,98.93 210.48,98.93 209.17,100.24 209.17,101.93 209.31,102.08 209.31,102.76 208.63,103.43 207.66,103.43 205.7,105.39 205.7,108.58 201.44,112.85 197.75,112.85 185.58,125.02 185.58,146.25 177.86,153.96 177.86,156.68 177.3,157.24 175.33,157.24 172.04,160.54 172.04,161.74 171.61,162.17 v1(171.15,162.17)
  BOTTOM w0.14: UG5.4 170.35,162.69 170.48,162.82 v1(171.15,162.82) 171.15,162.81 v1(171.15,162.17)
DPIP0_HPD: length 148.6
  IN1 w0.086: v1(223.69,124.76) 222.37,124.76 222.36,124.77 217.12,124.77 216.76,124.41 214.32,124.41 213.82,124.91 208.7,124.91 208.19,124.41 198.48,124.41 190.94,131.95 190.94,146.03 190.04,146.93 190.04,154.48 182.34,162.18 175.05,162.18 174.38,162.85 171.71,162.85 170.9,163.66 169.7,163.66 168.75,164.61 166.85,164.61 165.82,165.63 v1(164.89,165.63)
  IN3 w0.089: v1(257.78,134.16) 257.18,134.16 254.63,131.6 254.63,130.88 254.69,130.82 254.69,130.04 254,129.35 253.35,129.35 253.29,129.41 252.71,129.41 252.58,129.28 252.58,128.74 250.62,126.78 250.62,122.28 250.17,121.83 250.17,121.32 249.67,120.82 248.25,120.82 247.83,121.23 247.1,121.23 245.26,123.07 245.26,124.58 242.81,127.03 239.49,127.03 238.41,125.95 224.88,125.95 v1(223.69,124.76)
  BOTTOM w0.102: v1(257.78,134.16) 258.97,135.35
  BOTTOM w0.14: 258.97,135.35 261.25,137.63 v1(261.62,137.63) 262.38,137.63 262.77,137.25 RG120.2 CG504.1 ; v1(164.89,165.63) 164.08,165.63 163.48,165.03 R755.2 163.48,163.88 163.65,163.71 R760.2
DPIP0_HPD_CPU: length 34.8
  TOP w0.14: v1(163.85,166.27) 163.85,166.89 162.51,168.23 157.98,168.23 157.51,167.76 155.24,167.76 154.67,167.18 v1(154.67,165.92)
  BOTTOM w0.079: 162.17,155.1 162.17,154.37 161.92,154.12 161.92,153.74 161.75,153.57 161.47,153.57 161.15,153.25 161.15,152.32 U42.AE38
  BOTTOM w0.14: v1(154.67,165.92) 154.38,166.2 R1199.1 ; R754.1 165.96,165.24 165.54,165.66 v1(165.54,165.96) 165.23,166.27 v1(163.85,166.27) 163.6,166.02 163.6,165.55 163.01,164.96 163.01,163.85 163.6,163.26 R760.1 164,163.26 164.14,163.12 164.14,162.82 164.59,162.38 164.74,162.38 164.75,162.37 164.86,162.37 165.09,162.14 165.09,160.92 163.41,159.24 163.41,158.65 162.95,158.18 162.95,155.88 162.17,155.1
DPIP0_HPD_CPU_R: length 20.1
  BOTTOM w0.14: UG4.1 173.11,164.41 173.02,164.5 173.02,165.48 172.71,165.8 172.71,167.89 172.86,168.05 172.86,169.01 172.48,169.39 171.35,169.39 170.53,168.57 169.28,168.57 168.83,169.03 167.6,169.03 167.13,168.55 166.17,168.55 165.35,167.73 164.45,167.73 164.33,167.86 164.33,168.42 164.11,168.64 R1206.2 161.21,168.64 160.92,168.35 Q121.3
DPIP0_RCOMP: length 9.5
  BOTTOM w0.254: U42.AT40 154.29,153.66 154.29,154.67 154.44,154.81 154.44,156.91 153.46,157.89 152.11,157.89 151.5,158.5 150.23,158.5 149.85,158.12 R777.1
DPIP1_HPD: length 172.4
  TOP w0.14: v1(283,117.5) 283,117.31 285.24,115.08 288,115.08 288.15,114.92 289.34,114.92 291.21,116.79 291.21,117.89 291.99,118.67 RG70.2 291.98,118.83 CG382.1
  IN1 w0.086: v1(222.8,123.79) 219.85,123.79 219.61,123.56 217.01,123.56 216.54,124.03 214.17,124.03 213.85,123.72 209.01,123.72 208.7,124.03 198.33,124.03 190.57,131.79 190.57,145.87 189.66,146.78 189.66,154.33 182.19,161.8 172.19,161.8 170.71,163.28 167.02,163.28 v1(166.97,163.23)
  IN2 w0.089: v1(283,117.5) 278.6,117.5 274.7,113.61 257.79,113.61 257.42,113.98 251.42,113.98 250.74,114.66 248.83,114.66 248.15,113.98 246.32,113.98 246.14,114.15 245.19,114.15 244.49,114.85 243.4,114.85 242.7,114.15 229.69,114.15 228.85,115 228.85,118.08 223.13,123.79 v1(222.8,123.79)
  BOTTOM w0.14: R755.1 163.93,164.91 164.07,165.05 165.55,165.05 165.84,164.76 165.84,163.32 165.98,163.18 R761.2 166.92,163.18 v1(166.97,163.23)
DPIP1_HPD_CPU: length 22
  BOTTOM w0.079: U42.AE35 160.95,150.14 161.13,150.29 161.13,150.85 161.25,150.97 162.52,150.97 162.64,151.09 162.64,154.78
  BOTTOM w0.14: 162.64,154.78 163.43,155.57 163.43,157.88 163.97,158.42 163.97,159.01 166.02,161.06 166.02,162.55 166.2,162.73 R761.1 167.12,162.73 167.43,163.04 167.43,163.7 v1(167.29,163.84) ; v1(167.29,163.84) 167.29,164.28 167.4,164.39 167.4,165.44 167.82,165.85 R1201.1 ; v1(167.29,163.84) 166.87,163.84 166.77,163.74 R757.1
DPIP1_HPD_CPU_R: length 15.8
  BOTTOM w0.14: UG4.2 173.76,163.59 173.52,163.84 R1207.2 173.52,164.41 173.3,164.62 173.3,165.6 172.99,165.91 172.99,167.77 173.14,167.93 173.14,169.21 172.69,169.67 171.23,169.67 170.42,168.85 169.4,168.85 168.95,169.3 167.49,169.3 167.01,168.83 166.06,168.83 165.45,168.22 Q122.3
DPIP1_RCOMP: length 5.6
  BOTTOM w0.079: 152.01,153.8 152.01,153.56 152.09,153.48 152.09,153.15 152.26,152.97 152.81,152.97 U42.AU39
  BOTTOM w0.254: 152.01,153.8 152.01,154.16 152.09,154.24 152.09,156.23 151.4,156.92 R787.1
DPIP2_HPD: length 179.6
  TOP w0.14: RG45.2 CG292.1 286.13,138.42 285.71,138 v1(285.26,138)
  IN1 w0.086: v1(165.36,164.59) 166.06,164.59 166.18,164.46 166.39,164.46 167.38,163.47 170.79,163.47 172.27,161.99 182.27,161.99 189.85,154.4 189.85,146.86 190.76,145.95 190.76,131.87 198.4,124.22 208.27,124.22 208.77,124.73 213.74,124.73 214.25,124.22 216.84,124.22 217.2,124.58 222.94,124.58 v1(223.22,124.3)
  IN2 w0.089: v1(223.22,124.3) 223.22,123.98 229.04,118.16 229.04,115.08 229.77,114.35 242.63,114.35 243.32,115.04 244.57,115.04 245.27,114.35 246.22,114.35 246.4,114.17 248.07,114.17 248.75,114.85 250.82,114.85 251.5,114.17 257.5,114.17 257.87,113.8 274.62,113.8 281.41,120.59 281.41,132.44 285.58,136.6 285.58,137.68 v1(285.26,138)
  BOTTOM w0.14: v1(165.36,164.59) 165.5,164.45 165.5,163.52 165.11,163.13 R762.2
DPIP2_HPD_CPU: length 21.7
  IN2 w0.089: v1(165.56,161.97) 165.81,162.22 v1(167.76,162.22)
  BOTTOM w0.079: U42.AE37 161.31,151.82 161.31,152.88 161.39,152.96 161.94,152.96 162.08,153.1 162.08,154.05 162.36,154.34 162.36,154.84
  BOTTOM w0.14: R1204.1 169.2,164.82 168.91,164.53 168.06,164.53 167.76,164.22 v1(167.76,162.22) ; 162.36,154.84 163.19,155.67 163.19,158.03 163.69,158.54 163.69,159.13 165.56,160.99 v1(165.56,161.97) 165.56,162.17 165.05,162.68 R762.1 164.71,162.68 164.47,162.93 164.47,163.29 164.84,163.66 R758.1
DPIP2_HPD_CPU_R: length 15.8
  BOTTOM w0.14: UG5.2 168.53,162.04 168.89,162.4 168.89,163.31 169.07,163.49 R1208.2 169.07,164.06 169.32,164.3 169.73,164.3 169.86,164.17 169.86,163.5 170,163.36 170.87,163.36 171.12,163.62 171.12,164.66 172.33,165.87 172.33,167.91 172.59,168.17 172.59,168.88 172.36,169.11 171.47,169.11 170.64,168.29 168.63,168.29 Q123.3
DPIP2_RCOMP: length 6.4
  BOTTOM w0.254: R781.1 151.27,157.48 151.34,157.48 151.88,156.94 153.15,156.94 153.58,156.51 153.58,154.27 153.55,154.24 153.55,153.69 U42.AU40
DPIP3_HPD_CPU: length 7.4
  BOTTOM w0.079: U42.AC35 162.83,150.51 162.83,154.52 162.97,154.66
  BOTTOM w0.14: R783.1 163.79,155.49 162.97,154.66
DPIP3_RCOMP: length 8.4
  BOTTOM w0.254: R786.1 149.85,157.19 150.24,157.58 150.24,157.89 150.5,158.14 151.33,158.14 152.07,157.39 153.34,157.39 154.06,156.67 154.06,154.9 153.91,154.76 153.91,153.94 U42.AT41
DPWROK_EC: length 55.8
  TOP w0.14: U23.119 173.11,70.12 172.41,69.42 172.41,67.35 172.98,66.77 172.98,65.53 174.28,64.22 v1(174.28,62.57)
  IN2 w0.089: v1(207.05,48.3) 206.35,49 201.72,49 201.18,48.46 196.77,48.46 191.46,53.78 191.46,54.08 189.75,55.78 187.54,55.78 186.18,57.14 185.53,57.14 183.1,59.57 183.1,60.65 182.32,61.42 181.89,61.42 181.25,62.07 174.79,62.07 v1(174.28,62.57)
  BOTTOM w0.14: v1(207.05,48.3) 207.05,48.11 207.35,47.81 207.87,47.81 209.13,49.07 R1102.1
DPWROK_EC_R: length 9.4
  BOTTOM w0.102: U49.AB46 211.71,56.69 211.48,56.46 211.48,56.09 211.71,55.86 211.71,54.9 211.13,54.32 211.13,53.77 210.75,53.38 210.49,53.38 210.03,52.92 210.03,52.24 209.2,51.4
  BOTTOM w0.14: 209.2,51.4 208.68,50.89 R1102.2 208.68,50.03 TP172.1 208.51,49.85 R1127.1
DRMOS_IMON1: length 52.1
  TOP w0.14: v1(255.24,72.44) 255.46,72.23 PR244.1
  IN3 w0.14: v1(218.01,88.02) 218.27,88.28 220.02,88.28 220.71,87.59 227.08,87.59 227.82,86.86 233.58,86.86 233.89,86.55 236.05,86.55 236.35,86.86 250.08,86.86 250.97,85.96 250.97,80.11 252.25,78.83 252.25,74.74 253.29,73.7 253.98,73.7 v1(255.24,72.44)
  BOTTOM w0.14: v1(218.01,88.02) 218.38,88.02 218.61,88.24 218.82,88.24 219.05,88.48 PU31.38
DRMOS_IMON2: length 41.8
  TOP w0.14: PR237.1 255.36,73.37 v1(255.18,73.55)
  IN3 w0.14: v1(227.62,87.94) 228.46,87.1 233.68,87.1 233.99,86.79 235.95,86.79 236.25,87.1 250.18,87.1 251.22,86.06 251.22,80.21 252.59,78.83 252.59,75.74 252.86,75.48 253.88,75.48 254.64,74.72 254.64,74.16 255.18,73.62 v1(255.18,73.55)
  BOTTOM w0.14: v1(227.62,87.94) 227.68,88 228.25,88 228.49,88.24 228.59,88.24 228.83,88.48 PU32.38
DRMOS_IMON3: length 31.1
  TOP w0.14: PR226.2 255.27,74.38 v1(255.15,74.26)
  IN3 w0.14: v1(237.4,87.94) 238,87.34 250.28,87.34 251.46,86.16 251.46,80.31 252.83,78.93 252.83,77.59 253.24,77.18 253.93,77.18 254.08,77.03 254.08,75.71 255.15,74.64 v1(255.15,74.26)
  BOTTOM w0.14: v1(237.4,87.94) 237.46,88 238.03,88 238.27,88.24 238.37,88.24 238.61,88.48 PU33.38
DRMOS_IMON4: length 20.4
  TOP w0.14: PR223.2 255.68,75.27 v1(255.15,75.27)
  IN3 w0.14: v1(247.18,87.94) 247.52,87.59 250.37,87.59 251.72,86.24 251.72,80.39 253.08,79.03 253.08,78.28 253.29,78.07 253.88,78.07 254.38,77.56 254.38,76.04 v1(255.15,75.27)
  BOTTOM w0.14: PU34.38 248.39,88.48 248.15,88.24 248.05,88.24 247.81,88 247.24,88 v1(247.18,87.94)
DRMOS_IMON5: length 18.5
  TOP w0.14: PR211.2 255.27,76.42 v1(255.15,76.29)
  IN3 w0.14: v1(256.96,87.94) 256.63,87.61 254.82,87.61 252.99,85.78 252.99,83.73 253.65,83.07 253.99,83.07 254.84,82.22 254.84,80.22 254.11,79.49 254.11,78.27 254.64,77.74 254.64,76.8 v1(255.15,76.29)
  BOTTOM w0.14: v1(256.96,87.94) 257.02,88 257.58,88 257.83,88.24 257.93,88.24 258.17,88.48 PU35.38
DRMOS_IMON6: length 25.3
  TOP w0.14: v1(255.15,77.31) 255.27,77.43 PR203.2
  IN3 w0.14: v1(266.74,87.94) 266.42,87.62 257.79,87.62 257.49,87.31 255.58,87.31 254.35,86.08 254.35,83.05 255.08,82.32 255.08,80.12 254.35,79.39 254.35,78.46 255.15,77.66 v1(255.15,77.31)
  BOTTOM w0.14: v1(266.74,87.94) 266.8,88 267.36,88 267.61,88.24 267.71,88.24 267.95,88.48 PU36.38
DRMOS_IMON7: length 34
  TOP w0.178: v1(255.17,78.32) 255.3,78.45 PR197.2
  IN3 w0.14: v1(276.47,88.15) 276.06,87.75 273.28,87.75 272.92,87.38 257.89,87.38 257.59,87.07 255.68,87.07 254.59,85.98 254.59,83.15 255.32,82.42 255.32,80.02 254.59,79.29 254.59,78.9 v1(255.17,78.32)
  BOTTOM w0.178: PU29.38 277.98,88.71 277.75,88.48 277.39,88.48 277.06,88.15 v1(276.47,88.15)
DRMOS_IMON8: length 42.6
  TOP w0.178: PR190.2 255.32,79.34 255.27,79.29 v1(255.27,79.29)
  IN3 w0.14: v1(286.27,87.99) 284.89,89.37 283.47,89.37 281.6,87.5 273.38,87.5 273.02,87.14 258.12,87.14 257.81,86.83 257.56,86.83 257.03,86.3 257.03,85.88 256.67,85.51 255.58,85.51 255.15,85.08 255.15,83.86 255.57,83.44 255.57,79.59 v1(255.27,79.29)
  BOTTOM w0.178: PU30.38 287.89,88.71 287.58,88.4 286.99,88.4 286.58,87.99 v1(286.27,87.99)
DRMOS_REFIN: length 121.2
  TOP w0.14: 251.29,79.44 251.08,79.23 251.08,77.33 251.22,77.19 PC162.2 ; 251.29,79.44 251.03,79.69 250.93,79.69 250.24,80.39 249.81,80.39 248.56,81.64 248.56,85.57 248.42,85.71 246.87,85.71 v1(246.38,86.2) ; 251.29,79.44 251.72,79.44 251.94,79.66 PC159.2 PR187.1 252.52,79.83 PR193.1 PC160.2 ; PC181.2 251.14,73.44 250.96,73.62 250.96,74.46 251.5,75 PC168.2 ; PC181.2 251.49,73.13 251.63,72.99 252.23,72.99 252.35,73.11 252.35,73.28 PR235.1 252.61,73.34 252.61,72.85 252.92,72.54 252.92,71.72 253.73,70.91 255.96,70.91 256.59,71.54 256.59,72.91 256.95,73.27 PR228.2 PC191.1 257.41,72.58 257.86,72.13 PR242.2 258.19,71.46 PR250.1 ; PC181.2 251.49,73.58 251.94,74.03 PC174.2 PR227.1 ; PC162.2 251.5,77.34 251.96,77.81 PC161.2 PR199.1 252.51,77.71 PR205.1 ; PC162.2 251.5,76.92 250.9,76.33 250.9,75.63 251.19,75.34 PC168.2 ; PR224.1 252.51,76.09 PR213.1 PC164.2 251.95,75.94 251.5,75.49 PC168.2
  IN1 w0.086: v1(273.65,85.84) 273.28,86.21 272.76,86.21 272.39,85.85 271.07,85.85 270.73,86.18 268.62,86.18 268.14,85.7 266.41,85.7 v1(265.94,86.17)
  IN4 w0.14: v1(273.65,85.84) 274.32,86.51 275.63,86.51 276.28,87.16 282.81,87.16 283.01,86.96 284.41,86.96 v1(284.89,86.48) ; v1(265.94,86.17) 265.01,87.1 256.56,87.1 v1(255.75,86.3) 255.35,86.7 246.89,86.7 v1(246.38,86.2) 245.75,86.83 237.11,86.83 v1(236.6,86.32) 236.1,86.83 227.29,86.83 v1(226.83,86.36) 226.33,86.86 220.78,86.86 219.92,87.72 218.37,87.72 218.09,87.44 216.49,87.44 216.26,87.67 v1(216.26,87.69)
  BOTTOM w0.14: PR572.1 275.72,86.32 275.24,85.84 v1(273.65,85.84) ; PR599.2 256.16,86.71 v1(255.75,86.3) ; v1(265.94,86.17) PR604.2 ; v1(284.89,86.48) 284.89,86.92 285.03,87.06 PR570.1 ; v1(236.6,86.32) PR589.2 ; v1(226.83,86.36) PR584.2 ; PR579.2 216.61,86.86 216.27,87.2 216.27,87.68 v1(216.26,87.69) ; PR594.2 v1(246.38,86.2)
DRVON: length 79.8
  IN1 w0.086: v1(158.43,197.42) 157.91,197.93 157.18,197.93 156.42,198.69 155.2,198.69 154.82,198.31 149.3,198.31 v1(148.45,197.46) 147.29,198.62 142.57,198.62 141.37,199.82 140.07,199.82 139.62,199.38 139.62,198.37 v1(138.71,197.46) 136.63,199.53 134.19,199.53 133.63,200.09 130.08,200.09 129.33,199.34 v1(129.33,197.42) 128.88,197.42 126.45,199.85 120.9,199.85 120.32,199.28 120.32,198.48 v1(119.32,197.48) 119.12,197.48 117.25,199.35 115.81,199.35 v1(112.58,202.58) 113.21,203.21 113.21,205.26 116.55,208.61 v2(116.55,209.45)
  BOTTOM w0.14: v1(138.71,197.46) 138.84,197.32 PR461.1 ; PR462.1 148.5,197.42 v1(148.45,197.46)
  BOTTOM w0.152: PU20.24 117.2,209.93 116.72,209.45 v2(116.55,209.45) 116.36,209.45 115.8,210.01 PC305.2
  BOTTOM w0.203: v1(119.32,197.48) 119.34,197.48 119.54,197.28 PR459.1 ; PR458.1 110.08,197.19 109.6,197.66 109.6,200.75 111.43,202.58 v1(112.58,202.58) ; v1(129.33,197.42) 129.19,197.28 PR460.1 ; v1(158.43,197.42) 158.43,197.38 158.15,197.1 PR463.1
EAPD: length 29.2
  TOP w0.14: R503.2 308.56,62.68 308.29,62.68 v1(308.02,62.95) ; R372.1 292.19,74.35 292.86,73.68 D31.1 291.97,73.11 v1(290.71,71.84) 290.71,71.26 291.16,70.8 v1(291.32,70.8)
  IN3 w0.089: v1(291.32,70.8) 291.37,70.8 291.62,71.06 292.08,71.06 292.61,71.59 296.4,71.59 298.8,69.19 298.8,66.1 300.17,64.73 302.53,64.73 304.4,62.87 304.73,62.53 306.67,62.53 307.09,62.96 308.02,62.96 v1(308.02,62.95)
EAR#: length 20.9
  TOP w0.102: 173.74,155.66 172.93,154.85 172.93,152.72 173.15,152.49 173.15,152.11 173.07,152.02 173.07,151.51 173.44,151.13 v2(173.44,150.85)
  TOP w0.14: R91.2 v1(183.93,160.62) 181.36,160.62 180.71,161.27 178.66,161.27 v1(176.89,159.5) 176.89,158.81 173.74,155.66
  BOTTOM w0.102: U42.F36 173.44,150.82 v2(173.44,150.85)
  BOTTOM w0.14: v1(176.89,159.5) 176.89,159.88 R766.2
EC_FPBACK: length 224.2
  TOP w0.14: v1(185.21,66.65) 184.56,67.3 U23.86
  IN3 w0.089: v1(277.37,198.79) 277.37,196.65 277.22,196.49 277.22,193.6 277.6,193.21 278.65,193.21 279.36,193.92 280.04,193.92 280.35,193.61 280.35,188.85 282.06,187.13 282.06,153.84 280.62,152.4 280.62,131.44 277.68,128.49 275.75,128.49 272.37,125.11 272.37,124.78 269.23,121.64 269.23,119.17 268.78,118.71 266.79,118.71 265.93,117.86 263.37,117.86 261.53,116.02 261.53,115.31 261.53,115.31 261.53,114.22 261.06,113.75 248.44,113.75 248.02,113.33 244.51,113.33 244.02,113.82 240.9,113.82 240.61,113.54 212.89,113.54 210.25,110.9 210.25,110.43 209.7,109.88 209.7,105.93 208.94,105.18 208.94,103.39 208.25,102.7 208.25,100.96 203.26,95.97 202.74,95.97 199.96,93.18 199.96,87.14 199.03,86.21 199.03,80.39 198.93,80.28 198.93,76.53 198.72,76.32 198.72,70.15 199,69.87 199,68.26 199.05,68.21 199.05,67.74 v1(198.8,67.49)
  IN4 w0.086: v1(185.21,66.65) 185.41,66.44 188.57,66.44 189.26,67.13 196.58,67.13 197.93,68.47 198.56,68.47 198.81,68.22 198.81,67.5 v1(198.8,67.49)
  BOTTOM w0.14: v1(277.37,198.79) 277.37,200.24 276.91,200.7 276.2,200.7 275.99,200.48 U39.2
EC_GPI2: length 4.1
  TOP w0.14: R540.1 R539.1 186.65,59.94 186.59,59.88 185.28,59.88 185.06,60.1 U23.68
EC_HRST: length 149.5
  TOP w0.14: Q21.2 77.44,89.51 85.47,81.47 85.47,79.71 86.93,78.26 88.09,78.26 88.97,79.14 96.73,79.14 97.16,78.71 v1(97.16,78.71) ; v1(178.84,62.7) 178.84,61.45 178.63,61.23 178.63,60.12 179.94,58.81 181.56,58.81 182.68,57.7 182.68,55.77 181.56,54.64 179.64,54.64 R594.1
  IN3 w0.089: v1(108.16,55.47) 108.5,55.81 111.88,55.81 112.76,56.69 117.18,56.69 119.28,58.79 123.03,58.79 123.96,59.72 140.08,59.72 143.93,63.57 147.18,63.57 148.7,65.09 153.31,65.09 153.52,64.88 157.11,64.88 157.47,64.52 158.68,64.52 158.84,64.36 160.8,64.36 161.58,63.58 163.72,63.58 164.56,64.42 165.31,64.42 166.33,65.44 169.6,65.44 170.15,64.89 175.74,64.89 176.62,64 177.54,64 v1(178.84,62.7)
  BOTTOM w0.14: v1(108.16,55.47) 105.94,57.69 105.94,70.26 104.97,71.22 103.34,71.22 102.02,72.54 100.69,72.54 98.75,74.48 98.75,76.3 97.16,77.9 v1(97.16,78.71)
EC_I2C_INT_D: length 9.1
  TOP w0.14: U11.D1 63.28,88.03 63.3,88.05 63.68,88.05 64.04,87.68 64.04,87.6 64.45,87.2 64.69,87.2 64.83,87.06 R203.1 64.83,86.75 65.02,86.56 66.02,86.56 TP33.1 67.42,87.96 67.42,88.77 67.62,88.97 R193.2 68.26,88.97 Q22.1
EC_I2C_SCL_D: length 11.7
  TOP w0.14: Q20.1 69.87,92.02 70.11,91.78 TP31.1 69.85,90.77 68.93,90.77 R178.2 68.92,90.46 68.52,90.06 67.96,90.06 66.04,88.15 64.99,88.15 64.83,87.98 R200.1 64.5,87.72 63.87,88.35 63.87,88.66 63.63,88.9 63.22,88.9 62.75,88.43 U11.E1
EC_I2C_SDA_D: length 12.6
  TOP w0.14: U11.F1 62.52,88.83 63,89.31 64.52,89.31 64.83,89 R192.1 64.83,88.68 65.04,88.47 66,88.47 66.82,89.29 66.82,89.86 67.15,90.2 67.15,91.11 66.4,91.86 66.4,93.03 TP29.1 66.69,93.32 Q20.4 68.08,93.32 68.23,93.47 68.23,94.36 R159.2
EC_PECI: length 201.1
  TOP w0.14: v1(173.77,78.53) 173.77,77.09 173.73,77.06 173.73,76.13 173.57,75.97 R364.1
  IN1 w0.086: v1(112,90.31) 112.65,90.95 112.65,95.76 114.89,98 114.89,120.61 117.02,122.74 117.02,135.76 123.2,141.94 123.2,144.04 123.55,144.39 124.73,145.57 v1(124.73,145.65)
  IN2 w0.089: v1(215.39,82.3) 215.42,82.27 215.76,82.27 216.72,81.32 216.72,80.87 216.05,80.2 215.22,80.2 214.53,79.52 213.11,79.52 212.75,79.16 210.33,79.16 209.29,78.13 206.17,78.13 205.45,78.84 202,78.84 201.77,78.61 201.26,78.61 200.51,77.86 199.6,77.86 199.14,78.32 199.14,78.68 199.85,79.39 199.85,80.02 199.3,80.58 198.4,80.58 195.76,77.93 184.39,77.93 183.45,78.87 174.12,78.87 v1(173.77,78.53) 172.69,77.45 169.99,77.45 168.93,78.5 153.57,78.5 152.8,77.73 151.48,77.73 150.98,77.23 150.18,77.23 148.89,75.94 145.24,75.94 144.85,75.54 143.45,75.54 143.06,75.94 138.81,75.94 137.44,77.31 129.83,77.31 129.07,76.55 121.32,76.55 120.5,77.38 117.35,77.38 116.35,78.38 112.81,78.38 111.39,79.8 111.39,89.69 v1(112,90.31)
  BOTTOM w0.088: U42.CP25 128.97,144.97 127.22,144.97 127.17,145.03
  BOTTOM w0.102: C729.1 215.33,84.52 215.8,84.05 215.8,83.27 215.7,83.17 R911.1 215.7,82.6 v1(215.39,82.3)
  BOTTOM w0.14: 127.17,145.03 126.83,145.03 126.42,145.44 124.94,145.44 v1(124.73,145.65)
