# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3V3PD: length 16.1
  TOP w0.203: v1(65.83,87.02) 65.77,86.96 R203.2 R200.2
  TOP w0.305: Q24.1 v1(72.05,87.22) ; Q20.5 v1(66.93,92.67) ; Q25.2 v1(70.69,87.14) ; v1(70.36,92.78) 70.26,92.67 Q20.2 ; v1(67.06,83.91) Q29.5 ; Q29.2 v1(70.36,83.91) ; v1(65.81,88.94) 65.74,88.86 R192.2 ; R211.2 72.43,85.33 v1(72.74,85.02) ; Q22.2 v1(69.97,89.01)
  BOTTOM w0.305: Q106.5 66.88,88.23 v1(66.45,87.8) ; v1(65.83,87.02) 65.83,87.03 65.52,87.34 R862.2 ; Q106.2 69.47,88.23 69.97,88.73 v1(69.97,89.01) 69.97,90.01 69.35,90.64 68.96,90.64 68.58,91.03 Q105.2 ; R853.2 65.51,89.24 v1(65.81,88.94) 65.36,88.48 R858.2
  vias: v1(62.89,91.12)
+3V_5G: length 107.4
  TOP w0.508: 271.19,57.28 271.19,57.28 271.19,56.16 272.42,54.94 273.96,54.94 274.37,55.35 275.17,55.35 v1(275.5,55.69) 277.91,55.69 278.71,56.48 280.64,56.48 281.15,55.98 v1(281.15,55.15) ; v1(279.2,70.68) 279.2,70.39 281.52,68.07 281.52,66.96 284.23,64.25 Q49.2 Q49.5
  IN1 w0.508: v1(284.64,58.51) 284.64,54.88 v1(284.99,54.52)
  IN2 w0.508: v1(304.3,76.75) 302.75,78.3 300.76,78.3 300.1,78.96 299.22,78.96 298.53,78.27 v1(297.89,78.27) ; v1(279.2,70.68) 279.39,70.48 279.39,69.77 277.25,67.62 277.25,62.93 276.21,61.89 276.21,59.88 v1(277.24,58.84) 277.24,58.47 275.5,56.73 v1(275.5,55.69)
  IN3 w0.508: v1(286.39,80.23) 286.39,79.69 284.7,78.01 284.04,78.01 283.08,77.04 283.08,76.56 282.11,75.6 279.09,75.6 278.08,74.59 278.08,73.31 277.79,73.02 277.79,71.18 278.3,70.68 v1(279.2,70.68)
  IN4 w0.508: v1(309.71,88.43) 308.1,88.43 307.62,88.91 302.17,88.91 300.56,87.3 300.56,85.92 299.84,85.19 299.31,85.19 v1(299.06,84.94) 298.65,84.94 298.37,84.66 298.37,83.94 299.98,82.33 299.98,80.51 299.49,80.02 296.37,80.02 296.27,80.13 288.32,80.13 287.79,79.59 286.77,79.59 286.39,79.97 v1(286.39,80.23)
  BOTTOM w0.203: v1(310,92.27) 310.36,91.91 R843.1
  BOTTOM w0.508: v1(297.89,78.27) 297.72,78.09 297.46,78.09 297.16,77.79 297.16,77.1 297.56,76.7 ; R1063.2 285.42,54.09 v1(284.99,54.52)
  vias: v1(270.93,57.95) v1(296.6,92.62) v1(296.6,91.96) v1(297.08,105.61) v1(298.81,89.24) v1(305.39,76.26) v1(305.39,75.5) v1(305.97,91.98) v1(306.1,76.26) v1(306.1,75.5) v1(306.27,92.57) v1(306.28,91.41) v1(306.62,91.97) v1(306.78,76.26) v1(306.78,75.5) v1(306.95,92.55) v1(306.93,91.4)
+3V_DEEP_SUS: length 413.2
  TOP w0.381: v1(231.62,59.67) 232.46,60.52 234.45,60.52 235.65,59.31 236.52,59.31 238.23,57.6 240.17,57.6 240.75,57.02 246.52,57.02 247.01,56.54 R579.2 ; v1(229.68,78.24) 229.68,79.51 228.88,80.3 227.49,80.3 225.66,78.47 225.33,78.47 224.59,77.74 222.71,77.74 222.34,78.11 R321.2 ; U25.5 98.51,63.99 98.04,64.46 96.11,64.46 94.52,62.86 v1(94.52,62.6) ; v1(97.5,85.9) 98.29,85.9 98.67,86.28 U12.5 ; U30.5 213.06,46.33 212.43,46.97 C526.1 212.43,48.43 212.52,48.53 212.52,49.14 212.19,49.47 212.19,50.59 214.89,53.28 215.47,53.28 v1(215.49,53.26) 216.01,53.26 217.01,52.26 218.53,52.26 220.46,50.34 227.85,50.34 230.09,52.58 230.09,53.57 231.19,54.67 v1(232.48,54.67) 231.95,55.2 229.35,55.2 228.79,55.76 228.79,56.56 229.39,57.16 229.39,59.76 ; R511.1 198.05,61.35 v1(198.28,61.11)
  IN2 w0.381: v1(97.5,85.9) 94.63,83.03 v1(91.97,83.03) ; v1(192.88,61.81) 194.43,61.81 194.61,61.64 197.75,61.64 v1(198.28,61.11) 199.38,60.01 201.66,60.01 203.54,58.13 203.54,57.45 206.31,54.68 209.23,54.68 209.5,54.95 210.43,54.95 210.7,54.68 211.37,54.68 211.51,54.81 213.35,54.81 214.9,53.26 v1(215.49,53.26)
  IN3 w0.381: v1(21.72,57.17) 24.01,54.88 24.01,52.54 22.71,51.25 22.71,49.49 23.29,48.92 28.03,48.92 29.28,50.17 35.86,50.17 38.65,52.96 46.5,52.96 48.19,54.65 58.44,54.65 59.38,55.59 59.38,56.56 61.85,59.03 62.82,59.03 63.41,59.62 64.2,59.62 67.73,63.15 93.74,63.15 94.29,62.6 v1(94.52,62.6) 95.75,62.6 95.93,62.78 109.7,62.78 110.41,63.49 115.58,63.49 116.16,64.08 123.57,64.08 124.95,65.46 130.35,65.46 131.71,66.82 133.28,66.82 133.84,67.37 141.1,67.37 141.81,66.67 145.89,66.67 148.29,69.08 153.87,69.08 155.36,67.59 158.33,67.59 159.84,69.1 164.91,69.1 165.26,68.76 173.22,68.76 173.68,68.3 177.7,68.3 179.3,66.7 183.57,66.7 184.76,65.5 185.46,65.5 187.68,63.28 187.68,62.47 188.49,61.65 192.72,61.65 v1(192.88,61.81) ; v1(97.5,85.9) 97.5,86.39 100.29,89.18 100.29,93.41 105.84,98.96 105.84,100.89 116.22,111.26 116.22,115.74 113.08,118.88 113.08,119.65 117,123.56 117,135.63 v1(115.58,137.05)
  BOTTOM w0.203: R983.2 228.28,66.36 228.3,66.36 228.32,66.38 v1(228.35,66.38) 228.35,66.49 228.1,66.73 R980.2 ; R970.2 227.92,68.38 228.35,67.95 v1(228.44,67.95) 228.15,67.66 R975.2 ; R987.2 228.32,64.16 v1(228.46,64.02) 228.26,63.83 R991.2 ; v1(229.77,73.06) 229.33,72.62 R953.2 229.33,71.5 R955.2 ; v1(230.05,59.53) 230.04,59.54 230.04,59.54 230.02,59.55 R1019.2 ; R969.2 v1(230.09,68.49) 230.09,68.25 R974.2 ; R1010.2 229.77,60.39 v1(229.9,60.52) 229.83,60.59 229.83,60.68 229.37,61.14 R1006.2 ; R986.2 229.37,64.16 R989.2 229.86,64.06 v1(230.01,64.06)
  BOTTOM w0.254: U49.AM37 216.88,61.69 v1(217.27,62.09) ; U49.AP22 218.19,68.85 v1(218.52,69.18) ; v1(210.12,70.47) 210.12,70.6 209.82,70.9 U49.V18 ; U49.AG18 214.7,71.43 v1(214.7,71.47) ; U49.AP24 218.13,68.08 v1(218.53,68.49) ; v1(229.21,70.03) R958.2 227.91,70.03 R964.2 ; v1(219.85,68.44) 219.83,68.42 U49.AU24 ; R937.2 R932.2 229.59,77.71 229.68,77.8 v1(229.68,78.24) 229.59,78.32 R924.2 ; U49.AA18 211.56,70.98 211.96,71.38 v1(211.98,71.38) ; v1(218.35,62.89) U49.AT35 ; U49.AP19 218.18,70.58 218.51,70.25 v1(218.52,70.25)
  BOTTOM w0.381: v1(21.72,57.17) 21.85,57.04 R1053.2 ; v1(91.97,83.03) 91.97,71.36 93.16,70.17 93.16,65.7 94.52,64.34 v1(94.52,62.6) ; 115.24,142.46 115.47,142.23 115.47,137.3 115.58,137.2 v1(115.58,137.05)
+3V_DP: length 5.1
  TOP w0.508: v1(22.94,11.49) 23.32,11.49 R671.2
  BOTTOM w0.14: v1(24.04,25.87) 24.06,25.88
  BOTTOM w0.178: U56.20 23.62,25.44 v1(24.04,25.87) ; 24.06,25.88 24.06,26.43 24.51,26.88
  BOTTOM w0.508: 26.19,26.99 24.62,26.99 24.51,26.88
  vias: v1(14.58,19.43) v1(14.57,18.78) v1(14.71,23.18) v1(15.24,19.45) v1(15.26,18.79) v1(15.4,23.2) v1(15.89,19.47) v1(15.91,18.79) v1(17.54,20.87) v1(17.88,41.9) v1(18.55,41.9) v1(19.74,8.74) v1(22.95,27.89) v1(24.91,21.12) v1(25.69,19.07) v1(26.19,21.39)
+3V_DVDD: length 1.6
  TOP w0.203: 307.86,68.27 308.3,67.83 U20.3
  vias: v1(305.3,71.03)
+3V_DVDD_IO:
  vias: v1(310.08,62.73) v1(312.02,62.42)
+3V_EC: length 7.1
  TOP w0.203: U23.11 167.03,67.3
  TOP w0.254: 167.03,67.3 166.73,67.6 166.73,68.16 v1(166.41,68.47) 166.38,68.51 165.65,68.51 C434.1 165.53,68.85 165.28,69.1 164.02,69.1 R436.2 R413.2
+3V_EDPMUX: length 11.6
  IN3 w0.508: v1(262.75,213.31) 264.97,215.53 v2(265.67,215.53)
  BOTTOM w0.203: v1(271.82,215.2) 271.96,215.06 271.96,214.93 272.4,214.49 U36.3 ; U36.29 273.6,210.62 v1(273.73,210.48) ; v1(276.02,214.93) 276,214.91 U36.12 ; U36.32 272.4,210.42 v1(272.33,210.36) ; v1(276.35,210.23) 276.35,210.47 276,210.82 U36.23 ; v1(275.02,210.05) 274.8,210.27 U36.26
  BOTTOM w0.305: U37.16 262.35,213.51 262.56,213.31 v1(262.75,213.31)
  vias: v1(279.07,205.71) v1(279.25,206.65) v2(266.26,215.57)
+3V_HDD_REDRIVER:
  vias: v1(266.69,45.39) v1(266.75,44.7) v1(270.62,43.45) v1(271.01,44.29) v1(271.22,43.68) v1(274.12,43.07) v1(278.9,47.28) v1(278.92,46.52) v1(278.97,45.78)
+3V_HDMI: length 8.6
  TOP w0.254: U27.24 v1(38.73,55.86) ; U27.36 v1(44.73,55.92) ; U27.27 40.23,55.92 v1(40.24,55.92) ; U27.12 v1(40.23,60.6) ; U27.30 41.73,55.92 v1(41.74,55.92) ; U27.3 v1(44.73,60.57) ; U27.9 v1(41.73,60.57) ; U27.33 v1(43.23,55.92) ; U27.15 v1(38.73,60.56) ; U27.6 v1(43.23,60.57)
  TOP w0.508: v1(46.87,60.52) 47.53,61.18 R527.2
  vias: v1(34.8,57.62) v1(35.4,59.76) v1(35.41,59.07) v1(36.96,54.38)
+3V_LDO_EC: length 383.1
  TOP w0.381: v1(208.28,41.85) 208.28,40.96 209.24,40.01 212.86,40.01 213.32,40.47 213.32,42.72 216.6,46.01 219.82,46.01 219.9,45.93 220.6,45.93 221.63,46.97 233.82,46.97 238.49,51.64 238.49,54.56 239.65,55.72 244.69,55.72 246.77,53.63 248.67,53.63 250.06,52.25 250.06,49.3 251.65,47.71 256.07,47.71 259.26,50.9 259.26,52.37 ; R337.2 178.41,76.79 v1(178.23,76.62) 178.23,76 R358.2 ; v1(199.2,203.11) 199.41,203.33 PR96.2 ; R438.1 190.3,69.21 v1(190.89,68.62) ; R361.2 180.98,75.74 180.57,76.14 v1(180.57,76.6) 180.57,76.98 R338.1 ; R458.2 v1(162.61,67.4) ; D34.1 160.1,71.67 160.1,71.05 v1(160.06,71.01) ; PR272.2 PR273.2 157.62,65.08 v1(157.95,65.41)
  IN1 w0.381: v1(206.85,46) 206.68,46.17 204.97,46.17 204.8,46 200.14,46 199.65,46.49 195.22,46.49 193.89,47.82 193,47.82 192.66,48.16 191.65,48.16 190.89,48.92 190.89,49.46 191.85,50.41 191.85,55.73 v1(191.16,56.41) ; v1(199.2,203.11) 200.29,204.2 214.71,204.2 214.9,204.01 227.31,204.01 v1(227.51,204.2)
  IN2 w0.381: v1(191.16,56.41) 190.99,56.41 190.31,57.09 188.35,57.09 185.86,59.59 185.26,59.59 184.19,60.65 184.19,61.54 182.83,62.9 182.71,63.02 182.71,63.43 182.05,64.08 181.12,64.08 180.67,63.63 178.46,63.63 177.81,62.97 175.46,62.97 174.22,64.21 171.71,64.21 171.52,64.4 169.87,64.4 169.32,63.85 169.09,63.85 168.26,63.02 165.1,63.02 165.02,63.1 164.76,63.1 163.94,63.92 163.62,63.92 162.99,64.54 162.53,64.54 v1(161.8,65.27) ; v1(199.2,203.11) 199.2,200.28 200.41,199.08 200.41,195.23 188.06,182.89 188.06,167.88 v1(187.96,167.78)
  IN3 w0.381: v1(190.89,68.62) 190.89,69.77 191.5,70.38 191.5,71.46 192.67,72.63 192.67,78.83 192.82,78.98 192.82,88.7 193.83,89.72 193.83,104.91 193.16,105.59 193.16,107.88 189.52,111.52 189.52,152.16 188.81,152.87 188.81,166.52 187.96,167.37 v1(187.96,167.78)
  IN4 w0.381: v1(161.8,65.27) 161.66,65.27 161.37,64.98 158.38,64.98 v1(157.95,65.41)
  BOTTOM w0.381: v1(208.28,41.85) 208.28,41.69 207.73,41.14 206.67,41.14 206.12,41.69 206.12,44.34 206.85,45.06 v1(206.85,46) ; 180.57,76.99 181.33,77.74 181.33,78.87 182.1,79.64 188.42,79.64 191,77.06 191,72.75 191.55,72.2 191.55,71.66 191.39,71.5 191.39,70.3 190.89,69.79 v1(190.89,68.62) 191.74,68.62 193.61,66.76 193.61,64.8 194.69,63.71 194.69,60.88 194.31,60.5 193.61,60.5 193.48,60.62 190.96,60.62 190.46,60.12 190.46,58.87 190.84,58.49 R1027.2 190.9,56.68 v1(191.16,56.41) ; 180.57,76.99 180.19,77.38 179.01,77.38 178.24,76.62 v1(178.23,76.62) 178.23,78.5 177.4,79.34 176.26,79.34 v1(175.4,78.47) ; 180.57,76.99 v1(180.57,76.6) ; v1(161.8,65.27) 162.25,65.72 162.25,66.5 162.61,66.86 v1(162.61,67.4) 162.61,67.95 160.1,70.46 160.1,70.98 v1(160.06,71.01)
+3V_RTC: length 56.2
  TOP w0.508: v1(229.48,56.29) 229.48,56.29 229.99,55.78 232.28,55.78 233.13,54.93 233.82,54.24 233.82,52.15 234.15,51.82 v1(234.15,51.5) 232.39,49.74 220.22,49.74 218.29,51.67 216.97,51.67 214.45,49.15 213.48,49.15 v1(212.86,49.77)
  IN4 w0.508: v1(256.42,49.29) 256.42,49.27 255.66,48.5 241.58,48.5 241.43,48.36 237.3,48.36 v1(234.15,51.5)
+3V_S5: length 510.3
  TOP w0.508: v1(217.37,191.77) 214.78,191.77 211.15,188.14 211.15,185.55 210.47,184.87 v1(210.11,184.87) ; 219.51,56.07 221.9,56.07 223.63,54.35 225.44,54.35 v1(225.78,54.01) ; v1(187.48,54.8) 187.48,54.27 187.68,54.07 187.68,50.26 189.44,48.5 ; R319.1 180.99,78.71 180.39,79.31 178.66,79.31 R318.2 177.83,79.76 172,79.76 171.55,80.21 168.85,80.21 166.89,78.26 164.85,78.26 163.9,77.31 163.59,77.31 162.84,76.56 160.18,76.56 v1(159.42,75.8) ; v1(86.31,62.59) 84.6,64.3 74.37,64.3 70.65,68.02 67.96,68.02 67.32,67.38 PR271.1 ; v1(157.38,200.34) 157.18,200.14 148.71,200.14 148.42,199.86 146.16,199.86 145.55,200.47 142.5,200.47 140.79,202.18 140.79,204.47 140.78,204.47 ; v1(241.56,53.9) 242.52,52.94 244.07,52.94 246.22,50.8 246.22,46.28 v1(246.01,46.07)
  IN1 w0.508: v1(187.48,54.8) 186.41,53.73 179.38,53.73 178.99,53.34 173.8,53.34 173.02,52.56 v1(171.44,52.56) ; v1(234.15,209.97) 233.12,208.94 233.12,207.15 234.75,205.53 234.75,199.81 233.34,198.4 233.34,194.73 232.9,194.29 232.9,191.91 v1(232.13,191.15) 231.65,190.66 223.96,190.66 223.32,191.3 219.46,191.3 219.28,191.12 218.02,191.12 v1(217.37,191.77) ; v1(290.42,123.59) 287.88,121.05 287.88,118.49 290.45,115.92 290.45,112.23 290.76,111.92 290.76,111.21 293.72,108.26 295.34,108.26 297.69,105.91 297.69,103.6 297.05,102.96 v1(297.05,102.56) 297.24,102.38 297.77,102.38 298.28,101.87 298.28,101.16 301.93,97.5 v1(302.95,97.5)
  IN2 w0.508: v1(212.22,51.73) 212.85,51.1 214.45,51.1 v1(214.84,50.71) ; v1(264.09,190.91) 263.39,190.21 232.64,190.21 232.13,190.72 v1(232.13,191.15) ; v1(278.82,180.06) 283.06,180.06 284.23,178.89 285.57,178.89 286.61,177.84 286.61,155.15 282.82,151.36 282.82,143.58 285.25,141.16 285.87,141.16 287.12,139.91 287.12,136.45 282.61,131.94 282.61,125.14 284.29,123.46 287.45,123.46 288.08,122.83 289.66,122.83 v1(290.42,123.59)
  IN3 w0.508: v1(227.03,67.93) 227.62,67.34 228.8,67.34 229.35,67.89 229.35,69.04 228.56,69.82 228.56,70.59 v1(228.82,70.85) ; v1(240.76,37.1) 241.04,37.38 242.4,37.38 242.92,36.85 v1(242.92,36.36) 243.74,36.36 244.4,37.02 246.59,37.02 v1(246.64,37.07) ; v1(264.09,190.91) 264.09,186.99 265.82,185.26 267.35,185.26 268.23,184.38 269.37,184.38 270.14,185.14 273.74,185.14 v1(278.82,180.06) ; 99.54,86.43 99.54,86.43 100.84,87.73 100.84,93.18 106.96,99.3 106.96,101.23 116.77,111.04 116.77,115.97 v1(113.86,118.87) 113.86,119.2 118.45,123.79 118.45,143.71 120.39,145.65 121.76,145.65 v1(121.77,145.65) ; v1(157.38,200.34) 157.1,200.63 157.1,204.43 159.67,207 159.67,207.98 v1(159.48,208.17)
  IN4 w0.508: v1(157.38,200.34) 158.88,200.34 159.79,199.43 164.06,199.43 164.62,199.99 169.43,199.99 170.18,200.74 172.85,200.74 176.11,204 194.24,204 195.18,204.94 198.76,204.94 200.05,203.65 211.18,203.65 216.82,198.01 216.82,192.32 v1(217.37,191.77) ; v1(246.01,46.07) 245.44,45.51 245.44,40.32 246.64,39.13 v1(246.64,37.07)
  BOTTOM w0.508: PR642.1 v1(246.01,46.07) ; R742.1 v1(210.11,184.87) ; v1(202.31,39.08) 202.31,39.26 203.83,40.77 205.75,40.77 207.22,39.3 v1(207.22,39.03)
  vias: v1(48.59,95.29) v1(49.25,95.29) v1(77.21,85.1) v1(77.23,84.29) v1(86.82,85.54) v1(87.48,85.56) v1(155.75,71.12) v1(160.84,67.25) v1(201.3,86.86) v1(201.35,86.2) v1(201.91,86.55) v1(202.16,85.92) v1(203.37,48.34) v1(217.85,51.03) v1(222.11,212.27) v1(222.11,211.6) v1(225.97,212.25) v1(230.34,215.62) v1(247.55,58.03) v1(259.3,62.08) v1(269.07,73.5) v1(269.45,71.16) v1(269.67,73.72) v1(269.71,72.28) v1(270.36,73.7) v1(270.36,72.3) v1(303.61,97.5) v3(145.66,78.35) v3(145.68,77.57) v3(146.42,78.35) v3(146.44,77.57) v3(147.21,78.35) v3(147.23,77.57) v3(148.02,78.35) v3(148.04,77.57)
+3V_SSD1:
  vias: v1(99.35,79.78) v1(99.36,79.13) v1(100.04,79.78) v1(100.05,79.13) v1(100.72,79.78) v1(100.73,79.13) v1(101.96,77.08) v1(102.6,91.39) v1(102.61,90.72) v1(103.28,91.39) v1(103.31,90.71) v1(103.98,91.38) v1(104.03,90.7)
+3V_SSD2: length 2.4
  TOP w0.508: v1(99.92,54.16) 100.39,53.69 C517.2
  vias: v1(96.6,68.01) v1(98.5,67.88) v1(98.53,68.59) v1(99.24,68.59) v1(99.22,67.91) v1(99.9,68.57) v1(99.9,67.91)
+3V_SUS: length 390.3
  TOP w0.203: R396.2 318.9,71.98 v1(318.96,71.93) ; R395.2 319.84,72.83 320.05,73.03 v1(320.32,73.03)
  TOP w0.305: Q40.2 Q40.5 320.38,74.1 320.6,73.88 320.6,73.42 320.32,73.14 v1(320.32,73.03)
  TOP w0.508: v1(280.13,66.44) 280.11,66.42 280.11,63.59 280.9,62.8 280.9,62.08 283.37,59.62 v1(284.22,59.62)
  IN1 w0.508: v1(183.68,50.98) 184.15,50.51 184.15,48.75 183.33,47.93 183.33,40.71 185.24,38.8 192.62,38.8 193.95,40.14 199.85,40.14 200.3,39.69 210.01,39.69 210.91,38.79 219.41,38.79 221.31,40.68 224.64,40.68 228.15,37.17 239.3,37.17 240.08,37.96 243.56,37.96 244.53,37 245.04,37 245.72,36.31 247.93,36.31 248.39,36.77 255.35,36.77 258.85,40.27 258.85,44.64 260.52,46.3 266.64,46.3 271.96,51.62 283.06,51.62 285.67,54.24 285.67,58.9 284.95,59.62 v1(284.22,59.62)
  IN2 w0.508: v1(305.13,96.18) 305.13,96.42 306.11,97.4 308.53,97.4 311.92,94.01 315.42,94.01 315.61,93.82 316.59,93.82 316.89,94.12 317.99,94.12 318.62,93.49 318.62,92.85 318.19,92.42 318.19,90.31 319.4,89.1 319.4,76.81 318.75,76.16 318.75,74.61 v1(320.32,73.03)
  IN3 w0.508: 56.75,58.69 57.84,59.78 57.84,60.17 59.72,62.05 60.82,62.05 62.14,63.37 62.14,63.84 64.47,66.17 90.8,66.17 91.21,66.58 108.58,66.58 109.1,67.1 122.32,67.1 124.03,68.81 129.43,68.81 130.18,69.57 130.18,69.93 131.35,71.1 138.63,71.1 140.14,72.61 150.17,72.61 150.42,72.86 152.93,72.86 153.01,72.78 154.99,72.78 156.17,71.6 156.89,71.6 158.22,72.94 163.79,72.94 164.21,72.51 166.6,72.51 166.68,72.59 179.81,72.59 180.12,72.28 181.5,72.28 182.43,73.22 v1(182.43,73.34) ; v1(305.13,96.18) 301.9,96.18 300.63,94.91 300.63,92.51 297.87,89.75 297.87,87.09 297.14,86.36 296.25,86.36 295.91,86.02 294.41,86.02 292.3,83.91 291.47,83.91 290.15,82.59 290.15,81.19 284.74,75.78 284.36,75.78 282.96,74.39 282.96,72.27 282.09,71.4 281.6,71.4 279.65,69.46 279.65,66.92 v1(280.13,66.44)
  BOTTOM w0.508: v1(320.32,73.03) 320.07,73.03 v1(318.96,71.93) ; v1(182.43,73.34) 182.43,73.26 182.49,73.2 182.49,71.76 183.53,70.72 183.53,63.17 183.66,63.03 183.66,58.82 184.07,58.42 184.07,55.72 184.31,55.47 184.31,51.7 183.68,51.07 v1(183.68,50.98)
  vias: v1(25.43,68.57) v1(25.71,67.96) v1(55.71,57.87) v1(56.36,57.87) v1(57.15,57.47)
+3V_TCSS:
  vias: v1(202.94,185.43) v1(207.85,184.29)
+3V_THM: length 1.5
  BOTTOM w0.14: v1(257.52,212.23) 257.52,212 257.4,211.89 Q75.5 257.4,210.75 R704.1
  vias: v1(261.11,217.59) v1(261.77,217.6)
+3V_THM2: length 230.9
  TOP w0.508: R13.1 264.81,216.94 265.53,217.67 266.65,217.67 267.26,218.28 279.3,218.28 280.36,217.22 v1(280.36,216.51)
  IN2 w0.508: v1(212.13,106.24) 212.13,107.72 211.2,108.65 211.2,114.47 214.79,118.07 221.92,118.07 227.37,112.62 248.96,112.62 249.44,113.1 250.28,113.1 250.97,112.41 275.2,112.41 278.14,115.35 288.02,115.35 289.07,116.4 289.07,117.37 289.99,118.29 289.99,121.03 288.99,122.03 287.75,122.03 287.12,122.66 283.96,122.66 281.81,124.81 281.81,132.27 286.15,136.61 286.15,138.56 281.95,142.76 281.95,151.61 284.92,154.59 284.92,160.22 284.27,160.87 v1(284.27,163.94) ; v1(280.36,216.51) 279.35,216.51 278.92,216.07 277.32,216.07 276.81,215.57 276.81,212.44 279.32,209.93 281.57,209.93 v1(282.87,208.62)
  IN4 w0.508: v1(284.27,163.94) 286,165.68 286,169.1 285.02,170.08 285.02,171.91 286,172.89 286,199.08 284.77,200.32 284.77,205.96 283.91,206.82 283.91,207.54 282.87,208.57 v1(282.87,208.62)
+3V_U3: length 5.2
  TOP w0.178: U24.18 16.24,62.9 v1(16.08,63.06) R497.1 ; U24.1 21.01,66.67 21.26,66.92 v1(21.62,66.92)
  TOP w0.381: R494.1 24.71,63.11 v1(24.74,63.08) ; v1(13.55,64.94) R486.2 ; R462.2 v1(13.84,66.84)
  vias: v1(22.89,67.12) v1(24.88,66.66)
+3VPCU: length 766.1
  TOP w0.203: PR341.1 37.04,39.24 36.52,38.72 36.52,38.21 35.85,37.54 v1(35.11,37.54) 35.17,37.6 35.17,38.95 35.45,39.23 PR342.1 ; v1(27.94,41.93) 27.95,41.93 PR330.2 28.76,41.93 28.9,41.79 28.9,41.54 29.21,41.23 PR336.2
  TOP w0.254: PR182.1 272.18,81.37 271.85,81.04 v1(271.3,81.04)
  TOP w0.508: PR273.1 157.15,63.88 157.66,63.37 v1(157.66,63.05) ; v1(32.54,42.01) 32.08,42.47 32.08,43.02 31.81,43.28 PQ37.1 ; R578.2 251.21,57.3 251.91,58.01 v1(252.81,58.01) ; v1(113.54,206.55) 113.6,206.48 121.83,206.48 122.09,206.23 122.93,206.23 123.18,206.48 123.61,206.48 124.28,207.15 v1(125.29,207.15) ; v1(78.25,50.35) 76.03,50.35 73.01,47.32 v1(72.51,47.32) 72.51,45.54 72.38,45.41 ; v1(139.15,212.61) 139.15,211.91 140.16,210.89 140.16,210.7 141.1,209.77 ; PQ29.3 v1(55.94,55.58)
  IN1 w0.508: v1(159.08,201.77) 159.49,201.77 160.71,200.55 160.71,199.84 161.12,199.43 161.12,198.43 164.89,194.66 164.89,186.36 165.22,186.02 165.22,180.44 166.63,179.03 166.63,176.4 166.9,176.13 166.9,176.06 167.55,175.41 167.55,173.92 169.66,171.81 184.52,171.81 186.85,169.48 186.85,168.03 190.27,164.6 190.27,160.08 192.01,158.34 194.43,158.34 194.97,157.8 194.97,152.26 195.53,151.7 196.21,151.7 196.95,152.44 196.95,153.51 197.49,154.05 197.49,156.99 198.18,157.68 198.18,164.99 198,165.18 198,167.32 201.51,170.83 202.56,170.83 205.37,173.64 205.37,176.18 206.84,177.65 209.62,177.65 212.03,180.06 212.03,181.53 211.1,182.46 210.4,182.46 209.23,183.63 209.23,185.15 209.74,185.66 v1(209.93,185.66) 210.11,185.48 215.53,185.48 216.04,185.99 219.36,185.99 v1(219.86,186.5) 220.27,186.09 221.38,186.09 221.9,185.57 254.07,185.57 255.94,187.44 267.8,187.44 267.93,187.3 269.17,187.3 270.87,189 274.16,189 275.21,190.05 275.21,192.5 274.81,192.91 274.81,193.77 276.37,195.34 276.37,196.97 272.42,200.91 269.74,200.91 v1(268.89,200.06) ; v1(72.51,47.32) 69.49,47.32 67.63,49.18 64.66,49.18 v1(62.68,51.17) 62.62,51.1 61.05,51.1 58.91,53.25 50.33,53.25 49.99,52.9 49.46,52.9 47.11,50.55 43.26,50.55 42.02,49.31 42.02,47.57 40.02,45.56 36.96,45.56 35.07,43.67 34.58,43.67 32.92,42.01 v1(32.54,42.01) 32.4,42.01 31.8,41.41 31.8,39.47 33.73,37.54 v1(35.11,37.54) 35.73,36.92 38.63,36.92 40.32,38.61 v1(40.32,39.2) ; v1(19.48,77) 19.48,77.23 22.33,80.07 22.33,85.66 22.63,85.97 22.63,90.74 21.47,91.91 v1(21.47,93.56) ; v1(76.73,87.29) 78.13,88.69 81.79,88.69 82.61,89.51 82.61,92.1 86.77,96.26 91.07,96.26 94.5,99.7 101.79,99.7 107.92,105.82 107.92,106.79 109.12,107.99 109.12,110.75 111.53,113.16 111.53,126.04 115.39,129.9 115.39,134.67 114.93,135.14 114.93,137.28 118.52,140.88 118.52,143.7 119.44,144.62 119.44,154.39 114.97,158.86 114.97,160 116.47,161.5 116.47,167.59 115.96,168.1 v1(115.42,168.1)
  IN2 w0.508: v3(266.81,69.09) 267.1,68.8 268.7,68.8 269.31,69.42 269.31,70.08 268.79,70.6 267.91,70.6 267.75,70.76 267.25,70.76 266.75,71.26 266.75,72.04 269.25,74.54 271.21,74.54 271.72,75.05 271.72,75.76 271.47,76.01 271.47,80.87 v1(271.3,81.04) ; v1(159.08,201.77) 159.08,202.05 155.2,205.93 150.35,205.93 149.84,206.44 149.84,209.08 150.16,209.41 150.16,211.75 147.91,214.01 141.85,214.01 140.45,212.61 v1(139.15,212.61) 139.15,213.08 137.53,214.69 133.62,214.69 132.32,216 127.52,216 126.37,214.84 126.37,208.23 v1(125.29,207.15)
  IN3 w0.508: v1(16.7,93.53) 17.84,94.68 18.88,94.68 19.99,93.56 v1(21.47,93.56) ; v1(32.54,42.01) 28.02,42.01 v1(27.94,41.93) 27.92,41.93 27.64,42.21 20.01,42.21 19.38,42.84 19.38,47.39 21.01,49.02 21.01,52.25 19.18,54.09 19.18,57.75 18.57,58.36 17.88,58.36 17.43,58.81 17.43,59.53 18.02,60.12 18.02,61.11 17.56,61.57 15.21,61.57 13.62,63.17 13.05,63.17 12.41,63.81 12.41,69.54 15.09,72.22 v1(15.09,76.08) 15.42,76.08 16.02,75.48 17.96,75.48 v1(19.48,77) ; v1(111.28,190.54) 111.42,190.54 111.92,191.04 111.92,194.35 115.08,197.51 115.08,200.74 113.74,202.07 113.74,206.34 v1(113.54,206.55)
  IN4 w0.508: v1(48.54,96.86) 43.96,101.44 32.9,101.44 29.71,98.25 19.2,98.25 17.35,96.41 17.35,94.19 v1(16.7,93.53) ; v1(315.3,98.78) 314.75,98.22 310.87,98.22 310.3,98.79 305.83,98.79 305.67,98.96 301.66,98.96 300.14,97.43 300.14,95.97 299.63,95.47 297.44,95.47 293.6,91.63 293.6,85.48 292.61,84.49 284.79,84.49 284.1,85.18 283.21,85.18 282.27,86.12 280.55,86.12 280.54,86.13 278.65,86.13 277.79,85.27 274.8,85.27 271.38,81.84 271.38,81.12 v1(271.3,81.04)
  BOTTOM w0.508: R739.1 209.58,186.02 v1(209.93,185.66) ; CN4.3 314.93,98.41 v1(315.3,98.78) ; v1(40.32,39.2) 40.63,39.2 40.74,39.3 PR655.2 ; v1(233.56,55.91) 233.73,55.74 233.73,53 234.8,51.94 234.8,51.12 234.63,50.96 234.63,48.14 235.82,46.95 R1157.1 ; v1(55.94,55.58) 58.23,55.58 58.56,55.24 59.13,55.24 62.68,51.69 v1(62.68,51.17) ; v1(115.42,168.1) 112.49,168.1 109.2,171.39 109.2,189.88 109.72,190.4 111.14,190.4 v1(111.28,190.54) ; v1(165.82,76.62) 165.2,77.23 163.51,77.23 162.94,76.66 160.55,76.66 160.23,76.98 158.95,76.98 158.33,76.37 158.33,75.53 158.84,75.02 158.84,73.68 157.71,72.55 157.71,70.58 158.22,70.07 158.22,66.98 157.22,65.97 157.22,63.49 v1(157.66,63.05) ; v1(32.54,42.01) 32.42,42.14 PQ70.1
  vias: v1(49.2,96.86) v1(77.1,86.45) v1(78.99,50.34) v1(79.71,50.34) v1(145.16,59.78) v1(145.93,59.78) v1(146.69,59.78) v1(149.2,60.12) v1(259.14,60.37) v3(138.21,49.03) v3(138.23,49.79) v3(138.42,48.24) v3(138.81,47.58) v3(138.8,46.02) v3(138.85,46.78) v3(138.99,49.79) v3(139.02,49.01) v3(139.23,48.21) v3(139.6,47.53) v3(139.57,46.01) v3(139.62,46.78) v3(139.75,49.79) v3(139.84,49) v3(140,48.19) v3(140.52,49.82) v3(140.74,49.1) v3(141.28,49.82) v3(141.5,49.1) v3(142.04,49.82) v3(142.26,49.1) v3(142.85,49.83) v3(143.1,49.09) v3(143.72,49.84) v3(143.85,49.08) v3(266.03,69.11)
+3VPCU_EC: length 70.8
  TOP w0.203: U23.114 175.11,74.99 C375.1 175.57,74.64 v1(175.57,74.45) ; 172.14,74.02 172.14,73.91 172.31,73.74 U23.121 ; U23.26 167.06,61.3 166.24,60.47 C492.1 C491.1 164.88,60.47 164.56,60.15 164.56,59.78 v1(164.81,59.54) ; U23.50 176.31,56.19 176.12,56 v1(176.12,55.82) 176.12,55.79 176.41,55.5 C516.1 ; U23.92 184.77,69.7 184.97,69.89 185.83,69.89 C425.1
  TOP w0.305: L14.1 188,63.26 189.06,63.26 v1(189.18,63.39) ; v1(168.51,76.62) 168.51,76.45 L7.2 ; v1(170.82,74.45) 171.42,75.05 C374.1 171.79,75.05 172.14,74.7 172.14,74.02
  IN3 w0.305: v1(175.57,74.45) 175.57,74.72 175.87,75.02 180.73,75.02 181.23,74.52 183.56,74.52 184.07,74.01 184.21,74.01 184.84,73.38 186.94,73.38 187.74,72.57 187.74,69.7 v1(187.65,69.61)
  BOTTOM w0.305: v1(187.65,69.61) 187.56,69.7 187.13,69.7 186.75,69.32 186.75,68.18 187.39,67.53 187.39,64.17 188.3,63.25 189.05,63.25 v1(189.18,63.39) ; v1(175.57,74.45) 174.76,73.64 171.13,73.64 170.82,73.94 v1(170.82,74.45) 170.59,74.45 168.51,76.53 v1(168.51,76.62) 168.15,76.26 168.15,75.5 v1(167.8,75.15) 167.29,74.64 167.29,62.62 164.81,60.14 v1(164.81,59.54)
+3VPCU_ECPLL: length 3
  TOP w0.203: 169.91,74 U23.127
  TOP w0.305: 169.91,74 169.91,75.05 C373.2 169.52,75.05 169.43,75.14 L7.1
+3VSPI: length 2.5
  TOP w0.508: R580.1 R579.1 246.82,55.76 v1(246.31,56.27)
+5V: length 94.2
  TOP w0.254: R273.1 284.99,81.5 284.31,80.82 v1(284.31,80.3)
  TOP w0.508: R629.1 196.26,44.41 196.26,42.8 v1(196.34,42.72) ; v1(107.12,106.64) 107.25,106.64 107.71,106.19 107.71,99.1 106.95,98.34 v1(106.95,84.97)
  IN3 w0.508: v1(248.9,51.86) 248.9,51.54 248.39,51.03 244.04,51.03 241.7,48.69 240.31,48.69 239.79,48.17 238,48.17 237.31,47.47 225.43,47.47 221.71,43.75 219.59,43.75 219.45,43.62 214.24,43.62 212.98,42.36 212.12,42.36 211.61,41.85 211.13,41.85 210.22,40.93 198.33,40.93 196.54,42.72 v1(196.34,42.72)
  IN4 w0.086: 118.73,84.87 121.47,82.14 125.49,82.14
  BOTTOM w0.254: R818.1 107.18,107.63 107.63,108.08 R819.1
  vias: v1(19.29,41.26) v1(19.29,40.61) v1(19.95,41.29) v1(19.95,40.64) v1(20.63,41.29) v1(20.64,40.64) v1(56.52,66.82) v1(56.54,66.13) v1(57.18,66.82) v1(57.2,66.16) v1(57.84,66.82) v1(57.89,66.16) v1(89.74,77.22) v1(89.77,76.51) v1(90.4,77.22) v1(90.46,76.51) v1(91.1,77.22) v1(91.11,76.53) v1(283.45,41.75) v1(283.41,41.07) v1(283.96,40.6) v1(284.1,41.29) v1(293.91,81.29) v1(302.16,76.04) v1(302.16,75.37) v1(302.19,74.68) v1(302.89,76.01) v1(302.89,75.33) v1(302.9,74.68) v1(307.37,62.56) v1(309.64,63.65) v1(313.77,77.79) v1(313.77,77.13) v1(313.77,76.47) v1(314.43,77.79) v1(314.43,77.13) v1(314.43,76.47) v1(315.09,77.15) v1(315.09,76.47) v3(131.37,78.42) v3(132.13,78.45) v3(132.92,78.45) v3(133.73,78.45) v3(134.52,78.45) v3(135.36,78.47) v3(243.72,68.32) v3(243.72,67.53) v3(244.29,68.85) v3(244.47,68.09) v3(244.48,67.27)
+5V_HDD:
  vias: v1(281.99,45.78) v1(282.02,45.07) v1(282.64,45.77) v1(282.66,45.06) v1(283.31,45.76) v1(283.36,45.07) v1(283.66,43.75) v1(283.96,45.75) v1(284.01,45.06)
+5V_HDMIC: length 11.4
  IN4 w0.508: CN23.18 13.31,37 14.23,36.08 14.23,28.33 13.77,27.88 v1(13.77,26.58)
+5V_KB: length 5.8
  TOP w0.508: v1(186.75,52.45) 186.7,52.45 185.98,51.73 185.98,50.06 185.16,49.25
  BOTTOM w0.508: v1(186.75,52.45) 186.75,51.8 187.5,51.05 U54.5
  vias: v1(181.29,44.47) v1(181.33,43.73) v1(182.07,44.44) v1(182.06,43.78) v1(184.2,49.48)
+5V_LED: length 222.6
  TOP w0.508: 248.31,211.3 248.31,211.3 248.31,211 248.67,210.64 Q125.1 252.35,211.32 253.06,212.03 ; v1(254.31,214.98) 254.31,214.66 254.24,214.6 254.24,212.98
  IN1 w0.508: v1(174.8,201.81) 174.6,202 174.6,202.63 175.42,203.44 194.29,203.44 196.04,205.19 200.92,205.19 201.37,204.74 221.4,204.74 221.87,205.22 221.87,210.4 221.26,211.01 221.26,213.45 v1(222.08,214.26) ; v1(143.56,213.32) 140.7,210.46 140.7,203.65 141.28,203.07 141.76,203.07 142.04,202.79 142.04,201.13 142.55,200.62 144.01,200.62 144.41,201.02 v1(144.41,201.97)
  IN2 w0.508: v1(268.91,192.11) 269.48,192.11 270.7,193.34 270.7,201.88 270.03,202.55 270.03,202.88 264.54,208.37 263.91,208.37 261.05,211.23 261.05,211.89 259.42,213.51 257.68,213.51 255.84,215.35 254.68,215.35 v1(254.31,214.98) ; v1(144.41,201.97) 146.14,200.23 151.28,200.23 155.83,195.67 158.41,195.67 160.7,197.96 164.02,197.96 164.77,198.72 166.19,198.72 166.33,198.58 167.42,198.58 167.99,199.16 171.39,199.16 174.12,201.89 174.71,201.89 v1(174.8,201.81)
  IN3 w0.508: v1(222.08,214.26) 221.87,214.26 221.36,214.77 221.36,216.5 221.16,216.7 v1(221.16,217.84) 222.05,217.84 222.49,218.28 226.9,218.28 227.4,217.78 v1(227.4,216.91) 227.4,216.45 227.91,215.94 228.6,215.94 229.03,216.37 230.51,216.37 231.27,215.61 233.05,215.61 234.7,213.96 234.7,212.56 235.21,212.05 235.51,211.32 237.82,209 244.05,209 246.44,211.4 246.44,213.78 247.27,214.61 249.62,214.61 249.7,214.54 253.86,214.54 v1(254.31,214.98)
  BOTTOM w0.508: v1(172.75,217.44) 173.76,217.44 174.27,216.93 174.27,214.2 173.92,213.85 172.03,213.85 171.31,213.13 171.31,205.4 173.19,203.52 173.19,203.42 v1(174.8,201.81)
+5V_LIGHT:
  vias: v1(218.42,42.35) v1(219.07,42.36)
+5V_MCU: length 18.2
  IN1 w0.508: v1(144.14,207.33) 144.14,207.33 144.88,208.07 152.11,208.07 154.99,205.18 v1(154.99,204.81) 152.66,204.81 150.43,202.59 v1(150.43,202.57)
  vias: v1(142.8,205.33) v1(142.93,206.03)
+5V_PVDD: length 13.3
  IN1 w0.508: v1(307.33,64.25) 307.33,64.43 307.84,64.94 308.49,64.94 309.12,65.57 309.12,68.39 312.42,71.69 312.42,74.5 v1(312.8,74.89)
  vias: v1(310.92,75.95)
+5V_S5: length 468.7
  TOP w0.102: 284.26,85.71 284.2,85.65
  TOP w0.508: v1(113.51,49.52) 112.4,50.63 112.4,57.7 112.84,58.14 112.84,60.54 112.6,60.78 112.6,62.52 118.26,68.18 118.26,71.71 112.37,77.6 v1(112.37,80.96) ; v1(216.97,91.3) 216.97,90.82 219.1,88.7 221.68,88.7 222.53,87.85 226.09,87.85 226.62,88.38 226.62,91.23 v1(226.7,91.3) ; v1(285.63,92.37) 285.63,91.4 v1(286.01,91.02) 287,90.03 287,87.42 287.37,87.05 287.37,86.33 286.86,85.83 285.44,85.83 285.44,85.83 284.38,85.83 284.26,85.71
  IN1 w0.508: v1(157.77,196.28) 156.76,195.27 155.42,195.27 154.21,196.48 148.38,196.48 v1(148.14,196.24) 147.05,195.15 145.48,195.15 141.21,199.42 v1(140.23,199.42) 140.12,199.31 140.12,197.94 v1(138.48,196.3) 137.39,195.21 136.18,195.21 131.84,199.55 v1(130.54,199.55) 130.19,199.2 130.19,197.21 128.21,195.22 126.64,195.22 122.5,199.36 v1(121.14,199.36) 120.78,199.01 120.78,197.81 v1(119.22,196.24) 119.22,195.95 118.3,195.03 115.9,195.03 ; v1(261.27,72.71) 259.03,72.71 v1(259.01,72.73) 258.64,73.09 v1(257.75,73.09) 256.78,73.09 255.52,71.83 254.06,71.83 v1(253.66,72.24)
  IN2 w0.508: v1(149.06,199.3) 149.06,197.16 v1(148.14,196.24) ; v1(157.77,196.28) 156.89,197.16 156.89,198.58 157.4,199.09 158.09,199.09 158.52,198.66 159.23,198.66 159.76,199.18 159.76,200 v1(160.05,200.29) ; v1(160.05,200.29) 160.91,201.16 161.12,201.16 162.33,202.38 162.33,203.05 v1(162.7,203.42) 162.97,203.68 166.04,203.68 166.75,204.4 166.75,204.66 167.41,205.32 167.41,207.13 168.1,207.81 168.1,210.94 167.44,211.6 v1(167.44,212.69) ; v1(160.05,200.29) 161.04,199.3 164.14,199.3 164.94,200.11 171.47,200.11 173.89,202.53 174.63,202.53 174.98,202.88 176.36,202.88 176.56,203.09 185.6,203.09 186.3,203.78 188.44,203.78 188.67,203.55 193.55,203.55 195.33,205.33 195.33,206.09 195.84,206.6 198.09,206.6 199.47,205.21 200.4,205.21 201.94,203.68 213.1,203.68 213.67,204.26 219.09,204.26 219.67,203.68 225.48,203.68 226.57,204.77 226.57,206.9 227.08,207.4 230.18,207.4 230.64,206.94 230.64,205.47 231.26,204.85 231.69,204.85 232.97,206.13 233.56,206.13 234.37,205.32 235.69,205.32 236.66,206.29 242.52,206.29 242.98,206.75 252,206.75 252.48,207.23 v1(252.48,207.48)
  IN3 w0.508: v1(250.64,50.22) 249.85,50.22 248.81,49.18 243.91,49.18 241.21,46.47 240.44,46.47 240.04,46.87 238.43,46.87 237.81,46.25 229.3,46.25 228.49,45.44 227.26,45.44 226.64,46.06 225.74,46.06 222.21,42.53 v1(221.82,42.53) ; v1(260.46,214.05) 259.35,214.05 258.84,213.54 258.84,211.89 258.33,211.38 256.16,211.38 255.59,210.81 254.89,210.81 253.62,209.54 253.62,208.62 v1(252.48,207.48) ; 252.35,87.77 252.48,87.77 v1(256.04,91.33) 257.14,90.22 257.14,89.49 257.91,88.71 263.07,88.71 265.61,91.25 v1(265.81,91.25) 265.81,90.41 265.69,90.29 265.69,89.09 266.09,88.69 273.15,88.69 274.2,89.73 274.2,91.17 275.38,92.36 v1(275.71,92.36) 275.72,92.34 275.72,89.4 276.23,88.89 281.84,88.89 285.32,92.37 v1(285.63,92.37) ; 252.35,87.77 251.39,88.74 248.08,88.74 247.58,89.24 247.58,90.54 246.84,91.28 v1(246.26,91.28) 243.69,88.71 238.51,88.71 237.9,89.32 237.9,90.03 236.68,91.25 v1(236.48,91.25) 233.99,88.76 228.73,88.76 228.22,89.27 228.22,89.78 v1(226.7,91.3) ; 252.35,87.77 252.35,81.8 252.86,81.29 253.06,81.29 253.4,80.96 v3(253.44,80.96)
  BOTTOM w0.102: PR550.1 285.63,91.89
  BOTTOM w0.254: PR552.1 217.43,90.65 217.51,90.73 PU31.4 ; PU32.4 227.3,90.73 227.21,90.65 PR553.1 ; PU30.4 286.51,90.99 285.75,91.74 PR550.1 ; PU34.4 246.93,90.73 246.85,90.65 PR555.1 ; PR554.1 236.97,90.65 237.05,90.73 PU33.4 ; PU29.4 276.69,90.99 275.93,91.74 PR551.1 ; PU36.4 266.46,90.73 266.38,90.65 PR557.1
  BOTTOM w0.508: 285.63,91.89 v1(285.63,92.37) 285.64,92.38 PC430.1 ; PR557.1 v1(265.81,91.25) PC447.1 ; PC446.1 v1(226.7,91.3) PR553.1 ; v1(253.66,72.24) 253.44,72.01 253.44,68.37 251.14,66.07 246.96,66.07 246.45,65.57 246.45,61.73 247.55,60.63 249.07,60.63 251.23,58.48 251.23,55.2 250.39,54.36 250.39,53.25 250.64,52.99 v1(250.64,50.22) ; PR551.1 275.72,92.34 v1(275.71,92.36) 275.73,92.38 PC429.1 ; PC400.1 203.87,104.06 204.83,103.1 204.83,100.27 203.93,99.37 203.93,97.63 205.52,96.04 210.7,96.04 211.24,95.5 211.58,95.5 215.05,92.03 PC443.1 216.97,91.98 v1(216.97,91.3) 216.92,91.25 PR552.1 ; PC444.1 v1(246.26,91.28) PR555.1 ; PR402.1 251.58,206.77 252.02,206.77 252.48,207.23 v1(252.48,207.48) ; PC448.1 v1(236.48,91.25) PR554.1 ; v1(114.24,216.54) 114.33,216.45 PR355.2
  vias: v1(102.14,114.62) v1(102.24,113.65) v1(102.72,114.21) v1(102.8,113.2) v1(103.33,113.78) v1(103.33,112.71) v1(109.38,196.73) v1(109.48,207.1) v1(109.48,206.34) v1(109.48,205.58) v1(110.24,207.86) v1(110.24,207.1) v1(110.24,206.34) v1(110.24,205.58) v1(111.71,200.27) v1(126.04,78.04) v1(126.06,77.38) v1(126.72,78.05) v1(126.72,77.38) v1(127.41,78.05) v1(127.41,77.38) v1(127.51,213.6) v1(137.8,210.53) v1(138.18,211.16) v1(138.18,209.89) v1(138.56,210.53) v1(138.94,211.16) v1(138.94,209.89) v1(139.32,210.53) v1(151.52,71.12) v1(180.04,55.87) v1(180.07,55.22) v1(180.72,55.37) v1(184.92,43.3) v1(185.04,42.63) v1(185.62,43.16) v1(220.5,42.51) v1(221.16,42.51)
+5V_S5_TYPEC:
  vias: v1(57.53,95.37) v1(57.53,94.6) v1(57.71,83.45) v1(57.71,82.69) v1(57.71,81.93) v1(58.27,96.53) v1(58.3,95.37) v1(58.3,94.6) v1(58.47,83.45) v1(58.47,82.69) v1(58.47,81.93) v1(59.06,95.37) v1(59.06,94.6) v3(52.12,76.54) v3(52.12,75.78) v3(53.01,76.54) v3(53.01,75.78) v3(55.66,76.71) v3(55.66,75.95) v3(56.55,76.71) v3(56.55,75.95) v3(59.24,76.49) v3(59.24,75.73) v3(60.12,76.49) v3(60.12,75.73) v3(62.66,56.68) v3(62.66,55.89) v3(62.66,55.1) v3(62.69,54.33) v3(63.35,57.24) v3(63.37,56.42) v3(63.37,55.43) v3(63.47,54.32)
+5V_S5_TYPEC_R:
  vias: v1(64.57,54.7) v1(72.38,69.33) v1(72.4,68.67) v1(73.04,69.33) v1(73.07,68.67) v1(73.7,69.34) v1(73.72,68.69) v1(74.37,69.35) v1(74.4,68.68) v3(52.3,74.51) v3(52.33,73.75) v3(53.06,74.51) v3(53.09,73.75) v3(57.79,73.24) v3(59.41,74.79) v3(59.41,73.98) v3(60.18,74.79) v3(60.18,73.98) v3(65.36,54.52) v3(66.27,55.31) v3(66.32,54.55) v3(67.08,54.95) v3(70.88,56.25) v3(70.88,55.47) v3(71.67,56.25) v3(71.67,55.47)
+5V_TP_LED:
  vias: v1(193.42,46.86) v1(194.07,46.87) v1(195.14,46.78)
+5VA:
  vias: v1(313.54,72.25) v1(313.75,72.89) v1(314.41,72.9)
+5VPCU: length 393
  TOP w0.203: v1(320.53,68.42) 320.36,68.42 320.12,68.17 R454.1
  TOP w0.508: 319,90.68 319,88.28 318.49,87.77 317.12,87.77 316.08,88.81 314.26,88.81 313.9,89.17 313.9,91 312.93,91.97 ; PR305.2 v1(70.67,50.17) ; 73.97,91.4 76.19,91.4 87.65,79.95 v1(87.65,78.72) ; v1(200.37,81.8) 199.28,81.8 TP182.1
  IN1 w0.508: v1(198.94,65.19) 198.94,63.43 197.32,61.81 197.32,60.88 197.83,60.38 199.06,60.38 199.57,59.87 199.57,59.32 199.21,58.96 196.71,58.96 196,58.24 195.38,58.24 194.87,57.74 194.87,56.17 195.13,55.91 195.13,54.43 194.32,53.62 194.32,51.95 196.08,50.19 v1(196.08,48.48)
  IN2 w0.508: v3(61.46,71.81) 62.59,72.94 63.1,72.94 69.65,79.5 86.87,79.5 v1(87.65,78.72) ; 269.04,201.9 269.97,200.97 269.97,193.46 269.46,192.95 268.68,192.95 268.2,192.47 268.2,188.48 267.36,187.64 267.13,187.64 266.62,187.14 266.62,186.23 265.98,185.59 265.49,185.59 262.68,188.41 248.71,188.41 248.61,188.3 230.82,188.3 230.78,188.26 223.21,188.26 222.72,187.78 221.03,187.78 219.99,188.82 210.01,188.82 207.93,186.74 207.93,186.11 206.96,185.13 v1(206.06,185.13) 206.06,181.47 207.88,179.65 207.88,177.44 209.25,176.08 v1(209.25,174.5) 207.35,172.6 204.93,172.6 201.43,169.1 199.85,169.1 198.04,167.29 198.04,164.37 197.46,163.79 196.83,163.79 196.31,163.28 196.31,156.77 195.44,155.9 195.44,151.34 194.04,149.94 194.04,130.46 199.6,124.91 204.04,124.91 204.38,124.57 206.62,124.57 208.27,122.91 208.27,121.14 210.73,118.68 222.18,118.68 227.29,113.56 242.95,113.56 243.64,114.26 244.25,114.26 245.12,113.39 248.4,113.39 249.08,114.07 250.5,114.07 251.18,113.39 257.17,113.39 257.54,113.02 274.95,113.02 278.57,116.64 285.02,116.64
  IN3 w0.508: v1(200.37,81.8) 201.54,80.64 201.54,78.65 200.72,77.83 200.72,76.82 199.33,75.43 199.33,74.24 199.84,73.72 199.84,72.77 199.29,72.21 199.29,71.49 199.59,71.18 199.59,68.64 199.82,68.41 199.82,67.54 198.94,66.66 v1(198.94,65.19)
  IN4 w0.508: v1(319.51,91.65) 318.87,91.02 318.87,87.21 319.68,86.41 319.68,82 318.31,80.63 317.78,80.63 317.27,80.13 317.27,79.18 318.54,77.92 319.15,77.92 320.11,76.96 320.11,74.56 319.71,74.15 319.71,72.27 320.28,71.7 320.28,68.66 v1(320.53,68.42)
  BOTTOM w0.508: v1(145.42,69.08) 145.06,69.44 143.9,69.44 142.38,67.92 v1(137.06,67.92)
  vias: v1(26.14,54.8) v1(26.15,54.1) v1(26.81,54.83) v1(26.86,54.16) v1(27.51,54.85) v1(27.54,54.12) v1(30.2,53.21) v1(30.17,52.55) v1(30.38,53.84) v1(30.75,54.37) v1(30.86,52.89) v1(30.97,53.54) v1(126.95,67.73) v1(127.61,67.73) v1(128.29,67.73) v1(128.98,67.73) v1(134.98,67.92) v1(135.71,67.93) v1(136.39,67.93) v1(208.56,39.02) v1(266.42,202.13) v1(267.11,202.12) v1(267.77,202.17) v1(268.42,202.05) v1(307.77,98.12) v1(308.42,98.13) v1(309.08,98.18) v1(309.27,97.56) v1(309.75,98.18) v1(309.93,97.55) v1(315.75,98.31) v1(316.18,97.8) v1(316.31,98.64) v1(316.6,97.28) v1(316.92,97.85) v1(317.05,98.51) v3(49.24,68.79) v3(49.24,68.03) v3(50.04,68.8) v3(50.04,68.03) v3(50.8,68.8) v3(50.8,68.03) v3(59.78,70.19) v3(60.35,70.73) v3(60.91,71.28) v3(62.24,53.14) v3(63,53.25) v3(63.2,52.49) v3(63.76,53.17) v3(63.76,51.95) v3(73.46,53.63) v3(73.56,54.42) v3(74.22,53.96) v3(170.36,49.82) v3(170.36,49.04) v3(170.36,48.27) v3(171.12,49.82) v3(171.12,49.04) v3(171.12,48.27) v3(171.88,49.82) v3(171.88,49.04) v3(171.88,48.27) v3(172.65,49.82) v3(172.65,49.04) v3(172.65,48.27) v3(173.41,49.82) v3(173.41,49.04) v3(173.41,48.27) v3(174.17,49.82) v3(174.17,49.04) v3(174.17,48.27) v3(174.93,49.82) v3(174.93,49.04) v3(174.93,48.27) v3(175.69,49.82) v3(175.75,48.98) v3(175.75,48.22) v3(176.73,49.6) v3(177.52,49.57) v3(178.38,49.6) v3(285.85,116.21) v3(286.56,116.56) v3(287.26,116.17) v3(300.59,110.17) v3(300.59,109.39) v3(301.37,110.17) v3(301.37,109.39)
+12V_FAN: length 284.5
  TOP w0.508: v1(138.4,212.47) 138.09,212.47 136.73,211.11 PU1.8 135.44,211.11 135.05,210.73 v1(135.05,210.09) 135.31,209.84 PC11.1 ; v1(111.33,161.81) 111.33,160.64 117.45,154.52 117.45,153.12 110.74,146.41 110.74,141.58 109.62,140.47 109.62,125.87 107.85,124.1 107.85,116.55 109.15,115.25 109.15,106.72 109.43,106.44 109.43,105.62 108.63,104.82 108.63,98.64 v1(108.16,98.17)
  IN1 w0.508: v1(144.81,212.18) 144.82,212.17 145,212.17 145.51,212.68 145.51,214.78 144.29,215.99 142.34,215.99 140.59,214.24 139.11,214.24 138.47,213.6 138.47,212.54 v1(138.4,212.47) ; v1(226.68,187.02) 226.68,187.05 226.15,187.58 217.84,187.58 217.64,187.78 213.33,187.78 212.27,186.72 207.59,186.72 205.67,188.65 203.15,188.65 198.93,184.43 197.05,184.43 193.64,181.02 193.64,177.61 188.44,172.42 169.91,172.42 168.16,174.17 168.16,177.26 169.1,178.19 169.1,179.84 168.22,180.72 168.22,184.38 168.69,184.85 168.69,187.8 168.07,188.42 168.07,189.84 167.26,190.64 167.26,193.37 162.23,198.41 162.23,200.34 161.12,201.46 160.71,201.46 159.8,202.38 158.58,202.38 v1(158.07,201.87)
  IN2 w0.508: v1(158.07,201.87) 157.42,201.22 155.74,201.22 151.85,205.12 149.94,205.12 149.02,206.03 149.02,209.28 148.72,209.59 148.72,210.3 146.85,212.17 144.82,212.17 v1(144.81,212.18)
  IN4 w0.508: v1(111.33,161.81) 110.65,161.81 109.66,162.79 109.66,195.41 110.46,196.21 110.46,201.52 112.37,203.43 120.56,203.43 123.52,206.39 125.93,206.39 127,207.46 127,208.6 128.4,210 134.96,210 v1(135.05,210.09)
  vias: v1(85.5,96.79) v1(107.9,97.55) v1(108.4,78.79) v1(108.41,78.12) v1(108.42,77.46) v1(161.14,77.31) v1(161.79,77.31) v1(162.44,77.31) v1(237.62,77.94) v1(240.73,77.92) v1(241.66,77.94) v1(268.86,85.69) v1(269.52,85.69) v1(270.21,85.71) v1(291.53,86.58) v1(291.9,86.04) v1(292.27,86.58) v3(93.46,97.43) v3(94.24,97.44) v3(95.02,97.46)
+12V_FAN1: length 1
  BOTTOM w0.508: 110.49,103.85 v1(111.51,103.85)
+12V_FAN2:
  vias: v1(288.84,81.39) v1(289.49,81.4)
+19V_VIN1:
  vias: v1(182.61,200.32) v3(176.43,201.56) v3(176.76,202.35) v3(176.79,200.88) v3(177.19,201.72) v3(177.14,200.22) v3(177.6,202.43) v3(177.55,200.88) v3(177.93,200.22) v3(178.06,201.66) v3(178.36,202.43) v3(178.31,200.88) v3(178.69,200.22) v3(178.87,201.66) v3(179.07,200.88) v3(179.12,202.43) v3(179.53,200.24) v3(179.73,201.66) v3(179.89,202.43) v3(179.96,200.88) v3(180.65,202.43) v3(181.41,202.43) v3(182.17,202.43) v3(182.93,202.43) v3(183.7,202.43) v3(184.46,202.43) v3(185.22,202.43)
+19V_VIN2: length 33.1
  TOP w0.381: PR84.2 234.81,206.31 234.81,204.01 233.9,203.1 v1(233.46,203.1) PR98.2 ; v1(231.25,206.35) 230.91,206.35 230.53,205.97 PR90.1
  IN1 w0.381: v1(233.46,203.1) 232.46,204.1 232.46,205.63 231.76,206.33 231.26,206.33 v1(231.25,206.35) 231.24,206.35 228.41,203.52 215.26,203.52 212.92,201.18 v3(210.24,201.18)
  vias: v1(212.81,198.32) v3(205.59,196.79) v3(205.59,196.03) v3(206.38,196.79) v3(206.38,196.03) v3(207.14,196.79) v3(207.14,196.03) v3(207.9,196.79) v3(207.9,196.03) v3(208.66,196.79) v3(208.66,196.03) v3(209.43,196.79) v3(209.43,196.03) v3(210.24,200.42) v3(210.29,199.51) v3(210.29,198.74) v3(210.26,197.8) v3(210.26,197.04) v3(210.26,196)
+A3VPCU: length 4.7
  TOP w0.203: 184.56,62.5 U23.74
  TOP w0.305: 184.56,62.5 184.6,62.45 185.64,62.45 185.91,62.73 C464.1 186.07,62.72 C465.2 187.29,62.72 187.57,62.44 L14.2
+V3.3DX_RT_TCP0:
  vias: v1(55.12,97.47)
+V3.3DX_RT_TCP1:
  vias: v1(48.03,79.67)
+VCC0P9_LC_TCP0: length 2.8
  TOP w0.203: U9.J3 v2(40.49,91.36)
  BOTTOM w0.14: v2(40.49,91.36) 40.98,91.36 41.08,91.46 C712.2 41.84,91.46 41.94,91.56 v1(42.78,91.56)
+VCC0P9_LC_TCP1: length 1.4
  TOP w0.203: v2(35.92,74.09) U16.J3
  BOTTOM w0.14: v2(35.92,74.09) 35.94,74.11 C750.2
+VCC0P9_LVR_TCP0: length 4.7
  TOP w0.203: U9.L6 U9.M6 39.1,93.26 v1(39.27,93.43)
  BOTTOM w0.14: C701.2 38.76,95.31 38.48,95.59 v1(38.48,96.48)
  BOTTOM w0.508: C701.2 C704.2 39.24,93.47 v1(39.27,93.43)
+VCC0P9_LVR_TCP1: length 2.9
  TOP w0.203: v1(34.7,76.16) 34.52,75.99 U16.M6 U16.L6
  BOTTOM w0.381: v1(34.7,76.16) 34.67,76.2 C744.2 C742.2
+VCC0V9_SVR_TCP0: length 6.5
  TOP w0.203: U9.G3 v2(40.49,90.71) ; U9.G6 U9.F6 38.53,90.05 v2(37.88,90.05) ; v2(40.49,89.4) 40.49,89.41 U9.E3 ; U9.E9 37.52,89.74 v2(37.2,89.42) ; v2(37.24,91.36) U9.G9
  BOTTOM w0.508: v2(40.49,89.4) 40.97,89.4 41.29,89.72 C722.2 ; v2(40.49,90.71) 40.61,90.59 C718.2 ; v2(37.24,91.36) 36.76,91.36 C710.1
  vias: v1(46.56,95.32) v1(46.57,94.68) v1(47.13,95.63) v1(47.22,94.71) v1(47.68,95.16)
+VCC0V9_SVR_TCP0_PHASE:
  vias: v1(42.55,93.18)
+VCC0V9_SVR_TCP1: length 6.2
  TOP w0.203: v2(35.92,72.13) 35.92,72.14 U16.E3 ; U16.G9 v2(32.67,74.09) ; v2(33.3,72.79) 33.97,72.79 U16.F6 U16.G6 ; v2(32.63,72.1) U16.E9 ; U16.G3 v2(35.92,73.44)
  BOTTOM w0.508: C754.2 36.58,72.38 36.33,72.13 v2(35.92,72.13) ; v2(35.92,73.44) 35.9,73.42 C752.2 ; C747.1 32.02,74.09 v2(32.67,74.09)
  vias: v1(41.98,77.95) v1(41.99,77.07) v1(42.47,77.53) v1(42.9,77.03) v1(42.93,78.02)
+VCC0V9_SVR_TCP1_PHASE:
  vias: v1(38.1,76.42)
+VCC1.05_OUT_FET: length 89.1
  IN1 w1.016: 205.03,181.09 203.48,179.54 198.97,179.54 193.32,173.9 193.32,171.72 191.23,169.62
  IN2 w1.016: 207.44,110.63 202.54,115.52 198.86,115.52 189.21,125.17 189.21,166.43 190.25,167.48
  BOTTOM w0.254: v1(210.95,68.7) 210.6,69.05 U49.W22 ; v1(211.01,69.43) 211.01,69.43 210.62,69.82 U49.W20 ; U49.W23 210.58,68.25 v1(210.96,67.87) ; v1(210.96,67.09) 210.58,67.47 U49.W25
  vias: v1(190.45,168.52) v1(191.19,168.52) v1(203.66,182.87) v1(203.88,182.01) v1(208.06,180.74) v1(208.69,180.4) v1(208.92,109.46) v1(208.92,108.78) v1(212.73,82.03) v1(213.41,82.03)
+VCC3P3_ANA_TCP0: length 3.1
  TOP w0.203: U9.L2 40.49,92.01 v2(40.49,91.99)
  BOTTOM w0.508: v1(42.55,92.93) 42.22,92.93 41.69,92.4 C708.2 40.9,92.4 v2(40.49,91.99)
+VCC3P3_ANA_TCP1: length 0.7
  TOP w0.203: U16.L2 35.92,74.74 v2(35.92,74.72)
+VCC3P3_LC_TCP0: length 0.4
  TOP w0.254: v2(39.22,89.41) 39.22,89.44 U9.E5
  vias: v1(40.82,82.94) v1(41.47,86.37) v1(42.9,84.42) v1(43.31,83.71)
+VCC3P3_LC_TCP1: length 0.5
  TOP w0.254: U16.E5 v2(34.62,72.14)
  vias: v1(36.55,65.65) v1(38.26,67.15) v1(38.36,69.03)
+VCC3V3_SX_TCP0: length 7.1
  TOP w0.203: v2(38.54,89.42) U9.E6
  IN1 w0.508: v1(38.61,82.92) 37.95,82.26 35.02,82.26 v1(34.34,82.93)
  BOTTOM w0.508: R832.2 35.29,96.73 34.93,96.36 34.25,96.36 v1(34.08,96.19)
  vias: v1(32.77,96.72) v1(40.62,84.42) v1(41.23,97.78) v1(41.66,82.96) v1(41.79,98.13) v1(41.79,97.42) v1(55.88,94.58) v1(56.64,95.33) v1(56.65,94.58)
+VCC3V3_SX_TCP0_DBRONLY: length 11.2
  TOP w0.203: v2(39.21,91.38) U9.J5
  TOP w0.508: R128.1 v1(43.95,98.9)
  IN3 w0.508: v1(43.95,98.9) 43.67,99.18 41.76,99.18 40.29,97.71 40.29,95.63 38.48,93.82 38.48,92.8
+VCC3V3_SX_TCP1: length 4.1
  TOP w0.203: v2(33.96,72.11) 33.96,72.14 U16.E6
  IN4 w0.508: v1(35.84,67.17) 35.84,67.65
  BOTTOM w0.508: R921.2 v1(29.34,79.08) 29.14,79.29 v1(28.71,79.29) 28.7,79.29 v1(28.04,79.29)
  vias: v1(29.34,65.65) v1(34.04,65.61) v1(36.76,81.36) v1(36.88,79.54) v1(37.34,65.65) v1(37.45,81.44) v1(49.33,76.04) v1(50.06,75.16) v1(50.55,75.7) v1(50.81,76.41)
+VCC3V3_SX_TCP1_DBRONLY: length 10.7
  TOP w0.203: U16.J5 v2(34.63,74.11)
  TOP w0.508: v1(39.49,81.52) 39.25,81.52 39.18,81.45 R276.1
  IN3 w0.508: 34.32,75.55 36.68,75.55 38.74,77.61 38.74,81.02 39.25,81.52 v1(39.49,81.52)
+VCC3V3A_SX_TCP0: length 0.4
  TOP w0.203: v2(37.91,91.99) U9.J7
  vias: v1(37.54,95.35)
+VCC3V3A_SX_TCP1: length 0.5
  TOP w0.203: U16.J7 33.64,74.41 v2(33.3,74.75)
  vias: v1(32.85,78.35)
+VCC_CORE: length 63.3
  IN3 w0.508: 119.46,177.99 119.46,190.54 120.32,191.4 120.32,197.68 122.51,199.87 122.51,205.42 124.29,207.2 124.29,213.15 125.22,214.08 v1(125.22,216.61)
  BOTTOM w0.152: PL10.2 PR497.2 ; PL8.2 PR495.2 ; PL11.2 PR498.2 ; PL7.2 PR494.1 ; PL12.2 PR499.2
  BOTTOM w0.178: PL9.2 PR496.2
  BOTTOM w0.2: v2(131.29,151.59) U42.CM38
  vias: v1(116.35,175.47) v2(126.96,153.01) v2(126.96,152.09) v2(127.17,150.01) v2(127.12,148.59) v2(127.17,147.18) v2(127.56,154.05) v2(127.82,146.41) v2(128.14,154.49) v2(128.47,150.01) v2(128.47,148.59) v2(128.47,147.18) v2(128.47,146.41) v2(129.12,146.41) v2(129.44,154.48) v2(129.88,151.57) v2(130.13,154.48) v2(130.46,150.66) v2(130.46,147.49) v2(130.52,151.58) v2(131.1,150.65) v2(131.11,149.89) v2(131.11,148.26) v2(131.11,146.72) v2(131.11,145.96) v2(131.28,152.96) v2(131.76,149.03) v2(131.76,147.49) v2(132.05,154.26) v2(132.05,152.96) v2(132.39,150.66) v2(132.41,149.89) v2(132.41,148.26) v2(132.41,146.72) v2(132.41,145.19) v2(132.82,153.61) v2(133.06,150.66) v2(133.06,149.03) v2(133.06,147.49) v2(133.06,145.96) v2(133.06,144.42) v2(133.62,151.57) v2(133.71,148.26) v2(133.71,146.72) v2(133.71,145.19) v2(134.2,154.29) v2(134.36,145.96) v2(134.36,144.42) v2(134.36,142.89) v2(134.36,141.83) v2(134.36,138.49) v2(134.36,137.46) v2(135.01,148.26) v2(135.01,146.72) v2(135.01,145.19) v2(135.01,136.69) v2(135.03,138.47) v2(135.56,149.71) v2(135.66,145.96) v2(135.66,144.42) v2(135.66,141.83) v2(135.66,140.93) v2(135.66,139.26) v2(135.66,137.46) v2(136.31,148.26) v2(136.31,146.72) v2(136.31,145.19) v2(136.31,141.85) v2(136.31,140.16) v2(136.31,138.36) v2(136.31,136.69) v2(136.35,149.71) v2(136.95,146.72) v2(136.96,145.96) v2(136.95,142.83) v2(136.96,140.93) v2(136.96,139.26) v2(137.14,150.36) v2(137.14,149.71) v2(137.61,148.26) v2(137.61,145.19) v2(137.61,143.66) v2(137.61,139.26) v2(137.61,136.69) v2(137.91,149.72) v2(138.26,145.96) v2(138.26,140.03) v2(138.26,138.36) v2(138.26,137.46) v2(138.37,147.53) v2(138.71,150.36) v2(138.71,149.71) v2(138.86,136.2) v2(139.12,148.42) v2(139.5,150.36) v2(139.5,149.71) v2(139.57,135.49) v2(139.63,136.2) v2(139.91,148.42) v2(140.29,150.36) v2(140.28,149.71) v2(141.07,150.36) v2(141.07,149.71) v2(141.49,148.42) v2(141.86,150.36) v2(142.27,148.42) v2(142.65,150.36) v2(142.65,149.71) v2(143.85,148.42) v2(144.2,150.36) v2(144.2,149.71) v2(144.64,148.42) v2(144.99,150.36) v2(145.01,149.71) v2(145.78,149.71) v2(146.21,148.42) v2(146.57,150.36) v2(146.57,149.71) v2(147.35,150.36) v2(148.14,149.71) v2(148.93,149.71) v2(149.35,148.42) v2(150.47,149.71) v2(151.23,150.36) v2(151.22,149.71) v2(152,149.71) v2(152.76,150.36) v2(152.76,149.71) v2(153.19,148.42) v2(160.1,135.49) v2(160.93,136.2) v2(161.01,135.49) v2(161.72,136.19) v2(161.77,135.49) v2(162.49,136.2) v2(163.56,141.39) v2(163.56,140.23) v2(163.56,137.75) v2(164.21,141.39) v2(164.21,140.23) v2(164.21,139.05) v2(164.21,137.81) v2(164.18,136.88) v2(164.86,141.39) v2(164.86,140.23) v2(164.86,139.05) v2(164.86,137.81) v2(164.83,136.87) v2(165.51,141.39) v2(165.51,140.23) v2(166.16,140.23) v3(118.24,175.73) v3(118.37,176.49) v3(118.62,174.21) v3(118.75,174.97) v3(119.15,176.49) v3(119.15,175.71) v3(119.54,174.97) v3(119.54,174.18) v3(120.02,176.49) v3(120.86,176.54) v3(120.98,175.73) v3(121.49,174.18) v3(121.72,176.49) v3(121.75,175.71) v3(121.72,174.94) v3(122.25,174.16) v3(122.48,176.49) v3(122.51,175.68) v3(122.48,174.92) v3(122.9,147.77) v3(122.9,146.88) v3(123.02,174.16) v3(123.24,176.49) v3(123.27,175.68) v3(123.24,174.92) v3(123.66,147.77) v3(123.66,146.88) v3(123.78,174.16) v3(124.01,176.47) v3(124.01,174.92) v3(124.03,175.68) v3(124.42,147.77) v3(124.42,146.88) v3(124.54,174.13) v3(124.79,176.47) v3(124.79,175.65) v3(124.79,174.89) v3(125.3,174.13) v3(125.56,176.44) v3(125.56,175.65) v3(125.56,174.89) v3(125.89,178.7) v3(125.89,177.92) v3(126.06,174.13) v3(126.24,177.23) v3(126.32,176.44) v3(126.32,175.65) v3(126.32,174.89) v3(126.83,174.13) v3(127.08,176.44) v3(127.08,175.65) v3(127.08,174.89) v3(127.61,174.13) v3(127.84,176.44) v3(127.87,175.65) v3(127.84,174.89) v3(128.37,174.13) v3(128.6,176.44) v3(128.6,174.89) v3(128.63,178.09) v3(128.63,177.31) v3(128.63,175.65) v3(129.16,174.16) v3(129.37,176.44) v3(129.37,174.92) v3(129.42,175.68) v3(129.87,168.74) v3(129.92,169.6) v3(130.13,176.72) v3(130.67,169.6) v3(130.62,168.75) v3(130.94,176.49) v3(130.97,175.71) v3(131.37,168.75) v3(131.45,169.6) v3(131.7,176.47) v3(131.7,174.92) v3(131.73,175.68) v3(131.73,174.16) v3(132.2,169.6) v3(132.15,168.75) v3(132.46,176.47) v3(132.49,175.65) v3(132.46,174.89) v3(132.49,174.13) v3(132.9,168.75) v3(132.97,169.6) v3(133.23,176.47) v3(133.25,175.65) v3(133.23,174.89) v3(133.25,174.13) v3(133.67,168.75) v3(133.72,169.6) v3(133.99,176.44) v3(133.99,174.89) v3(134.01,175.65) v3(134.01,174.13) v3(134.5,169.6) v3(134.42,168.75) v3(134.78,176.44) v3(134.78,175.63) v3(134.78,174.87) v3(134.78,174.11) v3(135.24,169.6) v3(135.24,168.77) v3(135.56,178.55) v3(135.56,177.76) v3(135.54,176.42) v3(135.54,175.63) v3(135.54,174.87) v3(135.54,174.11) v3(136.05,177.15) v3(136.02,169.6) v3(136.03,168.77) v3(136.3,176.42) v3(136.3,175.63) v3(136.3,174.87) v3(136.3,174.11) v3(136.78,169.6) v3(136.81,168.77) v3(137.06,176.42) v3(137.06,175.63) v3(137.06,174.87) v3(137.06,174.11) v3(137.56,169.6) v3(137.68,168.75) v3(137.82,176.42) v3(137.85,175.63) v3(137.82,174.87) v3(137.85,174.11) v3(138.31,169.6) v3(138.36,178.27) v3(138.36,177.48) v3(138.44,168.77) v3(138.59,176.42) v3(138.59,174.87) v3(138.61,175.63) v3(138.61,174.11) v3(139.05,169.58) v3(139.27,176.92) v3(139.27,168.79) v3(139.8,169.58) v3(139.98,176.54) v3(140.01,175.76) v3(140.02,168.79) v3(140.58,169.58) v3(140.74,176.52) v3(140.77,175.73) v3(140.8,168.82) v3(140.87,174.97) v3(140.9,174.21) v3(141.33,169.58) v3(141.51,176.52) v3(141.53,175.71) v3(141.63,174.94) v3(141.66,174.18) v3(142.27,176.52) v3(142.29,175.71) v3(142.4,174.94) v3(142.42,174.18) v3(143.03,176.49) v3(143.06,175.71) v3(143.16,174.94) v3(143.18,174.18) v3(143.82,176.49) v3(143.82,175.68) v3(143.94,174.92) v3(143.94,174.16) v3(144.58,176.47) v3(144.58,175.68) v3(144.71,174.92) v3(144.71,174.16) v3(145.27,178.68) v3(145.27,177.89) v3(145.34,176.47) v3(145.34,175.68) v3(145.47,174.92) v3(145.47,174.16) v3(145.75,177.23) v3(146.1,176.47) v3(146.1,175.68) v3(146.23,174.92) v3(146.23,174.16) v3(146.87,176.47) v3(146.89,175.68) v3(146.99,174.92) v3(147.02,174.16) v3(147.26,177.13) v3(147.63,176.47) v3(147.65,175.68) v3(147.75,174.92) v3(147.78,174.16) v3(148.01,178.52) v3(148.01,177.74) v3(148.39,176.47) v3(148.44,175.71) v3(148.52,174.94) v3(148.57,174.18) v3(149.13,176.72) v3(149.89,176.47) v3(149.91,175.68) v3(150.65,176.47) v3(150.68,175.65) v3(150.8,174.13) v3(150.83,174.89) v3(151.41,176.47) v3(151.44,175.65) v3(151.59,174.89) v3(151.56,174.13) v3(152.17,176.44) v3(152.2,175.65) v3(152.35,174.89) v3(152.33,174.13) v3(152.96,176.44) v3(152.96,175.63) v3(153.11,174.87) v3(153.72,176.42) v3(153.72,175.63) v3(153.88,174.87) v3(154.49,176.42) v3(154.49,175.63) v3(154.64,174.87) v3(154.84,178.6) v3(154.84,177.81) v3(155.25,176.42) v3(155.25,175.63) v3(155.37,177.2) v3(155.4,174.87) v3(156.01,176.42) v3(156.04,175.63) v3(156.16,174.87) v3(156.42,177.11) v3(156.77,176.42) v3(156.8,175.63) v3(157.23,174.84) v3(157.58,177.2) v3(157.53,176.42) v3(157.58,175.65) v3(157.66,178.32) v3(158.28,176.31) v3(158.34,177.08) v3(159.04,176.46) v3(159.06,175.71) v3(159.38,177.13) v3(159.79,176.49) v3(159.82,175.68) v3(160.56,176.49) v3(160.58,175.68) v3(161.32,176.47) v3(161.34,175.68) v3(162.11,176.47) v3(162.11,175.65) v3(162.87,176.44) v3(162.87,175.65) v3(163.63,176.44) v3(163.63,175.65) v3(164.39,176.44) v3(164.39,175.65) v3(164.52,178.83) v3(164.52,178.04) v3(164.6,177.24) v3(165.15,176.44) v3(165.37,177.24)
