# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N49353207: length 3.6
  BOTTOM w0.14: CN13.10 100.35,52.43 v1(100.08,52.16) 99.81,52.43 99.17,52.43 99.03,52.29 R1072.1
N49355730: length 3
  BOTTOM w0.14: CN12.38 272.79,70.24 TP150.1
N49355733: length 4
  BOTTOM w0.14: CN12.40 275.42,70.81 271.77,70.81 TP148.1
N49355736: length 2
  BOTTOM w0.14: CN12.42 273.64,71.24 TP147.1
N53255970: length 2.6
  TOP w0.14: v1(234.56,69.56) R441.2 234.56,68.71 U18.29
N53256180: length 3
  TOP w0.14: R386.2 240.91,73.68 239.63,72.4 U18.19
N53256182: length 2.2
  TOP w0.14: U18.21 238.63,72.93 238.75,73.05 R384.2
N53564538: length 12
  BOTTOM w0.14: CN3.2 108.5,104.2 C691.1 107.73,104.66 107.59,104.8 107.59,106.07 108.11,106.6 R819.2 108.68,107.63 108.84,107.47 109.28,107.47 R820.2 109.47,106.94 109.61,106.8 110.84,106.8 110.98,106.94 v1(110.98,108.49) Q100.3
N53564570: length 3
  BOTTOM w0.14: Q99.2 107.76,112.84 v1(108.19,112.84) R816.2
N53565581: length 1.1
  TOP w0.14: Q35.2 v1(285.18,79.27)
N53565628: length 21.3
  TOP w0.14: v1(288.51,86.21) 288.65,86.07 C289.1 288.65,83.81 289.33,83.13 Q31.3 289.24,82.55 288.81,82.55 288.11,81.85 R274.2 287.83,82.4 288.01,82.58 288.01,83.08 287.75,83.34 287.24,83.34 286.97,83.08 286.97,83 286.24,82.26 R273.2
  BOTTOM w0.14: CN8.2 290.26,79.19 289.08,79.19 288.32,79.95 288.32,82.49 287.3,83.5 287.3,85.61 287.9,86.21 v1(288.51,86.21)
N53716068:
  vias: v1(82.35,93.33)
N53716070:
  vias: v1(84.28,87.77)
N53788267: length 2.2
  TOP w0.14: PQ5.2 262.94,212.32 PR43.1 263.14,212.51 PR35.1
N53788269: length 2.9
  BOTTOM w0.14: PR351.2 251.64,217
  BOTTOM w0.203: 251.64,217 251.64,216.99 251.86,216.99 252.11,216.74 252.62,216.74 PC279.1 253,217.12 PR352.2
N53788407: length 11.7
  TOP w0.203: PQ4.3 256.85,211.91 v1(256.49,212.27)
  IN1 w0.254: v1(247.83,215.32) 248.25,215.32 251.3,212.27 v1(256.49,212.27)
  BOTTOM w0.203: PR365.2 248.46,215.76 248.02,215.32 v1(247.83,215.32)
N53788559: length 4.5
  TOP w0.203: PR30.2 259.1,213.94 259.33,214.17 259.33,214.61 259.53,214.81 PQ1.2 259.99,214.81 260.36,215.18 PQ2.3 260.71,215.58 259.81,216.49 PR1.1
N53788585: length 2.4
  TOP w0.14: PR100.1 v1(235.03,201.72)
  TOP w0.508: PC30.1 234.05,200.67 PR100.1
N53788806: length 3.1
  BOTTOM w0.14: PR429.1 v1(268.43,203.11)
  BOTTOM w0.508: PR429.1 267.14,203.77 266.57,204.34 PC331.1
N53789031:
  vias: v1(257.94,216.75)
N53789209: length 0.9
  TOP w0.203: PQ2.2 262.95,214.68 PR20.2
N54130914: length 2.5
  TOP w0.14: U18.1 v1(237.13,65.14) 236.97,64.99 236.73,64.99 236.47,64.72 R490.1
N54227218: length 4.2
  TOP w0.14: U24.6 19.01,66.84 18.88,66.96 18.88,68.16 19.14,68.42 21.07,68.42 TP59.1
N54227279: length 1.9
  TOP w0.14: TP60.1 18.61,67.56 U24.7
N54443582: length 2.2
  BOTTOM w0.14: T6.1 25.38,21.55 24.85,22.08 U56.27
N54443594: length 3.3
  BOTTOM w0.14: T5.1 26.26,20.66 25.72,21.2 25.72,21.6 24.85,22.48 U56.26
N54443678: length 1.8
  TOP w0.14: v1(20.02,20.23) 20.02,20.68 T3.1
  BOTTOM w0.14: U56.38 v1(20.02,20.23)
N54443680: length 1.6
  TOP w0.14: T4.1 21.22,20.86 21.22,20.25 v1(21.21,20.24)
  BOTTOM w0.14: v1(21.21,20.24) 21.22,20.25 U56.35
N54443682: length 2.4
  TOP w0.14: v1(17.5,22.54) 18.19,22.54 T2.1
  BOTTOM w0.14: U56.3 17.57,22.48 v1(17.5,22.54)
N55927396: length 2.4
  BOTTOM w0.508: PR541.1 284.05,96.55 283.37,97.24 PC413.2
N55927404: length 2.5
  BOTTOM w0.178: PR559.2 282.7,88.43 282.68,88.46 281.38,88.46 281.13,88.71 PU29.31
N55927441: length 1.3
  BOTTOM w0.254: PR569.2 PC475.1
N55927461: length 2.2
  BOTTOM w0.178: PR575.2 278.13,87.44 279.33,88.64 PU29.35
N55927578: length 2.5
  BOTTOM w0.178: PR574.2 277.65,87.84 278.09,87.84 278.88,88.64 PU29.36
N55927589: length 2.9
  BOTTOM w0.178: PR572.2 275.72,88.1 276.25,88.63 276.56,88.63 276.77,88.84 276.77,88.84 276.94,89.01 PU29.39
N55927593: length 2.8
  BOTTOM w0.178: PR573.2 276.57,87.44 276.9,87.77 277.13,87.77 277.52,88.16 277.88,88.16 278.43,88.71 PU29.37
N55927597: length 4.9
  BOTTOM w0.254: TP117.1 276.36,94.45 276.36,92.13 276.6,91.89 PU29.6 277.49,91.89 277.76,92.16 PU29.41
N55927792: length 2.6
  BOTTOM w0.178: PC465.1 PR551.2 275.72,91.01 275.73,91.01 276.21,90.54 PU29.3
N55928956: length 1.3
  BOTTOM w0.508: PC414.2 294.14,96.82 293.97,96.65 PR542.1
N55928964: length 2.5
  BOTTOM w0.178: PU30.31 291.04,88.69 291.26,88.47 292.57,88.47 292.82,88.72 PR558.2
N55929001: length 2.9
  BOTTOM w0.254: PC474.1 294.36,87.09 293.72,86.45 v1(293.32,86.45) PR567.2
N55929021: length 2.2
  BOTTOM w0.178: PU30.35 289.24,88.64 288.03,87.44 PR578.2
N55929149: length 2.9
  BOTTOM w0.178: PR570.2 v1(285.63,88.23) 285.75,88.23 286.24,88.72 287.26,88.72 287.44,88.9 PU30.39
N55929153: length 2.8
  BOTTOM w0.178: PU30.37 288.34,88.64 287.78,88.08 287.12,88.08 286.48,87.44 PR576.2
N55929157: length 5.1
  BOTTOM w0.178: PU30.41 287.65,92.16 287.37,91.89 PU30.6 286.5,91.89 286.21,92.18 286.21,94.5 TP116.1
N55929352: length 2.5
  BOTTOM w0.178: PU30.3 286.42,90.54 286,90.96 PR550.2 PC466.1
N55940902: length 2.5
  BOTTOM w0.14: v1(226.44,95.47) 226.16,95.75 PR543.1
  BOTTOM w0.508: PR543.1 PC420.2
N55940967: length 1.3
  BOTTOM w0.254: PR583.2 PC476.1
N55940969: length 3.3
  BOTTOM w0.14: PC468.1 PR552.2 ; PR552.2 217.33,90.28 PU31.3 ; PR552.2 v1(216.03,89.87)
N55940971: length 1.9
  BOTTOM w0.14: PR582.1 219.42,87.31 219.67,87.56 219.67,87.65 220.4,88.38 PU31.35
N55940973: length 2.2
  BOTTOM w0.14: PR581.1 218.66,87.31 219.03,87.68 219.31,87.68 219.95,88.33 PU31.36
N55940977: length 2.6
  BOTTOM w0.14: PU31.37 219.5,88.27 219.19,87.96 218.83,87.96 218.58,87.72 218.39,87.72 217.98,87.31 PR580.2
N55940983: length 3.6
  BOTTOM w0.14: TP123.1 217.63,93.14 217.63,92.03 218.02,91.63 PU31.6 218.48,91.91 PU31.41
N55940988: length 2.4
  BOTTOM w0.178: PR563.2 223.73,88.18 223.68,88.22 222.43,88.22 222.2,88.45 PU31.31
N55941017: length 2.4
  BOTTOM w0.178: PU32.31 231.98,88.45 232.23,88.2 233.25,88.2 233.28,88.18 PR564.2
N55941021: length 2.8
  BOTTOM w0.14: PR544.1 235.99,95.83 v1(236.35,95.47)
  BOTTOM w0.508: PR544.1 235.1,96.64 234.93,96.82 PC415.2
N55941039: length 1.3
  BOTTOM w0.254: PR588.2 PC477.1
N55941042: length 1.9
  BOTTOM w0.14: PR587.1 229.2,87.31 229.45,87.56 229.45,87.65 230.18,88.38 PU32.35
N55941044: length 2.2
  BOTTOM w0.14: PU32.36 229.73,88.33 229.09,87.68 228.81,87.68 228.44,87.31 PR586.1
N55941048: length 2.6
  BOTTOM w0.14: PR585.2 227.68,87.31 228.09,87.72 228.36,87.72 228.61,87.96 228.97,87.96 229.28,88.27 PU32.37
N55941050: length 3.3
  BOTTOM w0.14: v1(226.06,87.08) 226.29,87.31 PR584.1 227.16,87.64 227.16,88.2 227.35,88.4 227.43,88.4 227.43,88.4 228.03,88.4 PU32.39
N55941056: length 4.2
  BOTTOM w0.14: PU32.41 228.26,91.91 PU32.6 227.5,91.63 227.36,91.77 227.36,93.54 TP120.1
N55941092: length 2.5
  BOTTOM w0.178: PR560.2 243.54,88.23 243.54,88.22 v1(243.21,88.22) 241.99,88.22 241.76,88.45 PU33.31
N55941096: length 2.7
  BOTTOM w0.14: PR545.1 245.72,95.75 v1(246,95.47)
  BOTTOM w0.508: PC416.2 244.45,96.62 244.95,96.12 PR545.1
N55941113: length 1.3
  BOTTOM w0.254: PR593.2 PC478.1
N55941116: length 1.9
  BOTTOM w0.14: PU33.35 239.96,88.29 238.98,87.31 PR592.1
N55941118: length 2.2
  BOTTOM w0.14: PR591.1 238.22,87.31 238.59,87.68 238.87,87.68 239.51,88.33 PU33.36
N55941122: length 2.6
  BOTTOM w0.14: PU33.37 239.06,88.27 238.75,87.96 238.39,87.96 238.14,87.72 237.86,87.72 237.45,87.31 PR590.2
N55941124: length 2.5
  BOTTOM w0.14: PU33.39 237.8,88.4 237.21,88.4 237.2,88.4 237.13,88.4 236.94,88.2 236.94,87.64 PR589.1
N55941130: length 4.4
  BOTTOM w0.14: TP119.1 236.99,93.82 236.99,91.78 237.14,91.63 PU33.6 238.03,91.91 PU33.41
N55941168: length 2.3
  BOTTOM w0.178: PR561.2 253.07,88.23 253.06,88.22 251.77,88.22 251.54,88.45 PU34.31
N55941172: length 2.8
  BOTTOM w0.14: PR546.1 255.29,95.7 v1(255.53,95.47)
  BOTTOM w0.508: PC417.2 253.98,96.69 254.49,96.18 PR546.1
N55941190: length 1.3
  BOTTOM w0.254: PR598.2 PC479.1
N55941193: length 1.9
  BOTTOM w0.14: PR597.1 248.76,87.31 249.01,87.56 249.01,87.65 249.74,88.38 PU34.35
N55941195: length 2.2
  BOTTOM w0.14: PR596.1 248,87.31 248.37,87.68 248.65,87.68 249.29,88.33 PU34.36
N55941199: length 2.6
  BOTTOM w0.14: PR595.2 247.23,87.31 247.64,87.72 247.92,87.72 248.17,87.96 248.53,87.96 248.84,88.27 PU34.37
N55941201: length 3.3
  BOTTOM w0.14: v1(245.62,87.21) 245.72,87.31 PR594.1 246.47,87.31 246.71,87.54 246.71,87.76 246.72,87.77 246.72,88.2 246.91,88.4 246.98,88.4 246.99,88.4 247.58,88.4 PU34.39
N55941207: length 4.1
  BOTTOM w0.14: TP121.1 246.76,93.56 246.76,92.23 247.36,91.63 PU34.6 247.81,91.91 PU34.41
N55941243: length 2.4
  BOTTOM w0.178: PR565.2 262.97,88.18 262.93,88.22 261.55,88.22 261.32,88.45 PU35.31
N55941247: length 2.9
  BOTTOM w0.14: v1(265.31,95.34) 264.97,95.68 PR547.1
  BOTTOM w0.508: PR547.1 264.25,96.02 263.5,96.77 PC418.2
N55941265: length 1.3
  BOTTOM w0.254: PR603.2 PC480.1
N55941268: length 1.9
  BOTTOM w0.14: PR602.1 258.54,87.31 258.79,87.56 258.79,87.65 259.52,88.38 PU35.35
N55941270: length 2.2
  BOTTOM w0.14: PR601.1 257.77,87.31 258.15,87.68 258.43,87.68 259.07,88.33 PU35.36
N55941274: length 2.6
  BOTTOM w0.14: PU35.37 258.62,88.27 258.31,87.96 257.94,87.96 257.7,87.72 257.51,87.72 257.1,87.31 PR600.2
N55941276: length 2.5
  BOTTOM w0.14: PU35.39 257.36,88.4 256.77,88.4 256.49,88.13 256.49,87.77 256.49,87.76 256.49,87.54 256.25,87.31 PR599.1
N55941282: length 4.2
  BOTTOM w0.14: PU35.41 257.96,91.91 257.69,91.63 PU35.6 257.18,91.63 256.67,92.14 256.67,93.82 TP118.1
N55941318: length 2.4
  BOTTOM w0.14: PR562.2 272.77,88.23 272.76,88.24 271.33,88.24 271.1,88.48 PU36.31
N55941322: length 2.1
  BOTTOM w0.508: PR548.1 274.03,96.49 273.41,97.11 PC419.2
N55941340: length 1.3
  BOTTOM w0.254: PR608.2 PC481.1
N55941343: length 1.9
  BOTTOM w0.14: PU36.35 269.3,88.38 268.57,87.65 268.57,87.56 268.32,87.31 PR607.1
N55941345: length 2.2
  BOTTOM w0.14: PU36.36 268.85,88.33 268.21,87.68 267.93,87.68 267.55,87.31 PR606.1
N55941347: length 2.6
  BOTTOM w0.14: PR605.2 266.79,87.31 267.2,87.72 267.48,87.72 267.72,87.96 268.09,87.96 268.4,88.27 PU36.37
N55941349: length 2.5
  BOTTOM w0.14: PU36.39 267.14,88.4 266.55,88.4 266.54,88.4 266.47,88.4 266.27,88.2 266.27,87.77 266.26,87.76 266.26,87.63 PR604.1
N55941355: length 4.2
  BOTTOM w0.14: TP122.1 266.45,93.56 266.45,91.77 266.58,91.63 PU36.6 267.37,91.91 PU36.41
N55941374: length 2.5
  BOTTOM w0.14: PU32.3 227.11,90.28 PR553.2 PC469.1
N55941387: length 2.5
  BOTTOM w0.14: PU33.3 236.89,90.28 PR554.2 PC470.1
N55941398: length 2.5
  BOTTOM w0.14: PC471.1 PR555.2 246.67,90.28 PU34.3
N55941409: length 2.5
  BOTTOM w0.14: PU35.3 256.45,90.28 PR556.2 PC472.1
N55941420: length 2.5
  BOTTOM w0.14: PU36.3 266.23,90.28 PR557.2 PC473.1
N56077694: length 11.6
  TOP w0.14: Q69.3 22.97,10.38 22.18,9.59 Q70.3 21.64,9.59 21.31,9.26 R675.2 21.31,8.05 21.45,7.91 21.66,7.91 v1(21.81,8.07) ; Q71.5 17.53,3.71 17.27,3.46 17.27,3.24 C562.1 16.84,3.31 16.84,3.48 16.59,3.73 16.59,4.48 16.93,4.82 17.29,4.82 17.53,5.06 Q71.2 17.53,5.8 v1(17.72,5.99) ; Q72.2 19.56,3.15 C563.1 19.43,3.01 19.43,2.45 v1(19.57,2.31) ; v1(19.62,5.99) 19.56,5.93 Q72.5
  vias: v1(19.09,8.08)
N56077756:
  vias: v1(25.61,9.69)
N56077770: length 1.9
  TOP w0.14: Q72.1 19.06,4.22 19.38,4.54 19.69,4.54 20.06,4.91 Q72.4
N56077935: length 4.8
  TOP w0.14: Q70.2 22.17,10.09 22.62,10.55 22.62,10.85 22.48,10.99 R673.2 21.79,10.99 21.62,11.16 Q67.3
N56085203:
  vias: v1(18.72,43.96)
N56199005: length 2.7
  BOTTOM w0.14: v1(276.26,43.93) R1168.2 275.48,45.57 U55.10
N56202137: length 3
  BOTTOM w0.14: v1(278.64,42.89) 278.52,42.77 R1171.2 279.33,41.87 279.4,41.95 CN18.13
N56214175: length 2.5
  BOTTOM w0.14: PR579.1 217.53,87.79 217.53,88.19 217.82,88.48 218.46,88.48 218.6,88.62 PU31.39
N56249919: length 1.9
  TOP w0.14: Q71.4 17.03,4.29 17.28,4.54 17.5,4.54 18.03,5.07 Q71.1
N56249956:
  vias: v1(22.56,45.84)
N56250018:
  vias: v1(20.48,47.92)
N56253576: length 2.5
  BOTTOM w0.178: PU30.36 288.79,88.64 288.53,88.39 287.91,87.77 287.48,87.77 PR577.2
N56276780: length 1.3
  TOP w0.14: Q18.2 v1(303.55,101.42)
N56849590: length 162.8
  TOP w0.14: R611.2 v1(169.87,53.43) ; v1(247.33,37.07) 247.66,36.74 255.53,36.74 258.59,39.8 258.59,44.68 258.14,45.12 258.14,49.22 260.06,51.13 260.06,53.79 259.59,54.25 259.59,56.11 257.82,57.87 253.59,57.87 251.55,59.92 251.55,62.78 252.71,63.95 252.71,65.52 252.52,65.71 252.52,67.99 254.24,69.71 264.11,69.71 265.04,70.64 268.05,70.64 268.22,70.82 R416.2 R403.2 268.34,72.43 268.23,72.54 C391.2 268.23,73.65 269.49,74.91 Q41.2
  IN2 w0.089: v1(247.33,37.07) 246.85,36.59 245.39,36.59 244.88,37.1 241.4,37.1 240.41,36.11 235.18,36.11 234.32,36.96 227.6,36.96 224.19,40.38 221.3,40.38 219.5,38.58 202.05,38.58 201.76,38.88 201.76,39.43 201.43,39.76 196.22,39.76 195.98,39.52 189.98,39.52 189.68,39.81 188.09,39.81 186.64,41.26 186.64,42.86 185.52,43.98 183.82,43.98 179.67,48.13 179.67,49.8 178,51.47 170.59,51.47 169.87,52.19 v1(169.87,53.43)
N56881941: length 1.3
  TOP w0.14: 25.91,13.17 26.04,13.17 26.67,13.81 v1(26.93,13.81)
N58459581: length 3.1
  TOP w0.14: v1(61.34,57.44) PR297.2
  TOP w0.508: PQ30.3 59.52,56.26 60.25,56.99 PR297.2
N59747615: length 0.8
  TOP w0.14: 67.06,61.18 v1(67.06,60.41)
N59747617:
  vias: v1(70.1,65.57)
N59809104: length 6.2
  TOP w0.14: Q12.3 219.03,190.45 219.81,191.22 v1(220.09,191.22) 221.07,190.25 Q13.2 221.97,190.97 R63.1 R64.2
N59809106: length 7
  TOP w0.14: R68.2 v1(216.24,189.48) 217.6,189.48 217.79,189.29 217.79,188.35 218.09,188.06 220.11,188.06 Q13.3
N60121159:
  vias: v1(185.03,191.55) v3(183.59,192.04) v3(183.59,191.2) v3(183.59,190.44) v3(183.59,189.68) v3(184.41,192.06) v3(184.36,191.2) v3(184.36,190.44) v3(184.36,189.68)
N60121164: length 5.4
  TOP w0.254: PQ36.3 55.87,43.42 56.86,43.42 PR320.1 58,44.67 59.05,45.71 PC241.1
  vias: v1(55.1,40.81) v3(51.51,41.8) v3(51.51,41.01) v3(51.54,40.25) v3(52.3,41.77) v3(52.3,40.98) v3(52.33,40.22) v3(53.06,41.77) v3(53.06,41.01) v3(53.09,40.25) v3(53.82,41.8) v3(53.82,41.03) v3(53.86,40.27)
N60121172: length 16.6
  TOP w0.254: v1(184.5,188.54) 183.27,188.54 182.73,189.08 182.73,192.42 183.53,193.23 v1(184.94,193.23)
  BOTTOM w0.254: PC377.2 184.75,193.94 184.83,193.86 184.83,193.33 v1(184.94,193.23) 185,193.28 PQ58.4 ; PQ59.4 182.59,188.11 182.88,187.82 182.88,187.81 PR485.1 182.99,187.69 185.77,187.69 PC383.2 185.18,188.54 v1(184.5,188.54)
N60121264: length 1.4
  TOP w0.178: PR327.2 42.93,42.03 42.46,41.56 PC259.2
N60121271:
  vias: v1(179.43,189.94) v3(176.3,189.93) v3(176.28,188.99) v3(176.89,188.41) v3(176.81,187.44) v3(177.57,187.44) v3(177.65,188.41) v3(178.34,187.44) v3(178.41,188.41) v3(179.1,187.44) v3(179.17,188.41) v3(179.86,187.44) v3(179.94,188.41)
N60121298: length 15.9
  TOP w0.178: v1(35.06,42.64) 35.58,43.16 PU18.10
  TOP w0.203: v1(29.51,42.92) 29.25,42.92 28.71,42.38 PR330.1 28.23,42.38 28.18,42.43 27.7,42.43 26.94,41.67 26.94,41.25 27.41,40.78 PR335.1 PR336.1
  TOP w0.508: PQ37.2 29.91,43.33 v1(29.51,42.92)
  BOTTOM w0.508: PQ70.2 29.91,42.51 v1(29.51,42.92) 31.83,42.92 32.03,43.13 33.54,43.13 33.83,43.42 34.7,43.42 35.06,43.06 v1(35.06,42.64)
N60121308: length 6.7
  TOP w0.254: PR314.1 60.72,46.39 59.27,44.93 PC241.2 58.9,44.62 58.9,44.1 v1(57.81,43.02) 57.47,42.67 PQ36.4
N60121335: length 3.7
  TOP w0.178: PU18.28 40.81,43.96 41.08,44.23 41.08,44.72 v1(41.17,44.81) PC243.1 42.16,45.31 42.12,45.35 PR318.1
N60121339: length 1.8
  TOP w0.14: PR333.1 35.08,42 35.84,42.76 PU18.11
N60121341: length 2
  TOP w0.14: PU18.12 35.85,42.36 34.9,41.41 PR334.1
N60121342: length 2.9
  TOP w0.14: PR319.1 35.15,44.99 35.29,44.85 36.32,44.85 36.78,45.32 37.05,45.32 37.18,45.18 37.18,44.79 PU18.7
N60121344: length 1.5
  TOP w0.14: PU18.9 35.17,43.56 35.03,43.42 PR325.1
N60121361: length 1.1
  TOP w0.14: PR317.1 37.85,45.67 37.96,45.56 PU18.5
N60121365: length 4.1
  TOP w0.14: PR340.2 36.23,39.69 36.09,39.83 36.09,40.35 36.39,40.65 v1(36.43,40.65) 36.82,40.26 37.02,40.26 37.16,40.4 PU18.15
  BOTTOM w0.14: PR340.2 36.66,39.69 36.8,39.83 36.8,40.28 v1(36.43,40.65)
N60121374: length 1.7
  TOP w0.14: PR322.1 35.03,44.22 35.17,44.36 35.57,44.36 35.97,43.96 PU18.8
N60121443: length 1
  BOTTOM w0.14: 31.12,39.84 31.37,39.84 v1(31.88,39.33)
  vias: v1(29.99,40.03)
N60121447: length 2.8
  TOP w0.14: PQ38.3 31.25,42.92 31.16,43.01 30.86,43.01 30.23,42.38 PR331.2
N60121455: length 1
  TOP w0.254: v1(31.32,46.49) 31.32,46.31 30.86,45.86 PQ37.3
  vias: v1(30.5,46.5)
N60121459: length 3.3
  BOTTOM w0.14: v1(28.83,43.65) 29.27,44.09 PR648.2 30.57,44.09 30.87,44.39 31.23,44.39 31.37,44.25 PQ68.3
N60121483: length 1.4
  TOP w0.14: 43.42,45.93 44.33,45.02 v1(44.33,44.92)
N60415319: length 9.9
  TOP w0.508: v1(219.71,202.4) 220.2,202.4 221.64,200.95 221.64,198.67 220.22,197.24 v1(220.02,197.24)
  BOTTOM w0.254: PQ46.4 219.89,201.84 219.71,202.02 v1(219.71,202.4)
  BOTTOM w0.508: PQ47.4 216.79,198.01 217.38,197.42 PC353.2
N60415322: length 4.1
  BOTTOM w0.508: PR465.2 215.76,196.12 v1(216.24,195.63) 216.46,195.42 216.46,192.97 PQ55.1
N60415324: length 1.6
  BOTTOM w0.14: v1(218.7,195.29) 218.24,194.83 PQ55.3
N60415329:
  vias: v1(220.2,199.69) v3(216.46,202.53) v3(217.12,202.88) v3(217.43,202.12) v3(217.43,201.36) v3(217.43,200.6) v3(217.43,199.84) v3(217.88,202.88) v3(218.19,202.12) v3(218.19,201.36) v3(218.19,200.6) v3(218.19,199.84) v3(218.65,202.88) v3(218.95,202.12) v3(218.95,201.36) v3(218.95,200.6) v3(218.95,199.84)
N60415356: length 8.4
  IN1 w0.508: v1(186.29,196.99) 186.47,196.81 187.96,196.81 188.73,197.57 188.73,201.34 v1(187.93,202.13)
  BOTTOM w0.635: v1(187.93,202.13) PQ49.4
N60415361:
  vias: v1(178.95,196.69)
N60415366: length 3.4
  BOTTOM w0.254: PC364.1 186.93,194.95 185.69,194.95 PR467.2
  vias: v1(186.03,202.12) v1(186.57,202.5) v1(186.97,201.94) v1(186.92,201.26) v1(186.95,200.01) v1(186.95,198.74) v1(187.18,200.62) v1(187.15,199.38) v1(187.18,198.13) v1(187.18,197.45) v1(187.82,198.94)
N60419650: length 8.9
  TOP w0.14: v1(196,203.42) 196.31,203.42 197.09,202.65 199.69,202.65 200.03,202.99 201.29,202.99 201.43,203.14 PR97.2
  BOTTOM w0.14: PR412.1 194.44,204.18 194.67,203.96 PR428.1 194.74,203.52 PR426.2 195.9,203.52 v1(196,203.42)
N60434551: length 7.8
  BOTTOM w0.14: PR478.2 205.37,192.74 v1(205.07,192.44) 204.13,192.44 203.88,192.69 PQ54.2 203.88,193.76 203.58,194.06 202.46,194.06 202.22,194.31 PR472.1 200.65,194.3 PC379.1
N60434568: length 3
  BOTTOM w0.14: PR473.1 204.74,194.64 v1(203.97,195.42) 203.44,194.89 PQ54.3
N60434570: length 15.1
  TOP w0.254: v1(203.89,196.25) 204.11,196.25 204.64,196.78 204.64,202.36 v1(204.56,202.44)
  BOTTOM w0.254: PQ45.4 203.91,202.22 204.16,202.46 204.51,202.46 204.54,202.44 v1(204.56,202.44) ; PQ50.4 200.28,196.94 200.82,196.4 PC360.2 201.79,196.34 PR464.1 203.8,196.34 v1(203.89,196.25) 204.14,196.25 205.23,195.17 205.55,195.17 205.8,194.92 PR473.2
N60434578:
  vias: v1(201.6,197.81) v3(201.17,202.1) v3(201.17,201.28) v3(201.17,200.52) v3(201.17,199.76) v3(201.17,199) v3(201.93,201.28) v3(201.93,200.52) v3(201.93,199.76) v3(201.93,199) v3(202.19,202.07) v3(202.7,201.28) v3(202.7,200.52) v3(202.7,199.76) v3(202.7,199) v3(202.7,198.24)
N60447029: length 2.5
  BOTTOM w0.14: PR475.1 198.5,192.72 PC381.1 198.2,192.51 PQ57.2
N60481587: length 3.3
  BOTTOM w0.254: PQ60.4 189.63,176.63 v1(189.36,176.37) 189.18,176.19 PR509.2 PR510.1
N60536855: length 5.1
  BOTTOM w0.14: PQ51.2 175.94,198.17 v1(175.94,198.09) 175.94,197.84 176.96,196.81 PC363.1 PR468.1
N60538244: length 5.1
  BOTTOM w0.14: PQ57.3 195.96,194.79 196.1,194.93 199.36,194.93 199.52,195.08 v1(199.82,195.08) PR472.2
N60539202: length 3.7
  BOTTOM w0.508: PR471.1 214.51,194.31 213.67,193.46 PQ53.2 214.02,192.55 PC380.1
N60539593: length 22.8
  BOTTOM w0.508: PR476.1 199.85,193.15 199.85,192.24 200.49,191.61 202.7,191.61 v1(202.95,191.86) 203.92,190.89 208.08,190.89 208.92,191.73 211.71,191.73 211.8,191.82 216.5,191.82 217.51,192.83 PQ55.2 218.9,192.83 219.12,193.04 PC378.1
N60539854: length 2.8
  BOTTOM w0.508: PR465.1 v1(213.18,196.12) 212.72,195.66 PQ53.3
N60541902: length 2.1
  TOP w0.254: PU6.3 224.01,188.06 223.75,187.81 PR112.2 223.43,188.27 223.19,188.51 PC53.1
N60541904: length 1.8
  TOP w0.14: PU6.1 224.91,189.36 225.13,189.58 225.13,189.77 224.65,190.25 PR104.1
N60541918: length 1.7
  TOP w0.14: PR103.2 226.47,190.19 226.1,189.82 226.1,189.5 226.24,189.36 PU6.6
N62866854: length 4.7
  TOP w0.14: PU1.1 142.29,211.11 142.47,210.93 PR58.1 142.54,209.77 PR61.1 143.47,209.76 PR62.1 144.22,210.45 v1(144.15,210.53)
N62866877: length 116.3
  TOP w0.14: PU1.3 142.45,213.65 142.76,213.97 146.67,213.97 v1(147.58,213.07) ; PU5.6 230.87,190 230.53,190.34 230.53,191.19 v1(230.41,191.3)
  IN1 w0.086: v1(156.28,201.94) 156.28,203.2 157.7,204.62 157.7,205.69 161.04,209.03 169.98,209.03 171.02,208 171.02,206.85 172.56,205.3 172.56,204.3 173.93,202.94 173.93,201 176.22,198.71 177.2,198.71 179.91,196.01 181.68,196.01 182.1,195.59 187.16,195.59 192.3,190.45 199.74,190.45 200.81,191.52 206.86,191.52 208.79,189.59 211.08,189.59 211.42,189.93 212.14,190.66 215.62,190.66 217.15,192.19 217.7,192.19 218.2,191.7 223.49,191.7 224.12,191.06 230.17,191.06 v1(230.41,191.3)
  IN2 w0.089: v1(156.28,201.94) 155.59,201.94 152,205.53 150.14,205.53 149.43,206.24 149.43,209.79 149.13,210.1 149.13,210.61 147.58,212.15 v1(147.58,213.07)
N62866886: length 1.8
  TOP w0.508: PU1.2 142.57,212.38 142.6,212.41 PR38.2 143.28,212.38
N62866953: length 1.9
  TOP w0.254: PR115.2 227.73,187.63 227.65,187.71 PC54.1 228.02,188.05 228.05,188.08 PU5.3
N62867585: length 1.2
  TOP w0.14: PU5.1 229.01,189.38 229.17,189.54 PR111.2
N63146067: length 6.8
  BOTTOM w0.254: PQ62.2 178.29,174.86 177.93,175.22 177.93,176.13 177.75,176.3 177.75,176.92 PC388.1 176.88,177.8 176.85,177.8 176.59,178.05 176.59,179.24 PR503.2
N63146116: length 6.4
  TOP w0.254: v1(179.3,175.91) 178.4,176.81 PQ12.2
  BOTTOM w0.254: PR502.2 PC387.1 179.06,179.35 179.56,178.85 v1(179.56,177.53) 179.56,176.37 179.3,176.1 v1(179.3,175.91)
N63146153: length 1.6
  BOTTOM w0.254: PQ62.3 178.31,177.85 178.28,177.88 PR504.2
N63146169: length 5
  TOP w0.14: v1(176.98,174.91) PQ12.1
  TOP w0.254: PQ12.1 178.07,175.21 v1(178.49,175.63)
  BOTTOM w0.254: v1(178.49,175.63) 178.72,175.86 178.72,176.09 178.93,176.3 178.93,178.27 PR504.1
N63146173: length 10.2
  TOP w0.254: PQ12.3 180.07,176.09 v1(181.04,177.06)
  BOTTOM w0.254: PR506.1 PR505.2 184.82,175.6 184.65,175.77 PC392.1 183.6,175.77 183.04,175.21 183.04,175.06 PQ61.2 182.61,174.88 182.3,175.2 182.3,175.81 182.6,176.11 182.6,177.23 182.32,177.51 181.49,177.51 v1(181.04,177.06)
N63148268: length 3.7
  BOTTOM w0.254: PR506.2 186.52,175.15 187.14,175.77 PR507.2 187.35,175.77 187.76,175.35 187.76,175.15 187.92,174.99 PR508.2 188.59,174.99 188.75,175.15 PR509.1
N63148362: length 12.3
  BOTTOM w0.14: PQ61.3 181.66,176.63 181.66,174.38 182.16,173.89 189.68,173.89 190.17,174.38 PR510.2
N64129205: length 5.2
  BOTTOM w0.102: 126.8,143.78 127.08,143.78 127.32,143.54 127.84,143.54 U42.CT24
  BOTTOM w0.14: R800.2 123.67,144.43 123.81,144.57 126.01,144.57 126.8,143.78
N64186431: length 7.8
  BOTTOM w0.102: 225.12,53.25 224.46,53.92 223.72,53.92 222.03,55.6 222.03,56 U49.BC48
  BOTTOM w0.14: 225.12,53.25 225.47,52.91 227.87,52.91 TP158.1
N64265500: length 4.6
  BOTTOM w0.14: U49.BG13 224.39,73.4 225.19,73.4 225.66,72.94 226.93,72.94 227.41,73.42 227.41,74.05 R948.1
N65800419: length 10.7
  TOP w0.14: PQ6.3 195.25,205.61 195.39,205.75 195.74,205.75 196.47,206.48 196.47,206.83 198,208.37 200.03,208.37 v1(200.54,207.86) 200.81,207.59 200.91,207.59 201.24,207.26 PQ7.2 201.24,205.91 v1(201.15,205.83)
  BOTTOM w0.14: PR410.2 200.85,205.52 v1(201.15,205.83)
N65800425: length 4.5
  TOP w0.14: PQ6.2 195.9,207.1 v1(196.38,207.58) 196.38,208.08 v1(196.09,208.37)
  BOTTOM w0.14: v1(196.38,207.58) 196.38,207.17 196.01,206.8 PR401.1 195.3,206.8 195.16,206.66 195.16,206.3 195.3,206.16 PR409.1
N65858536: length 5
  TOP w0.14: PR93.1 230.02,203.04 v1(229.49,203.04)
  TOP w0.203: PR98.1 232.48,203.81 PR94.2 232.48,203.83 232.34,203.97 231.82,203.97 v1(231.63,203.79)
  TOP w0.508: v1(231.63,203.79) 231.4,203.55 PR93.1
  BOTTOM w0.508: v1(231.63,203.79) 231.3,204.12 PR413.1
N65858616: length 2.1
  TOP w0.508: v1(231.51,205.56) 232.11,206.17 PQ9.2
  BOTTOM w0.508: v1(231.51,205.56) 231.75,205.8 PQ40.3
N65858620: length 3.8
  TOP w0.203: PR76.1 234.55,207.4 234.25,207.11 ; 234.25,207.11 234.58,206.78 PR84.1 ; 234.25,207.11 v1(234.25,207.11)
  BOTTOM w0.14: v1(233.18,207.48) 233.18,206.72 233.44,206.45 PQ40.2
  BOTTOM w0.508: v1(234.25,207.11) 234.25,207.1 234.05,206.9 PQ40.2
N65865868: length 3.8
  TOP w0.14: v1(202.57,204.18) 201.64,205.11 PQ7.3 200.59,204.38 200.65,204.32 PR97.1
N65865900: length 3.4
  TOP w0.508: PQ9.3 v1(233.23,205.52)
  BOTTOM w0.508: PR413.2 232.61,204.9 v1(233.23,205.52)
N66086348: length 4.6
  TOP w0.14: PR95.2 197.76,204.11 197.49,204.37 197.49,205.56 198.6,206.67 PQ8.2 v1(198.6,207.83)
N66086758: length 2.1
  TOP w0.508: PQ10.2 228.99,205.41 v2(228.99,205.01)
  BOTTOM w0.508: v2(228.99,205.01) 229.13,205.01 229.47,205.35 PR411.2
N66087447: length 3.8
  TOP w0.14: PR61.2 142.63,209.32 v1(142.09,208.79) 141.88,208.57 141.02,208.57 140.89,208.7 Q8.2
N78693073: length 2.7
  BOTTOM w0.14: Q96.2 119.74,144.39 119.64,144.49 119.64,144.74 119.78,144.89 Q96.3 120.36,145.24 120.3,145.3 R798.2
N78693124: length 14.7
  TOP w0.14: v1(115.6,145.07) 116.09,144.58 v1(120.99,144.58)
  BOTTOM w0.14: v1(120.99,144.58) 121.01,144.57 121.19,144.57 121.36,144.39 Q96.5 ; U41.4 113.4,144.15 R799.2 113.36,144.23 113.05,144.23 112.83,144.01 R801.2 112.12,144.01 111.62,144.51 111.62,145.07 111.99,145.44 115.23,145.44 v1(115.6,145.07)
N78802721: length 7.2
  BOTTOM w0.079: 148.24,154.52 148.25,154.51 148.25,153.58 U42.BD40
  BOTTOM w0.14: 148.24,154.52 147.67,155.09 147.67,157.51 148.26,158.11 148.26,159.16 TP93.1
N78802728: length 4.9
  BOTTOM w0.14: U42.BD41 148.54,154.75 148.04,155.26 148.04,157.27 148.74,157.97 TP101.1
N78802735: length 9.3
  BOTTOM w0.079: 147.92,154.33 148.04,154.21 148.04,153.15 148.22,152.97 148.22,151.66 U42.BD37
  BOTTOM w0.14: 147.92,154.33 147.29,154.96 147.29,157.53 147.98,158.22 147.98,159.13 TP92.1
N78802737: length 9.4
  BOTTOM w0.079: U42.BD36 148.54,150.71 148.04,151.21 148.04,152.85 147.92,152.98 146.85,152.98 146.65,153.18 146.65,154.21
  BOTTOM w0.14: TP100.1 146.65,157.54 146.65,154.21
N78802759: length 4.8
  BOTTOM w0.14: TP105.1 142.5,156.84 141.85,156.19 141.85,153.9 142.24,153.5 U42.BP40
N78802926: length 6.9
  BOTTOM w0.14: TP91.1 154.13,159.88 154.13,159.11 155.83,157.41 155.83,155.14 156.17,154.81 156.17,153.99 U42.AM41
N78802933: length 8.6
  BOTTOM w0.14: U42.AM40 155.91,153.6 155.91,154.76 155.59,155.08 155.59,157.31 153.82,159.08 153.82,159.58 153.07,160.33 TP89.1
N78802940: length 6.4
  BOTTOM w0.14: U42.AN41 155.57,154.06 155.57,154.78 155.35,155.01 155.35,157.21 153.47,159.09 TP96.1
N78963500: length 7.2
  BOTTOM w0.102: U49.C36 202.13,61.91 202.08,61.86 200.99,61.86 200.8,62.05 198.64,62.05 197.87,61.28
  BOTTOM w0.14: 197.87,61.28 196.83,61.28 TP155.1
N78963508: length 7.4
  BOTTOM w0.102: U49.D36 202.64,61.91 202.41,62.14 202.07,62.14 201.99,62.07 201.07,62.07 200.88,62.25 198.29,62.25 197.87,61.84
  BOTTOM w0.14: 197.87,61.84 197.59,61.56 TP154.1
N78963515: length 1.3
  TOP w0.14: TP71.1 206.53,61.66 v1(206.53,61.28)
  BOTTOM w0.102: U49.L36 206.14,61.67 v1(206.53,61.28)
N78963531: length 1.4
  TOP w0.14: v1(205.88,61.25) 205.29,61.25 TP74.1
  BOTTOM w0.102: v1(205.88,61.25) 205.64,61.49 U49.J37
N78983942: length 2.5
  BOTTOM w0.14: v1(236.93,45.88) R1157.2
  BOTTOM w0.508: R1157.2 235.41,45.47 D71.2
N78983951: length 2.3
  BOTTOM w0.14: v1(232.03,45.17) 232.26,45.4 R1160.2 232.69,46.06 D71.1
N79012469: length 1.9
  TOP w0.14: TP53.1 216.59,72.53 216.9,72.22 v1(217.25,72.22)
  BOTTOM w0.102: U49.AM15 216.94,72.53 217.24,72.23 217.24,72.23 v1(217.25,72.22)
N79039454: length 2
  TOP w0.14: v1(211.81,75.38) 211.86,75.33 212.26,75.33 TP51.1
  BOTTOM w0.102: v1(211.81,75.38) 211.81,75.33 212.32,74.83 U49.AC11
N79039460: length 1.6
  TOP w0.14: v1(211.82,74.52) 211.95,74.38 TP52.1
  BOTTOM w0.102: U49.AC12 212.31,74.08 211.87,74.52 v1(211.82,74.52)
N79070746: length 1.6
  TOP w0.14: v1(220.44,60.8) 220.6,60.96 TP72.1
  BOTTOM w0.102: U49.AW37 220.39,60.84 v1(220.44,60.8)
N79156031: length 2.1
  TOP w0.14: TP42.1 163.41,82.59 v1(163.53,82.7)
  BOTTOM w0.14: v1(163.53,82.7) JDIM2.162
N79156044: length 4
  TOP w0.14: TP32.1 164.29,88.63 164.29,87.96 v1(164.74,87.51)
  BOTTOM w0.14: JDIM2.165 164.28,87.98 v1(164.74,87.51)
N79156113: length 1.8
  TOP w0.14: R308.2 155.48,78.58 v1(155.35,78.45) 155.16,78.26 Q33.2
N79244319: length 2.2
  TOP w0.14: v1(163.42,97.51) 163.5,97.43 TP26.1
  BOTTOM w0.14: JDIM1.162 163.58,97.36 v1(163.42,97.51)
N79244333: length 3.9
  TOP w0.14: TP24.1 165.51,100.98 v1(165.51,101.67)
  BOTTOM w0.14: v1(165.51,101.67) 164.33,102.85 JDIM1.165
N79250891: length 2.7
  TOP w0.079: v2(33.97,74.13) 34,74.13 U16.J6
  BOTTOM w0.14: R935.2 33.89,76.14 33.89,74.2 v2(33.97,74.13)
N79252860: length 1.1
  TOP w0.203: R142.2 154.33,96.61 154.49,96.77 Q19.2
N79254828: length 0.8
  TOP w0.203: C256.2 168.35,89.12 R189.2
N79287073: length 1.3
  TOP w0.203: C437.2 R440.1
N79287127: length 2.9
  TOP w0.14: C440.1 166.04,67.81 166.37,67.48 v1(166.37,67.15) 166.7,67.15 166.95,66.9 U23.12
N79287181: length 5
  TOP w0.14: U23.66 184.7,59.3 184.84,59.16 v1(184.84,58.01) 185.17,58.01 185.34,58.18 185.83,58.18 186.11,57.9 186.11,57.52 186.34,57.29 R574.2
N79287203: length 6
  TOP w0.14: R474.2 188.39,66.66 188.23,66.82 186.93,66.82 186.7,66.59 C446.1 186.7,66.42 186.7,66.2 186.59,66.09 186.33,66.09 185.82,65.58 184.48,65.58 184.36,65.7 U23.82
N79287219: length 2.5
  TOP w0.14: R362.1 181.74,74.66 181.43,74.35 v1(181.13,74.35) 181.11,74.33 U23.99
N79287231: length 22.6
  TOP w0.14: R318.1 178.29,78.34 177.51,79.12 R317.1 174.87,79.12 174.68,78.93 v1(174.68,78.47) 174.68,77.84 R334.2 R335.2 ; v1(186.36,76.39) 185.88,76.87 185.08,76.87 184.71,76.5 R348.2
  IN3 w0.089: v1(186.36,76.39) 185.85,76.9 185.39,76.9 184.88,77.4 184.06,77.4 183.15,78.31 178.58,78.31 178.02,78.87 175.08,78.87 v1(174.68,78.47)
N79287237: length 5.9
  TOP w0.14: U23.2 167.11,70.9 166.87,71.14 166.87,71.79 v1(165.84,72.82) 165,72.82 164.86,72.68 C395.1 164.86,72.24 165.03,72.07 165.45,72.07 165.68,71.85 R406.2
N79287238: length 4.3
  TOP w0.14: R353.2 167.44,75.05 167.7,75.3 C369.1 168.32,75.3 168.55,75.08 168.55,74.89 v1(169.11,74.32) 169.51,73.93 U23.128
N79287282:
  vias: v1(255.65,55.67)
N79287301:
  vias: v1(252.36,56.66)
N79287317: length 4.4
  TOP w0.14: R493.1 164.22,63.29 164.95,63.29 165.71,64.05 166.47,64.05 v1(166.53,64) 166.82,63.7 U23.20
N79287363: length 5.1
  TOP w0.14: U23.24 167.03,62.1 165.98,61.05 164.66,61.05 164.45,60.85 163.79,60.85 R528.1
N79287372: length 5
  TOP w0.14: U23.25 167.02,61.7 166.07,60.74 164.75,60.74 164.57,60.57 163.87,60.57 R538.1
N79287384: length 1.9
  TOP w0.14: R455.2 185.43,67.7 U23.87
N79287387: length 4.7
  TOP w0.14: U23.15 167.01,65.7 166.93,65.77 164.91,65.77 164.73,65.59 164.17,65.59 163.78,65.98 R477.2
N79287457: length 3.5
  TOP w0.14: Q56.3 254.78,51.9 254.18,51.3 v1(253.47,51.3) 253.15,51.62 R615.2
N79287463: length 4.3
  TOP w0.14: U23.16 166.98,65.3 166.78,65.49 165.03,65.49 164.72,65.19 163.98,65.19 R483.2
N79287499: length 1.5
  TOP w0.14: TP77.1 181.87,56.38 181.91,56.42 U23.64
N79287500: length 3.2
  TOP w0.14: U23.65 184.12,58.9 184.26,58.76 184.26,56.4 TP76.1
N79447335:
  vias: v1(248.67,112.48)
N79447337: length 12
  TOP w0.14: 248.13,115.01 248.13,115.28 248.2,115.35 248.2,116.57 248.04,116.73 QG8.5 ; 248.13,115.01 248.13,114.22 248.27,114.08 CG401.1 248.83,114.08 249.14,113.77 250.71,113.77 250.75,113.73 RG93.1 251.23,113.25 251.04,113.06 QG15.3 ; 248.13,115.01 247.55,115.01 247.22,115.34 246.62,115.34 246.28,115.69 245.51,115.69 245.37,115.83 245.37,116.59 245.51,116.73 QG8.2
N79449214:
  vias: v1(230.53,117.69)
N79450667: length 2.7
  TOP w0.14: RG85.1 256.09,115.83 256.16,115.75 QG10.2 256.16,114.87 255.98,114.69 255.98,114.42 256.16,114.24 QG10.5
N79453383: length 1.9
  BOTTOM w0.14: UG7.7 RG133.1
N79546811: length 2.7
  BOTTOM w0.14: UG11.1 268.89,116.9 268.52,117.27 268.52,117.86 268.74,118.07 269.07,118.07 269.2,118.21 RG169.2
N79546831: length 5.3
  TOP w0.14: RG92.2 269.39,115.57 269.39,117.16 v1(268.99,117.56)
  BOTTOM w0.14: UG11.2 269.9,117.31 269.95,117.36 RG173.2 269.18,117.76 v1(268.99,117.56)
N79546869: length 0.9
  BOTTOM w0.14: RG172.2 266.72,117.52 266.83,117.41 UG10.1
N79546889: length 5.6
  TOP w0.14: RG91.2 268.87,115.83 268.87,116.82 268.57,117.13 267.84,117.13 v1(267.41,117.56)
  BOTTOM w0.14: RG170.2 267.41,118.04 v1(267.41,117.56) 267.49,117.48 267.49,116.9 UG10.2
N79558552: length 4.1
  TOP w0.14: QG15.2 250.38,112.56 250.24,112.7 250.24,113.15 249.9,113.49 248.32,113.49 RG99.2
N79558559: length 1
  TOP w0.14: RG99.1 247.17,112.93 247.44,113.19 247.49,113.19 247.62,113.33 RG94.2
N79575148: length 2.7
  TOP w0.14: RG96.1 235.06,113.58 CG403.1 RG95.1 235.84,114.01 235.63,114.22 UG2.5
N79575380: length 5.2
  TOP w0.14: DG1.3 244.54,113.88 243.82,114.6 242.95,114.6 242.56,115 241.89,115 RG88.2 242.03,114.66 242.34,114.66 242.48,114.52 QG14.2
N79956292: length 10
  TOP w0.152: v3(233.44,44.24) 233.72,44.52 234.42,44.52 235.6,45.7 240.35,45.7 241.46,44.59 241.7,44.59 v1(241.71,44.59)
  BOTTOM w0.152: PR644.2 241.43,44.76 241.61,44.59 v1(241.71,44.59)
  vias: v1(225.71,39.3) v3(228.04,39.69) v3(228.4,40.37) v3(228.81,39.69) v3(229.16,40.37) v3(229.59,39.69) v3(229.92,40.37) v3(230.41,39.71) v3(230.76,40.4) v3(231.12,44.24) v3(231.12,43.4) v3(231.31,38.87) v3(231.88,44.24) v3(231.88,43.4) v3(232.24,38.75) v3(232.64,44.24) v3(232.64,43.4) v3(233.4,43.4)
N79964562: length 2.5
  TOP w0.14: PR194.1 268.52,78.69 268.3,78.47 267.58,78.47 267.44,78.33 PR198.2 PR204.2
N79964568: length 6.6
  TOP w0.14: PQ19.3 275.9,84.75 275.72,84.93 v1(274.96,84.93) 274.56,84.53 PQ20.2 273.75,82.31 273.72,82.28 PR179.1 273.16,81.88 273.02,81.74 PR182.2
N79964844: length 6.8
  TOP w0.14: PR241.1 266.53,72.94 266.86,73.27 266.86,73.48 267.18,73.8 PC180.1 267.18,74.74 266.85,75.08 266.71,75.08 PC169.1 266.46,75.51 267,76.04 PC165.2 267.85,76.04 268.1,76.29 PR212.1 PR221.2
N79965031: length 2.5
  TOP w0.14: PR240.1 267.85,73.81 v1(267.85,74.05) 267.85,74.65 267.59,74.91 267.59,75.14 PC165.1
N79965205: length 2.8
  TOP w0.14: PR251.1 264.01,71.48 264.24,71.71 PC192.1 265.38,71.71 265.41,71.75 PC194.1 PR247.1
N79965238: length 12.2
  TOP w0.14: PR178.1 266.17,82.1 266.86,81.42 268.17,81.42 268.36,81.61 PC157.1 268.36,82.29 268.94,82.87 268.94,83.47 268.49,83.92 PR166.1 267.59,84.81 263.76,84.81 v1(263.71,84.76) 263.4,84.45 PR163.1
N79965309: length 0.8
  TOP w0.14: PC192.2 264.67,72.62 PR234.1
N79965319: length 2.6
  TOP w0.14: PC188.1 PR233.1 263.62,73.27 263.48,73.41 263.48,73.65 v1(263.11,74.01)
  BOTTOM w0.14: PR612.1 263,73.9 v1(263.11,74.01)
N79965429: length 1.7
  TOP w0.14: PR165.1 267.2,83.14 266.42,83.92 PR164.1
N79965651: length 1.2
  TOP w0.14: PR245.2 260.23,72.41 PR231.2
N79966658: length 1.5
  TOP w0.14: PR162.2 v1(284.55,82.26)
N79966767:
  vias: v1(279.91,86.96)
N80010015: length 3.2
  TOP w0.14: RG103.1 259.6,112.9 v1(259.6,113.11) 259.6,113.27 259.29,113.58 QG12.2 259.29,114.27 259.37,114.35 259.37,114.91 259.29,114.99 QG12.5
N80011119: length 3.1
  TOP w0.14: RG101.1 262.41,112.93 v1(262.41,113.13) 262.31,113.23 QG11.5 QG11.2
N80538567: length 6.8
  IN1 w0.086: v1(261.22,126.08) 261.38,126.25 v1(264.31,126.25)
  BOTTOM w0.14: R814.1 262.41,126.29 262.27,126.43 261.56,126.43 v1(261.22,126.08) 261.26,126.04 261.26,125.15 U43.4 ; v1(264.31,126.25) U44.2
N80539359:
  vias: v1(286.26,199.48)
N80539361: length 0.8
  BOTTOM w0.14: 283.72,193.38 v1(283.72,192.62)
N80546240: length 2.2
  BOTTOM w0.14: v1(280.74,194.34) 280.74,194.59 280.44,194.88 R727.1 280.44,195.44 280.77,195.77 Q82.3
N80546897: length 5.4
  TOP w0.14: R85.1 282.1,174.49 282.45,174.84 282.94,174.84 283.27,175.17 R83.1 283.82,175.17 283.93,175.07 R82.2 284.15,175.4 284.03,175.53 284,175.53 284,175.53 283.33,175.53 283.1,175.76 U4.2
N80546937: length 3.3
  TOP w0.14: R79.1 R80.2 R81.2 284.8,180.65 284.8,180.39 284.66,180.25 284.24,180.25 284.1,180.11 U4.5
N80547209: length 3.3
  TOP w0.14: QG2.3 283.05,171.32 282.65,171.72 R88.1 ; QG2.2 283.09,171.82 282.84,172.07 282.6,172.07 282.5,171.97 R88.1 ; R88.1 282.5,171.08 v1(282.32,170.9)
N80570435: length 5.6
  TOP w0.14: R434.2 C422.1 319.76,69.15 318.8,68.19 315.99,68.19 315.94,68.23 U20.35
N80570444: length 3.2
  TOP w0.14: C421.1 318.34,69.33 R435.2 317.02,69.33 v1(316.74,69.05) 316.32,68.63 U20.36
N80571375: length 4.4
  TOP w0.203: R454.2 319.38,67.49 316.11,67.49 316.06,67.43 U20.33
N80571553: length 2.8
  TOP w0.203: C445.2 317.96,67.19 316.55,67.19 316.39,67.03 U20.32
N80572115: length 3
  TOP w0.203: C469.1 317.28,62.83 315.88,64.23 U20.25
N80572629: length 1.6
  TOP w0.14: C407.2 314.55,70.78 314.15,70.38 U20.38
N80572801: length 5.3
  TOP w0.14: U20.39 313.75,70.37 314.1,70.73 314.1,71.26 314.43,71.59 v1(315.37,71.59)
  BOTTOM w0.14: v1(315.37,71.59) 315.26,71.49 C755.2 314.12,71.26 R957.2
N80576314: length 10.4
  TOP w0.14: R383.1 303.99,73.78 303.99,73.34 304.2,73.13 R390.2 304.68,73.13 305.08,72.73 305.08,72.48 R398.2 305.25,72.32 305.64,72.71 306.74,72.71 306.92,72.89 307.47,72.89 307.63,72.73 307.63,72.12 307.37,71.85 307.37,70.41 307.85,69.94 307.85,69.82 v1(307.85,69.81) 307.85,69.67 308.89,68.63 U20.1
N80631277: length 5.1
  TOP w0.203: U20.20 312.95,62.73 313.14,62.54 313.14,61.71 313.01,61.58 C483.1 313.01,61.09 C490.1
  TOP w0.508: C490.1 313.43,60.11 v1(313.06,60.11)
  BOTTOM w0.508: L22.1 313.31,60.36 v1(313.06,60.11)
N80631343: length 2.2
  TOP w0.203: v1(313.59,62) 313.59,62.52 313.35,62.77 U20.21
  BOTTOM w0.14: v1(313.59,62) 313.59,62.03 C778.1
N80633779: length 3.5
  TOP w0.14: C485.1 311.79,60.55 v1(311.53,60.29)
  TOP w0.203: C485.1 312.38,61.75 312.38,61.94 312.55,62.12 U20.19
N81193871: length 2
  TOP w0.14: U8.6 18.33,96.47 18.14,96.66 17.14,96.66 R147.2
N81193876: length 2.5
  TOP w0.14: U8.5 18.73,96.56 18.34,96.94 17.02,96.94 C189.2
N81194222: length 1.2
  TOP w0.14: C220.1 19.13,93.71 U8.11
N81194306: length 1.7
  TOP w0.14: U8.3 19.53,96.45 19.76,96.69 TP27.1
N81194319: length 1.2
  TOP w0.14: U8.4 19.13,97.12 TP25.1
N81194476: length 2.8
  TOP w0.14: v1(17.4,94.32) R162.2 R163.1 18.16,94.27 18.33,94.44 U8.9
N81195388: length 1
  TOP w0.14: C322.2 17.08,80.3 U15.5
N81195415: length 1.1
  TOP w0.14: R284.2 16.68,79.99 U15.6
N81195478: length 1.5
  TOP w0.14: TP45.1 18.01,79.78 17.87,79.64 U15.3
N81195507: length 1.5
  TOP w0.14: U15.4 17.47,79.93 TP44.1
N81195511: length 2
  TOP w0.14: U15.9 16.68,77.75 16.51,77.59 R342.1 R341.2
N81195559: length 1.2
  TOP w0.14: C356.1 17.47,77.02 U15.11
N81212064: length 10.7
  TOP w0.14: v1(150.85,210) 150.85,209.18 152.28,207.76 152.28,206.13 152.1,205.96 Q9.3 ; v1(149.53,210.3) v1(148.62,210.3) 148.62,209.03 148.06,208.48 148.06,208.1 147.8,207.84 U1.3
  BOTTOM w0.14: v1(150.85,210) 149.84,210 v1(149.53,210.3)
N81221610: length 6.5
  BOTTOM w0.254: LED2.2 148.15,218.65 148.41,218.4 148.41,216.74 148.16,216.49 v1(147.58,216.49) 145.38,216.49 145.09,216.19 R686.1
N81221622: length 8.3
  BOTTOM w0.254: LED2.1 146.75,217.8 v1(146.19,217.25) 145.88,216.94 143.01,216.94 142.76,216.68 142.76,216.4 142.49,216.13 141.35,216.13 140.74,216.74 R683.1
N81221647: length 7.3
  BOTTOM w0.508: Q74.6 146.7,214.35 147.6,215.25 v1(148.2,215.25) 150.28,217.32 LED2.6 LED2.5 LED2.4
N81221898: length 27.9
  IN4 w0.508: v1(145.4,211.16) 147.7,211.16 149.18,209.69 150.24,209.69 150.75,209.18 151.67,209.18 152.68,208.17 158.32,208.17 161.88,211.72 161.88,215.74 161.75,215.86 v1(161.75,216.95)
  BOTTOM w0.508: LED3.6 LED3.5 LED3.4 160.63,217.37 161.04,216.95 v1(161.75,216.95)
N81221918: length 3.6
  TOP w0.254: v1(162.09,219.15) 161.14,219.15 160.57,218.58 R4.1
  BOTTOM w0.254: v1(162.09,219.15) 162.44,219.5 LED3.1
N81221920: length 6.7
  BOTTOM w0.254: LED3.2 162.72,218.65 162.36,218.29 162.36,216.43 v1(162.01,216.09) 162.36,215.74 162.36,213.87 162.1,213.62 R695.1
N81221922: length 3.8
  BOTTOM w0.254: LED3.3 163.06,217.8 162.75,217.49 162.75,217.1 163.38,216.48 v1(163.38,216.18) 163.38,215.11 R694.1
N81223341:
  vias: v1(170.25,218.86) v1(172.98,219.29)
N81223347: length 65.7
  TOP w0.14: Q1.3 168.28,217.63 169.22,216.69 v1(169.43,216.69)
  IN3 w0.089: v1(169.43,216.69) 169.43,216.36 170.26,215.54 170.26,214.57 173.45,211.39 173.45,207.21 174.22,206.44 174.22,205.32 174.73,204.81 175.64,204.81 176.05,205.22 176.05,207.25 176.25,207.46 176.56,207.46 177.45,206.57 179.68,206.57 181.31,204.94 189.99,204.94 190.78,204.15 193.27,204.15 194.66,205.54 194.66,207.73 195.69,208.76 200.27,208.76 203.08,211.58 203.08,213.72 202.47,214.33 202.47,219.03 202.13,219.37 201.31,219.37 v1(201.07,219.13)
  BOTTOM w0.254: LED1.6 LED1.5 LED1.4 200.19,220 v1(201.07,219.13)
N81223387: length 3.2
  BOTTOM w0.254: v1(166.75,218.53) 167.04,218.24 R682.1 167.35,217.22 167.93,217.8 LED4.1
N81223389: length 5.9
  BOTTOM w0.254: R696.1 v1(166.95,215.77) 167.66,216.48 168.49,216.48 169.26,217.25 169.26,218.4 169.01,218.65 LED4.2
N81223391: length 8.6
  TOP w0.254: R5.1 v1(172.52,218.75)
  BOTTOM w0.254: LED4.3 169.16,219.5 169.66,219.01 169.66,217.36 170.24,216.77 171.63,216.77 172.16,217.31 172.16,218.39 v1(172.52,218.75)
N81223393: length 25.6
  TOP w0.254: R47.1 187.71,205.8 188.34,206.44 v1(188.34,206.46)
  IN3 w0.254: v1(188.34,206.46) 188.6,206.46 189.42,205.64 189.68,205.64 190.86,204.46 193.17,204.46 194.39,205.68 194.39,210.14 193.4,211.13 193.4,217.42 v1(194.92,218.94)
  BOTTOM w0.254: v1(194.92,218.94) 195.56,218.3 LED1.1
N81223395: length 23.8
  TOP w0.254: v1(189.61,206.21) 189.33,205.93 R48.1
  IN3 w0.254: v1(193.87,218.84) 193.04,218.02 193.04,210.99 194.03,210 194.03,205.83 193.02,204.81 191.01,204.81 v1(189.61,206.21)
  BOTTOM w0.254: v1(193.87,218.84) 194.49,219.47 195.65,219.47 195.96,219.15 LED1.2
N81223397: length 31.1
  TOP w0.254: v1(201.86,218.63) 201.75,218.53 200.87,218.53 199.92,219.48 v1(197.67,219.48) ; v1(191.01,205.7) 190.93,205.63 R49.1
  IN1 w0.254: v1(191.01,205.7) 191.01,204.38 191.39,204 193.93,204 196.83,206.9 198.48,206.9 202.72,211.14 202.72,217.77 v1(201.86,218.63)
  BOTTOM w0.254: LED1.3 197.14,220 v1(197.67,219.48)
N81224802:
  vias: v2(224.13,216.96)
N81224808: length 8.1
  IN2 w0.508: v1(234.39,218.53) 233.93,218.07 227.87,218.07 227.36,218.58 v1(227.36,219.26)
N81224848: length 8.8
  IN1 w0.254: v1(223.54,219.1) 224.52,218.12 228.49,218.12 v1(229.19,218.82)
  BOTTOM w0.254: LED5.1 228.96,219.5 229.19,219.27 v1(229.19,218.82) ; v1(223.54,219.1) 224,218.64 R678.1
N81224850: length 4.6
  BOTTOM w0.254: R690.1 226.39,215.69 226.61,215.91 v1(226.61,216.5) 226.61,217.32 227.93,218.65 LED5.2
N81224852: length 2.7
  BOTTOM w0.254: LED5.3 229.02,217.8 229.07,217.86 R680.1 v1(229.82,216.68)
N81224854: length 4.5
  TOP w0.254: v1(231.83,216.33) 230.7,216.33 229.83,217.2 R11.1
  BOTTOM w0.254: v1(231.83,216.33) 232.53,217.02 LED6.1
N81224856: length 2.4
  TOP w0.254: v1(231.64,218.69) 232.2,218.69 232.46,218.43 R7.1
  BOTTOM w0.254: LED6.2 231.74,218.65 231.7,218.69 v1(231.64,218.69)
N81224858: length 4.7
  TOP w0.254: R8.1 233.89,217.71 v1(234.55,217.05)
  BOTTOM w0.254: LED6.3 233.22,219.5 233.47,219.25 233.47,218.13 v1(234.55,217.05)
N81228094: length 1.4
  TOP w0.14: Q36.3 297.29,76.94 v1(298.07,76.16)
N81228098: length 4.2
  TOP w0.508: R289.2 296.96,80.88 297.28,80.56 298.25,80.56 298.91,79.9 v1(299.22,79.9) 299.55,79.9 299.58,79.93 Q34.3
N81229156: length 0.6
  TOP w0.14: 39.37,35.65 v1(39.37,35.01)
N81229164: length 1.1
  TOP w0.14: R654.2 v1(43.18,34.76)
N81246200: length 2.7
  BOTTOM w0.14: v1(278.01,196.18) 277.89,196.29 Q81.3
  BOTTOM w0.508: Q81.3 277.03,195.83 276.62,195.43 R730.2
N81246208: length 1.6
  BOTTOM w0.203: R724.2 274.55,197.98 274.94,197.59 Q81.6
N81246213: length 1.4
  BOTTOM w0.508: R729.2 272.77,194.8 Q86.3
N81660210: length 1.8
  BOTTOM w0.14: CN19.9 183.65,46.68 R1143.2
N81660211: length 1.9
  BOTTOM w0.14: R1144.2 183.93,46.72 183.93,46.09 184.15,45.87 CN19.8
N81660387: length 3.4
  BOTTOM w0.14: CN19.1 187.65,45.75 187.84,45.94 v1(187.84,46.7) 188.22,46.7 188.44,46.48 R1152.2 189.76,46.48 R1151.2
N81714774: length 3.5
  BOTTOM w0.14: R1126.2 185.19,48.97 U54.3 185.81,47.73 186.22,47.32 R1146.1 v1(185.43,47.09)
N81715455: length 2.7
  BOTTOM w0.14: R1152.1 189.68,48.14 v1(189.95,48.14) 190.56,48.75 Q114.3
N81715916: length 5.5
  TOP w0.14: v1(179.72,41.51) R643.1
  TOP w0.508: R631.2 182.92,41.89 Q61.3 181.63,41.24 181.36,41.51 R643.1
N81715961: length 1.2
  TOP w0.14: Q61.2 v1(184.26,39.09)
N81716020: length 6.8
  TOP w0.14: R1233.2 191.04,39.34 C874.1 190.52,40.19 190.38,40.04 189.84,40.04 189.69,40.2 R645.1 189.46,40.09 186.08,40.09 185.87,39.88 Q64.2
N81719173:
  vias: v1(220.34,40.48)
N81719273: length 7.2
  TOP w0.14: R1234.2 213.92,39.36 214.27,39.71 C875.1 214.27,40.23 213.72,40.78 213.72,42.51 214.71,43.49 R635.1 215.19,43.49 Q59.2
N81807638: length 6.2
  TOP w0.178: PC146.1 88.7,89.78 89.34,89.78 89.97,89.15 PU9.6 91.26,89.15 91.59,89.48 PU9.31
N81807642: length 7.7
  TOP w0.178: PU9.26 93.59,89.48 93.91,89.15 PU9.19 95.31,89.15 95.97,88.49 95.97,87.29 96.24,87.01 96.81,87.01 PC149.2
N81807662: length 1.9
  TOP w0.178: PU9.7 89.46,88.75 PC146.2
N81807690: length 4.2
  TOP w0.178: PC149.1 96.21,86.57 95.56,87.22 95.56,88.45 95.26,88.75 PU9.18
N81807757:
  vias: v1(89.26,90.92)
N81807781: length 6.6
  TOP w0.14: PU9.17 95.02,88.35 95.16,88.21 95.16,87.88 94.93,87.66 v1(94.54,87.66)
  BOTTOM w0.14: v1(94.49,91.69) 94.94,91.69 95.18,91.45 95.18,88.29 v1(94.54,87.66)
  vias: v1(96.3,91.94)
N81807999: length 7.9
  TOP w0.14: v1(96.49,87.57) 96.61,87.68 PR141.1
  TOP w0.178: PR147.1 90.94,86.25 91.31,86.62 v1(91.58,86.62)
  IN4 w0.203: v1(91.58,86.62) 91.58,86.23 91.78,86.03 93.8,86.03 95.35,87.57 v1(96.49,87.57)
N81808027: length 2.8
  TOP w0.178: PU9.8 90.11,88.35 89.92,88.16 89.92,87.67 89.58,87.33 PR143.1 PR142.2
N81808059: length 4.4
  TOP w0.178: PR153.1 PR147.2 90.52,85.34 90.35,85.5 90.35,86.14 91.59,87.38 PU9.10
N81808076: length 8.1
  TOP w0.14: PR154.1 88.4,84.29 88.57,84.29 88.66,84.39 v1(88.66,84.65) 88.66,84.95 88.45,85.17 PR152.2
  TOP w0.178: v1(92.78,86.7) 92.79,86.7 PU9.13
  IN4 w0.178: v1(88.66,84.65) 91.27,87.26 92.22,87.26 v1(92.78,86.7)
N81808078: length 3.9
  TOP w0.178: PR148.2 93.06,85.66 92.97,85.57 PC151.1 92.28,85.77 92.28,87.06 91.99,87.35 PU9.11
N81808084: length 2.7
  TOP w0.178: PR149.2 93.19,86.96 PU9.14
N81808086: length 3.3
  TOP w0.178: PU9.15 93.59,87.01 94.43,86.17 94.99,86.17 PR150.2
N81808088: length 3.7
  TOP w0.178: PU9.16 93.97,87.79 93.97,87.34 94.46,86.86 95.02,86.86 v1(95.15,86.73) 96.22,85.66 PR151.2
N81808152: length 0.8
  TOP w0.178: PR148.1 PC152.1
N81980636: length 4.4
  BOTTOM w0.14: R1175.1 15.66,35.03 15.66,35.43 v1(16.58,36.35) 16.99,36.35 17.15,36.19 17.15,35.7 17.29,35.56 Q117.3
N81980639: length 4.4
  BOTTOM w0.14: R1176.1 16.51,32.91 16.9,32.52 17.57,32.52 v1(18.2,33.15) 19.31,34.26 Q117.6
N81981614: length 3.5
  TOP w0.14: v1(32.39,58.13) 32.57,57.95 Q52.1 32.95,57.11 33.08,57.24 R569.2 R563.2 R556.2
N82151523: length 6.3
  TOP w0.14: R211.1 73.63,84.83 v1(73.79,84.67) 74.04,84.93 R228.2 R207.2 75.1,86.92 74.96,87.06 C267.1 74.55,87.59 74.43,87.72 Q24.3
N82151584: length 5.3
  TOP w0.14: v1(74.93,88.48) 73.54,88.48 73.27,88.22 Q24.2 71.86,89.08 C255.1 R182.2 Q21.3
N82154411: length 3
  TOP w0.14: U11.H6 60.47,89.67 60.47,90.71 60.36,90.83 60.36,91.34 60.56,91.55 60.7,91.55 TP30.1
N82154412: length 2.3
  TOP w0.14: TP39.1 61.22,85.17 60.85,85.54 60.53,85.54 60.35,85.72 60.35,86.14 60.52,86.31 U11.A6
N82154792: length 1.6
  TOP w0.102: U11.C6 61.06,87.63 v2(61.1,87.67)
  BOTTOM w0.14: v2(61.1,87.67) 60.74,87.67 TP135.1
N82161843: length 3.6
  TOP w0.14: U11.E8 57.08,88.43 56.53,88.98 R187.1
N82161861: length 5.9
  TOP w0.14: R263.1 63.73,83.31 63.73,84.52 63.43,84.82 62.84,84.82 62.08,85.58 61.92,85.58 61.58,85.92 61.58,86.3 61.32,86.57 U11.A4
N82161876: length 3
  TOP w0.14: U11.A3 61.72,86.7 61.86,86.55 62.09,86.55 62.71,85.93 v1(62.71,85.58)
  BOTTOM w0.508: v1(62.71,85.58) 62.63,85.5 62.63,84.78 R888.1
N82161891: length 3.1
  TOP w0.079: U11.B4 61.52,87.03 61.52,86.63 62.02,86.13 62.02,86.06 v1(62.06,86.01)
  BOTTOM w0.14: v1(62.06,86.01) 61.86,85.82 R887.1
N82161906: length 3.2
  TOP w0.14: R196.1 56.6,88.03 U11.D8
N82291980: length 5.6
  BOTTOM w0.14: R839.2 311.97,93.39 312.02,93.43 R836.2 R835.2 311.06,93.79 310.7,93.43 309.81,93.43 309.48,93.1 309.48,92.15 309.33,92 CN7.6
N82294378: length 2.4
  BOTTOM w0.14: CN7.24 309.69,87.51 310.04,87.85 TP131.1
N82296250: length 3.5
  BOTTOM w0.14: R1018.2 242.18,59.79 LG8.1 241.98,59.6 241.45,59.07 241.25,59.07 241.1,58.92 D65.1 241.13,58.63 241.61,58.15 241.61,58.12 241.78,57.95 R1026.1
N82296273: length 2.2
  BOTTOM w0.14: LG6.1 236.92,59.59 D63.1 236.92,58.38 R1022.1
N82296311: length 2
  BOTTOM w0.14: R1025.1 239.83,58.21 240.03,58.4 D64.1 240.03,59.44 LG7.1
N82364605: length 3.6
  BOTTOM w0.14: U50.C1 278.53,56.27 278.72,56.45 C805.1 279.46,56.76 279.65,56.95 R1045.1 279.65,58.01 v1(279.4,58.26)
N82364645: length 2.7
  BOTTOM w0.14: U50.C2 278.37,55.87 v1(278.69,55.54) 278.84,55.69 C810.1 279.46,55 R1060.1
N82368376: length 3.1
  BOTTOM w0.14: C809.1 286.06,56.1 286.28,56.32 R1051.1 285.65,56.63 v1(285.39,56.37) 285.03,56.01 U51.C1
N82368414: length 3.6
  BOTTOM w0.14: U51.C2 284.84,55.61 v1(285.38,55.07) 285.97,55.07 C813.1 286.06,54.77 286.26,54.57 286.85,54.57 287.06,54.36 R1063.1
N82537287: length 1.2
  BOTTOM w0.508: R747.2 v1(207.78,177.25)
N82537484:
  vias: v1(206.76,182.33)
N82537501: length 2.3
  TOP w0.203: U3.1 205.38,188.29 R69.2 R67.2
N82537584: length 0.9
  TOP w0.14: 210.95,182.46 211.46,182.46 v1(211.71,182.21)
N82538045:
  vias: v1(199.92,182.68)
N82538223: length 5.4
  TOP w0.14: v1(199.58,181.92) 199.58,182.53 v1(200.03,182.97) 200.52,183.46 U2.4
  BOTTOM w0.14: v1(199.58,181.92) 199.58,181 200.29,180.29 R745.1
