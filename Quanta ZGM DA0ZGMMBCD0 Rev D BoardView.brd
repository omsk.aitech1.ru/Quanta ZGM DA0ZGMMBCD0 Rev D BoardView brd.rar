# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
INT_DP2_D0#: length 159.1
  TOP w0.14: C57.2 160.27,156.92 160.27,157.31 v1(160.06,157.53)
  IN4 w0.086: v2(246.62,125.94) 246.44,125.76 245.46,125.76 244.51,124.8 244.51,122.11 244.01,121.61 244.01,120.53 241.55,118.06 241.55,117.62 240.52,116.6 240.52,115.75 238.18,113.41 231.73,113.41 231.64,113.5 231.64,113.94 231.45,114.14 230.87,114.14 230.67,113.94 230.67,113.5 230.59,113.41 230.17,113.41 230.08,113.5 230.08,114.04 229.88,114.25 229.33,114.25 229.11,114.02 229.11,113.5 229.02,113.41 228.6,113.41 228.52,113.5 228.52,113.94 228.27,114.19 227.79,114.19 227.54,113.94 227.54,113.5 227.46,113.41 227.04,113.41 226.95,113.5 226.95,114 226.75,114.19 226.18,114.19 225.98,114 225.98,113.5 225.89,113.41 225.47,113.41 225.39,113.5 225.39,114.1 225.19,114.3 224.61,114.3 224.42,114.1 224.42,113.5 224.33,113.41 223.91,113.41 223.82,113.5 223.82,114.1 223.62,114.3 223.05,114.3 222.85,114.1 222.85,113.5 222.76,113.41 222.34,113.41 222.26,113.5 222.26,114.1 222.06,114.3 221.48,114.3 221.29,114.1 221.29,113.5 221.2,113.41 220.78,113.41 220.69,113.5 220.69,114.1 220.5,114.3 219.92,114.3 219.72,114.1 219.72,113.5 219.64,113.41 219.21,113.41 219.13,113.5 219.13,114.1 218.93,114.3 218.35,114.3 218.16,114.1 218.16,113.5 218.07,113.41 217.65,113.41 217.56,113.5 217.56,114.1 217.37,114.3 216.79,114.3 216.59,114.1 216.59,113.5 216.51,113.41 216.08,113.41 216,113.5 216,114.1 215.8,114.3 215.22,114.3 215.03,114.1 215.03,113.5 214.94,113.41 204.33,113.41 203.63,112.71 197.69,112.71 193.62,116.78 193.62,123.68 188.28,129.02 188.28,142.91 184.76,146.43 184.49,146.43 184.26,146.2 184.13,146.2 183.83,146.5 183.83,146.62 184.06,146.85 184.06,147.13 183.32,147.87 183.04,147.87 182.66,147.49 182.54,147.49 182.24,147.79 182.24,147.91 182.62,148.29 182.62,148.57 182.21,148.98 181.94,148.98 181.55,148.59 181.43,148.59 181.13,148.89 181.13,149.01 181.52,149.4 181.52,149.68 180.67,150.52 179.72,150.52 176.65,153.59 175.97,153.59 175.85,153.71 173.97,153.71 172.88,154.8 172.6,154.8 172.09,154.29 171.95,154.15 171.83,154.15 171.53,154.45 171.53,154.57 172.09,155.13 172.18,155.22 172.18,155.5 171.77,155.91 171.5,155.91 170.84,155.26 170.72,155.26 170.42,155.55 170.42,155.68 171.07,156.33 171.07,156.61 170.67,157.02 170.39,157.02 169.73,156.36 169.61,156.36 169.31,156.66 169.31,156.78 169.97,157.44 169.97,157.72 169.56,158.12 169.28,158.12 168.63,157.47 168.51,157.47 168.21,157.77 168.21,157.89 168.86,158.54 168.86,158.82 168.25,159.44 164.72,159.44 163.44,158.15 160.56,158.15 160.36,157.96 160.36,157.84 v1(160.06,157.53)
  BOTTOM w0.102: v2(246.62,125.94) 246.47,125.79 246.21,125.79 246.1,125.89 246.1,126.17 246.79,126.86 246.79,127.57 246.58,127.79 246.58,128 246.57,128.01 246.47,128.33 246.31,128.58 UG6.BP16
INT_DP2_D0#_C: length 5.5
  TOP w0.102: 160.25,155.03 160.25,155 160.31,154.95 160.31,154.1 160.07,153.87 160.07,152.76 159.85,152.53 159.85,152.39 159.77,152.31 v2(159.67,152.31)
  TOP w0.14: 160.25,155.03 160.25,155.51 160.49,155.75 160.49,155.98 160.39,156.08 160.39,156.27 160.3,156.36 160.14,156.36 160.05,156.27 C57.1
  BOTTOM w0.14: U42.AG38 159.28,151.99 159.28,152.19 159.44,152.34 159.63,152.34 v2(159.67,152.31)
INT_DP2_D0_C: length 5.5
  TOP w0.102: v2(159.69,151.66) 159.7,151.67 160.01,152.13 160.05,152.24 160.05,152.36 160.11,152.5 160.28,152.67 160.28,153.79 160.51,154.02 160.51,154.95 160.57,155 160.57,155.03
  TOP w0.14: C58.1 160.81,155.62 160.57,155.38 160.57,155.03
  BOTTOM w0.14: U42.AG37 159.52,151.57 159.61,151.66 v2(159.69,151.66)
INT_DP2_D1: length 156.7
  TOP w0.14: C56.2 162.49,157.86 162.49,158.48 161.64,159.33 161.54,159.33 v1(161.41,159.46)
  IN4 w0.086: v1(161.41,159.46) 161.11,159.46 160.88,159.69 160.47,159.69 160.12,159.34 159.75,159.34 159.53,159.56 159.53,162.01 160.07,162.55 160.31,162.55 160.68,162.18 160.68,162.06 160.29,161.66 160.29,161.39 160.71,160.96 161.21,160.96 161.58,160.59 161.58,160.29 162.54,159.32 163.62,159.32 164.2,159.9 169.24,159.9 169.55,159.59 169.55,159.43 169.37,159.25 169.37,158.97 169.78,158.56 170.06,158.56 170.26,158.76 170.38,158.76 170.68,158.47 170.68,158.34 170.48,158.14 170.48,157.87 170.89,157.46 171.17,157.46 171.37,157.66 171.49,157.66 171.84,157.31 172.51,157.31 172.84,156.97 172.84,156.85 172.34,156.35 172.34,156.01 172.71,155.63 172.99,155.63 173.53,156.17 173.65,156.17 173.95,155.87 173.95,155.75 173.61,155.41 173.61,155.13 174.02,154.72 174.3,154.72 174.48,154.9 176.34,154.9 178.96,152.29 179.75,152.29 187.39,144.65 187.67,144.65 188.12,145.11 188.25,145.11 188.54,144.81 188.54,144.69 188.09,144.23 188.09,143.95 188.75,143.29 188.75,129.3 194.09,123.96 194.09,116.97 197.89,113.18 203.44,113.18 205.08,114.82 205.55,114.82 205.63,114.74 205.63,114.07 205.83,113.88 206.41,113.88 206.61,114.07 206.61,114.74 206.69,114.82 207.11,114.82 207.2,114.74 207.2,114.07 207.4,113.88 207.97,113.88 208.17,114.07 208.17,114.74 208.26,114.82 208.68,114.82 208.76,114.74 208.76,114.07 208.96,113.88 209.54,113.88 209.73,114.07 209.73,114.74 209.82,114.82 210.29,114.82 210.37,114.74 210.37,114.07 210.57,113.88 211.15,113.88 211.34,114.07 211.34,114.74 211.43,114.82 211.85,114.82 211.94,114.74 211.94,114.07 212.14,113.88 212.71,113.88 212.91,114.07 212.91,114.74 213,114.82 213.42,114.82 213.5,114.74 213.5,114.07 213.7,113.88 214.28,113.88 214.47,114.07 214.47,114.74 214.56,114.82 230.4,114.82 231.05,115.46 232.38,115.46 232.88,115.97 234.52,115.97 235.26,116.71 236.49,116.71 238.42,118.64 239.91,118.64 240.32,119.06 240.32,119.47 241.21,120.36 241.62,120.36 241.79,120.53 242.26,120.53 244.04,122.3 244.04,125.74 245.03,126.73 246.41,126.73 247.16,125.98 247.53,125.98 v2(247.73,125.78)
  BOTTOM w0.102: v2(247.73,125.78) 247.64,125.78 247.08,126.35 247.08,127.53 247.31,127.76 247.31,128 247.58,128.65 UG6.BP14
INT_DP2_D1#: length 156.7
  TOP w0.14: v1(161.07,158.89) 161.17,159 161.53,159 162.18,158.35 162.18,157.93 162.04,157.79 C55.2
  IN4 w0.086: v2(247.73,126.46) 247.77,126.42 247.77,126.26 247.68,126.17 247.24,126.17 246.49,126.92 244.95,126.92 243.85,125.82 243.85,122.38 242.18,120.71 241.71,120.71 241.54,120.55 241.14,120.55 240.13,119.55 240.13,119.14 239.83,118.83 238.35,118.83 236.41,116.9 235.19,116.9 234.44,116.15 232.81,116.15 232.3,115.65 230.97,115.65 230.32,115.01 214.48,115.01 214.29,114.81 214.29,114.15 214.2,114.06 213.78,114.06 213.69,114.15 213.69,114.81 213.5,115.01 212.92,115.01 212.72,114.81 212.72,114.15 212.64,114.06 212.21,114.06 212.13,114.15 212.13,114.81 211.93,115.01 211.35,115.01 211.16,114.81 211.16,114.15 211.07,114.06 210.65,114.06 210.56,114.15 210.56,114.81 210.37,115.01 209.74,115.01 209.55,114.81 209.55,114.15 209.46,114.06 209.04,114.06 208.95,114.15 208.95,114.81 208.76,115.01 208.18,115.01 207.98,114.81 207.98,114.15 207.9,114.06 207.47,114.06 207.39,114.15 207.39,114.81 207.19,115.01 206.61,115.01 206.42,114.81 206.42,114.15 206.33,114.06 205.91,114.06 205.82,114.15 205.82,114.81 205.63,115.01 205,115.01 203.36,113.37 197.96,113.37 194.28,117.05 194.28,124.04 188.93,129.38 188.93,143.37 188.27,144.03 188.27,144.15 188.73,144.61 188.73,144.89 188.32,145.3 188.05,145.3 187.59,144.84 187.47,144.84 179.82,152.48 179.03,152.48 176.42,155.09 174.4,155.09 174.22,154.91 174.1,154.91 173.8,155.21 173.8,155.33 174.14,155.67 174.14,155.95 173.73,156.35 173.45,156.35 172.91,155.82 172.79,155.82 172.53,156.08 172.53,156.27 173.03,156.77 173.03,157.05 172.59,157.49 171.92,157.49 171.57,157.84 171.29,157.84 171.09,157.64 170.97,157.64 170.67,157.94 170.67,158.07 170.87,158.27 170.87,158.54 170.46,158.95 170.18,158.95 169.98,158.75 169.86,158.75 169.56,159.05 169.56,159.17 169.74,159.35 169.74,159.67 169.32,160.09 164.13,160.09 163.54,159.51 162.62,159.51 161.77,160.36 161.77,160.67 161.29,161.15 160.79,161.15 160.48,161.46 160.48,161.59 160.87,161.98 160.87,162.26 160.39,162.74 159.99,162.74 159.34,162.09 159.34,159.49 159.68,159.15 160.2,159.15 160.55,159.5 160.8,159.5 161.17,159.14 161.17,158.99 v1(161.07,158.89)
  BOTTOM w0.102: v2(247.73,126.46) 247.73,126.35 247.62,126.24 247.47,126.24 247.28,126.43 247.28,127.45 247.52,127.68 247.52,127.89 UG6.BR14
INT_DP2_D1#_C: length 8
  TOP w0.102: v2(160.46,151.65) 160.46,151.45 160.56,151.35 160.83,151.35 161.03,151.55 161.03,154.71 161.25,154.93 161.25,155.01 161.27,155.03
  TOP w0.14: 161.27,155.03 161.52,155.29 161.52,156.32 162.17,156.97 162.17,157.21 162.02,157.36 161.82,157.36 C55.1
  BOTTOM w0.14: v2(160.46,151.65) 160.41,151.65 160.09,151.34 U42.AF37
INT_DP2_D1_C: length 8
  TOP w0.102: v2(160.44,150.98) 160.6,151.15 160.92,151.15 161.23,151.46 161.23,154.63 161.39,154.79 161.47,154.79 161.49,154.81
  TOP w0.14: 161.49,154.81 161.84,155.16 161.84,156.19 162.48,156.83 162.48,157.26 C56.1
  BOTTOM w0.14: U42.AF36 160.23,150.86 160.35,150.98 v2(160.44,150.98)
INT_DP2_D2: length 155.1
  IN4 w0.086: v2(247.99,127.66) 248.22,127.66 248.31,127.58 248.31,127.3 248.08,127.07 247.65,127.07 247.52,127.21 247.52,127.98 247.32,128.18 246.76,128.18 246.54,127.96 246.54,127.71 246.46,127.62 244.74,127.62 243.2,126.08 243.2,122.65 242.1,121.55 241.49,121.55 241.16,121.21 240.74,121.21 239.59,120.06 238.53,120.06 236.02,117.55 234.91,117.55 234.18,116.82 231.57,116.82 231.35,116.61 229.52,116.61 229.32,116.41 229.32,115.75 229.23,115.66 228.81,115.66 228.73,115.75 228.73,116.41 228.53,116.61 227.95,116.61 227.76,116.41 227.76,115.75 227.67,115.66 227.25,115.66 227.16,115.75 227.16,116.41 226.97,116.61 226.74,116.61 226.65,116.69 226.65,117.13 226.45,117.33 225.64,117.33 225.44,117.13 225.44,115.75 225.36,115.66 224.91,115.66 224.82,115.75 224.82,117.13 224.62,117.33 224.03,117.33 223.84,117.13 223.84,116.3 223.75,116.21 223.3,116.21 223.09,116 223.09,115.75 223,115.66 222.58,115.66 222.49,115.75 222.49,116 222.3,116.2 221.72,116.2 221.52,116 221.52,115.75 221.44,115.66 221.02,115.66 220.93,115.75 220.93,116 220.73,116.2 220.16,116.2 219.96,116 219.96,115.75 219.87,115.66 219.45,115.66 219.36,115.75 219.36,116 219.17,116.2 216.26,116.2 216.06,116 216.06,115.75 215.98,115.66 215.56,115.66 215.47,115.75 215.47,116 215.27,116.2 214.7,116.2 214.5,116 214.5,115.75 214.41,115.66 213.99,115.66 213.91,115.75 213.91,116 213.71,116.2 213.13,116.2 212.93,116 212.93,115.75 212.85,115.66 212.43,115.66 212.34,115.75 212.34,116 212.14,116.2 211.57,116.2 211.37,116 211.37,115.75 211.28,115.66 210.86,115.66 210.78,115.75 210.78,116 210.58,116.2 210,116.2 209.81,116 209.81,115.75 209.72,115.66 209.3,115.66 209.21,115.75 209.21,116 209.01,116.2 208.44,116.2 208.24,116 208.24,115.75 208.15,115.66 207.73,115.66 207.65,115.75 207.65,116 207.45,116.2 206.87,116.2 206.68,116 206.68,115.75 206.59,115.66 206.17,115.66 206.08,115.75 206.08,116.17 205.89,116.37 205.43,116.37 203.09,114.02 198.24,114.02 194.94,117.32 194.94,124.38 189.59,129.72 189.59,144.96 187.63,146.92 187.35,146.92 186.89,146.46 186.77,146.46 186.47,146.76 186.47,146.88 186.93,147.34 186.93,147.62 186.49,148.06 186.21,148.06 185.77,147.63 185.65,147.63 185.37,147.9 185.37,148.07 185.79,148.48 185.79,148.76 185.38,149.17 185.1,149.17 184.67,148.73 184.54,148.73 184.25,149.03 184.25,149.16 184.68,149.59 184.68,149.87 184.27,150.28 183.99,150.28 183.57,149.85 183.42,149.85 183.15,150.13 183.15,150.27 183.57,150.7 183.57,150.97 183.16,151.38 182.89,151.38 182.48,150.98 182.36,150.98 182.06,151.28 182.06,151.4 182.39,151.72 182.39,152.16 182.06,152.49 181.69,152.49 181.48,152.28 181.36,152.28 180.46,153.18 179.26,153.18 176.69,155.74 175.27,155.74 172.86,158.15 172.19,158.15 171.37,158.97 171.37,159.09 171.48,159.21 171.48,159.59 171.17,159.9 170.48,159.9 169.3,161.08 167.61,161.08 167.39,160.86 162.58,160.86 162.13,161.31 162.13,162.02 161.9,162.25 161.9,162.59 161.99,162.68 v1(162.4,162.68)
  BOTTOM w0.102: UG6.BT14 247.86,127.32 247.99,127.45 v2(247.99,127.66)
  BOTTOM w0.14: v1(162.4,162.68) 162.14,162.42 162.14,162.1 C643.2
INT_DP2_D2#: length 155.1
  IN4 w0.086: v2(248.7,127.67) 248.5,127.47 248.5,127.22 248.16,126.89 247.58,126.89 247.33,127.13 247.33,127.9 247.24,127.99 246.84,127.99 246.73,127.88 246.73,127.63 246.53,127.43 244.82,127.43 243.39,126 243.39,122.58 242.17,121.36 241.57,121.36 241.23,121.03 240.81,121.03 239.66,119.88 238.61,119.88 236.1,117.36 234.99,117.36 234.26,116.63 231.64,116.63 231.43,116.42 229.59,116.42 229.51,116.33 229.51,115.67 229.31,115.48 228.73,115.48 228.54,115.67 228.54,116.33 228.45,116.42 228.03,116.42 227.94,116.33 227.94,115.67 227.75,115.48 227.17,115.48 226.97,115.67 226.97,116.33 226.89,116.42 226.66,116.42 226.46,116.61 226.46,117.05 226.38,117.14 225.72,117.14 225.63,117.05 225.63,115.67 225.43,115.48 224.83,115.48 224.63,115.67 224.63,117.05 224.54,117.14 224.11,117.14 224.03,117.05 224.03,116.22 223.83,116.03 223.38,116.03 223.28,115.92 223.28,115.67 223.08,115.48 222.5,115.48 222.31,115.67 222.31,115.92 222.22,116.01 221.8,116.01 221.71,115.92 221.71,115.67 221.52,115.48 220.94,115.48 220.74,115.67 220.74,115.92 220.65,116.01 220.23,116.01 220.15,115.92 220.15,115.67 219.95,115.48 219.37,115.48 219.18,115.67 219.18,115.92 219.09,116.01 216.34,116.01 216.25,115.92 216.25,115.67 216.06,115.48 215.48,115.48 215.28,115.67 215.28,115.92 215.2,116.01 214.77,116.01 214.69,115.92 214.69,115.67 214.49,115.48 213.91,115.48 213.72,115.67 213.72,115.92 213.63,116.01 213.21,116.01 213.12,115.92 213.12,115.67 212.93,115.48 212.35,115.48 212.15,115.67 212.15,115.92 212.07,116.01 211.64,116.01 211.56,115.92 211.56,115.67 211.36,115.48 210.78,115.48 210.59,115.67 210.59,115.92 210.5,116.01 210.08,116.01 209.99,115.92 209.99,115.67 209.8,115.48 209.22,115.48 209.02,115.67 209.02,115.92 208.94,116.01 208.52,116.01 208.43,115.92 208.43,115.67 208.23,115.48 207.65,115.48 207.46,115.67 207.46,115.92 207.37,116.01 206.95,116.01 206.86,115.92 206.86,115.67 206.67,115.48 206.09,115.48 205.89,115.67 205.89,116.09 205.81,116.18 205.51,116.18 203.17,113.83 198.16,113.83 194.75,117.24 194.75,124.3 194.06,124.98 189.4,129.64 189.4,144.88 187.55,146.73 187.43,146.73 186.97,146.27 186.69,146.27 186.28,146.68 186.28,146.96 186.74,147.42 186.74,147.54 186.41,147.87 186.29,147.87 185.85,147.44 185.57,147.44 185.18,147.83 185.18,148.14 185.6,148.56 185.6,148.68 185.3,148.98 185.18,148.98 184.74,148.55 184.47,148.55 184.06,148.96 184.06,149.23 184.49,149.67 184.49,149.79 184.19,150.09 184.07,150.09 183.65,149.67 183.34,149.67 182.96,150.05 182.96,150.35 183.38,150.77 183.38,150.9 183.09,151.2 182.96,151.2 182.56,150.79 182.28,150.79 181.87,151.2 181.87,151.47 182.2,151.8 182.2,152.08 181.98,152.3 181.77,152.3 181.56,152.09 181.28,152.09 180.38,152.99 179.18,152.99 176.62,155.56 175.19,155.56 172.78,157.96 172.11,157.96 171.18,158.89 171.18,159.17 171.29,159.28 171.29,159.51 171.09,159.71 170.4,159.71 169.23,160.89 167.69,160.89 167.47,160.67 162.51,160.67 161.95,161.23 161.95,161.94 161.71,162.17 161.71,162.46 v1(161.5,162.68)
  BOTTOM w0.102: UG6.BT13 v2(248.7,127.67)
  BOTTOM w0.14: C642.2 161.83,162.06 161.83,162.35 v1(161.5,162.68)
INT_DP2_D2#_C: length 9.8
  BOTTOM w0.079: U42.AF40 160.06,153.08 160.13,153 160.31,153 160.38,153.08 160.38,154.61 160.68,154.91 160.68,155.1 161.86,156.28 161.86,156.66 161.78,156.74 161.78,156.76
  BOTTOM w0.14: 161.78,156.76 161.78,159.05 161.89,159.16 161.89,161.27 161.75,161.41 C642.1
INT_DP2_D2_C: length 9.8
  BOTTOM w0.079: 162.07,156.71 162.02,156.66 162.02,156.22 160.84,155.04 160.84,154.84 160.54,154.55 160.54,153.01 160.37,152.84 160.22,152.84 160.06,152.67 U42.AF39
  BOTTOM w0.102: 162.1,156.76 162.1,156.74 162.07,156.71
  BOTTOM w0.14: C643.1 162.21,161.23 162.21,159.03 162.1,158.92 162.1,156.76
INT_DP2_D3: length 157.1
  IN4 w0.086: v1(163.85,162.16) 163.72,162.16 163.52,161.95 163.52,161.66 163.66,161.51 166.92,161.51 167.15,161.73 169.58,161.73 170.21,161.1 170.93,161.1 172.91,159.12 172.91,159.03 175.54,156.4 176.98,156.4 177.66,155.72 178.18,155.72 178.88,155.02 178.88,154.54 179.52,153.9 181.57,153.9 190.24,145.23 190.24,130.03 195.59,124.68 195.59,117.59 198.51,114.68 202.82,114.68 206.12,117.98 206.75,117.98 206.94,117.79 206.94,117.05 207.03,116.96 207.45,116.96 207.54,117.05 207.54,117.79 207.73,117.98 208.31,117.98 208.51,117.79 208.51,117.04 208.59,116.95 209.01,116.95 209.1,117.04 209.1,117.79 209.3,117.98 209.88,117.98 210.07,117.79 210.07,116.94 210.16,116.85 210.58,116.85 210.67,116.94 210.67,117.79 210.86,117.98 211.44,117.98 211.64,117.79 211.64,116.94 211.72,116.85 212.14,116.85 212.23,116.94 212.23,117.79 212.43,117.98 213,117.98 213.2,117.79 213.2,116.94 213.29,116.85 213.71,116.85 213.8,116.94 213.8,117.79 213.99,117.98 214.57,117.98 214.77,117.79 214.77,116.94 214.85,116.85 215.27,116.85 215.36,116.94 215.36,117.79 215.56,117.98 216.13,117.98 216.33,117.79 216.33,116.94 216.42,116.85 216.84,116.85 216.92,116.94 216.92,117.79 217.12,117.98 217.7,117.98 217.89,117.79 217.89,116.94 217.98,116.85 218.4,116.85 218.49,116.94 218.49,117.79 218.69,117.98 219.26,117.98 219.46,117.79 219.46,116.94 219.55,116.85 219.97,116.85 220.05,116.94 220.05,117.79 220.25,117.98 220.83,117.98 221.02,117.79 221.02,116.94 221.11,116.85 221.53,116.85 221.62,116.94 221.62,117.79 221.81,117.98 222.39,117.98 222.59,117.79 222.59,116.94 222.67,116.85 223.1,116.85 223.18,116.94 223.18,117.79 223.38,117.98 228.36,117.98 228.56,117.79 228.56,117.35 228.65,117.26 229.07,117.26 229.15,117.35 229.15,117.79 229.35,117.98 229.9,117.98 230.1,117.79 230.1,117.56 230.18,117.47 233.91,117.47 234.64,118.21 235.74,118.21 236.81,119.28 236.81,119.43 236.3,119.93 236.3,120.36 236.69,120.75 237.1,120.75 237.56,120.29 237.83,120.29 237.96,120.42 237.96,120.82 237.75,121.04 237.75,121.32 238.31,121.87 239.34,121.87 239.79,121.42 240.01,121.42 240.46,121.87 240.88,121.87 241.35,122.34 241.93,122.34 242.51,122.93 242.51,125.61 242.72,125.81 242.72,126.65 244.4,128.33 245.58,128.33 245.66,128.42 245.66,128.95 245.95,129.23 246.97,129.23 247.07,129.33 247.07,129.75 247.29,129.98 247.96,129.98 248.18,129.76 248.18,129.11 248.42,128.86 248.42,128.66 v2(248.7,128.37)
  BOTTOM w0.102: UG6.BR13 v2(248.7,128.37)
  BOTTOM w0.14: v1(163.85,162.16) 163.67,161.99 163.67,161.4 163.22,160.95 163.22,160.69 C652.2
INT_DP2_D3#: length 157.1
  IN4 w0.086: v2(248,128.37) 248.24,128.61 248.24,128.79 247.99,129.03 247.99,129.68 247.88,129.79 247.37,129.79 247.26,129.67 247.26,129.25 247.05,129.04 246.03,129.04 245.85,128.87 245.85,128.34 245.66,128.14 244.47,128.14 242.9,126.57 242.9,125.73 242.7,125.53 242.7,122.85 242,122.15 241.43,122.15 240.96,121.68 240.54,121.68 240.09,121.23 239.72,121.23 239.26,121.68 238.38,121.68 237.94,121.24 237.94,121.12 238.15,120.9 238.15,120.35 237.91,120.1 237.48,120.1 237.02,120.56 236.77,120.56 236.49,120.28 236.49,120.01 236.99,119.5 236.99,119.2 235.81,118.02 234.72,118.02 233.99,117.29 230.1,117.29 229.91,117.48 229.91,117.71 229.82,117.8 229.43,117.8 229.34,117.71 229.34,117.27 229.14,117.07 228.57,117.07 228.37,117.27 228.37,117.71 228.29,117.8 223.46,117.8 223.37,117.71 223.37,116.86 223.17,116.66 222.6,116.66 222.4,116.86 222.4,117.71 222.31,117.8 221.89,117.8 221.81,117.71 221.81,116.86 221.61,116.66 221.03,116.66 220.84,116.86 220.84,117.71 220.75,117.8 220.33,117.8 220.24,117.71 220.24,116.86 220.05,116.66 219.47,116.66 219.27,116.86 219.27,117.71 219.18,117.8 218.76,117.8 218.68,117.71 218.68,116.86 218.48,116.66 217.9,116.66 217.71,116.86 217.71,117.71 217.62,117.8 217.2,117.8 217.11,117.71 217.11,116.86 216.92,116.66 216.34,116.66 216.14,116.86 216.14,117.71 216.06,117.8 215.63,117.8 215.55,117.71 215.55,116.86 215.35,116.66 214.77,116.66 214.58,116.86 214.58,117.71 214.49,117.8 214.07,117.8 213.98,117.71 213.98,116.86 213.79,116.66 213.21,116.66 213.01,116.86 213.01,117.71 212.93,117.8 212.5,117.8 212.42,117.71 212.42,116.86 212.22,116.66 211.64,116.66 211.45,116.86 211.45,117.71 211.36,117.8 210.94,117.8 210.85,117.71 210.85,116.86 210.66,116.66 210.08,116.66 209.88,116.86 209.88,117.71 209.8,117.8 209.38,117.8 209.29,117.71 209.29,116.96 209.09,116.76 208.52,116.76 208.32,116.96 208.32,117.71 208.23,117.8 207.81,117.8 207.72,117.71 207.72,116.97 207.53,116.77 206.95,116.77 206.75,116.97 206.75,117.71 206.67,117.8 206.2,117.8 202.89,114.49 198.43,114.49 195.4,117.52 195.4,124.6 190.06,129.95 190.06,145.15 181.49,153.72 179.44,153.72 178.7,154.46 178.7,154.94 178.1,155.53 177.58,155.53 176.9,156.21 175.46,156.21 172.72,158.95 172.72,159.04 170.85,160.91 170.13,160.91 169.5,161.55 167.22,161.55 167,161.32 163.58,161.32 163.33,161.58 163.33,161.94 v1(163.06,162.2)
  BOTTOM w0.102: UG6.BP13 v2(248,128.37)
  BOTTOM w0.14: C651.2 162.91,160.68 162.91,161.09 163.36,161.54 163.36,161.91 v1(163.06,162.2)
INT_DP2_D3#_C: length 8
  BOTTOM w0.079: 161.69,155.32 161.69,155.29 161.15,154.75 161.15,153.76 161,153.61 160.85,153.61 160.77,153.69 160.77,153.88 U42.AE41
  BOTTOM w0.14: C651.1 162.85,160.01 162.99,159.87 162.99,159.66 162.62,159.29 162.62,158.75 162.4,158.53 162.4,156.03 161.69,155.32
INT_DP2_D3_C: length 8
  BOTTOM w0.079: U42.AE40 160.82,153.38 160.9,153.46 161.07,153.46 161.31,153.7 161.31,154.69 161.7,155.08 161.8,155.08
  BOTTOM w0.14: C652.1 163.23,159.79 163.23,159.56 162.86,159.19 162.86,158.65 162.65,158.43 162.65,155.93 161.8,155.08
INT_DP_AUXN: length 19.6
  TOP w0.102: 250.35,124.68 250.35,124.7 250.29,124.76 250.29,131.95 249.9,132.34 249.56,132.34 249.39,132.52 v2(249.39,132.58)
  TOP w0.14: QG8.4 247.31,116.08 246.87,116.52 246.87,118.37 RG74.1 246.8,118.55 246.8,118.93 248.24,120.37 248.24,121.62 248.83,122.2 248.83,122.62 250.35,124.15 250.35,124.68
  BOTTOM w0.102: UG6.BJ11 v2(249.39,132.58)
INT_DP_AUXN_Q: length 317.7
  TOP w0.14: Q72.3 20.06,4.19 20.49,4.61 20.49,5.95 19.79,6.65 C561.2 19.79,6.9 20.09,7.21 v1(20.34,7.21) ; QG8.3 246.54,116.08 246.89,115.73 247.44,115.73 v1(247.7,115.46)
  IN1 w0.086: v1(247.7,115.46) 247.86,115.3 248.08,115.3 248.26,115.48 248.26,115.77 247.98,116.05 247.45,116.05 244.13,112.73 212.6,112.73 210.61,110.75 210.61,109.88 209.73,109 209.73,106.29 210.39,105.63 210.39,105.04 209.62,104.28 209.62,102.51 209.03,101.92 209.03,99.64 207.72,98.34 207.72,96.83 203.8,92.91 203.8,87.23 203.8,87.22 203.8,80.24 202.75,79.19 202.3,79.19 200.38,77.27 199.39,77.27 198.17,76.05 198.17,75.79 196.69,74.31 196.69,72.61 192.08,68 190.19,68 188.6,66.41 187.91,66.41 186.78,65.28 176.14,65.28 175.56,64.7 169.8,64.7 169.52,64.98 168.25,64.98 166.01,62.74 160.06,62.74 159.46,63.34 157.93,63.34 157.82,63.46 148.73,63.46 147.51,62.23 143.83,62.23 142.97,61.37 133.18,61.37 132.86,61.05 122.97,61.05 122.34,60.42 110.92,60.42 110.8,60.31 73.49,60.31 72.53,59.35 65.52,59.35 64.61,58.43 62.38,58.43 60.24,56.29 54.72,56.29 48.9,53.88 46.56,51.54 41.8,51.54 39.92,49.66 37.44,49.66 35.67,47.88 35.67,47.08 33.41,44.83 33.29,44.83 32.05,43.6 29.13,40.68 27.36,40.68 23.47,36.79 23.47,30.97 26.14,28.31 26.14,22.45 26.77,21.82 26.77,16.27 24.58,14.07 24.58,10.8 22.34,8.56 21.07,8.56 20.41,7.9 19.41,7.9 19.1,7.6 19.1,7.38 19.28,7.21 v1(20.34,7.21)
INT_DP_AUXP: length 18.1
  TOP w0.102: 250.03,124.68 250.03,124.7 250.09,124.76 250.09,131.87 249.82,132.14 249.56,132.14 249.4,131.98 v2(249.4,131.87)
  TOP w0.14: 250.03,124.68 250.03,124.28 248.51,122.75 248.51,122.33 247.93,121.75 247.93,120.5 246.48,119.06 246.48,118.91 246.23,118.65 RG73.1 246.55,118.11 246.55,117.57 246.36,117.38 QG8.1
  BOTTOM w0.102: UG6.BK11 v2(249.4,131.87)
INT_DP_AUXP_Q: length 316.8
  TOP w0.14: Q71.3 17.03,6.1 17.42,6.49 18.2,6.49 18.34,6.63 C560.2 18.34,6.95 18.05,7.25 v1(17.8,7.25) ; v1(248.71,115.97) 248.44,116.24 248.44,116.67 248.25,116.87 248.25,117.14 248.01,117.38 QG8.6
  IN1 w0.086: v1(17.8,7.25) 18.8,7.25 18.92,7.36 18.92,7.68 19.33,8.09 20.34,8.09 20.99,8.75 22.26,8.75 24.39,10.88 24.39,14.15 26.59,16.35 26.59,21.74 25.95,22.38 25.95,28.23 23.29,30.9 23.29,36.87 27.28,40.87 29.05,40.87 31.87,43.68 33.21,45.02 33.34,45.02 35.48,47.16 35.48,47.96 37.37,49.85 39.85,49.85 41.73,51.73 46.48,51.73 48.79,54.04 54.68,56.48 60.16,56.48 62.31,58.62 64.53,58.62 65.45,59.54 72.46,59.54 73.42,60.5 110.72,60.5 110.84,60.61 122.26,60.61 122.89,61.24 132.79,61.24 133.11,61.56 142.89,61.56 143.75,62.42 147.43,62.42 148.66,63.64 157.89,63.64 158.01,63.52 159.54,63.52 160.14,62.92 165.93,62.92 168.17,65.16 169.6,65.16 169.88,64.89 175.48,64.89 176.07,65.47 186.7,65.47 187.83,66.6 188.52,66.6 190.11,68.18 192,68.18 196.5,72.68 196.5,74.39 197.99,75.87 197.99,76.13 199.31,77.45 200.3,77.45 202.22,79.38 202.67,79.38 203.61,80.32 203.61,87.3 203.61,87.3 203.61,92.98 207.54,96.91 207.54,98.41 208.84,99.72 208.84,102 209.44,102.59 209.44,104.35 210.2,105.12 210.2,105.55 209.54,106.21 209.54,109.08 210.42,109.96 210.42,110.82 212.52,112.92 244.05,112.92 247.37,116.24 248.06,116.24 248.39,115.91 248.65,115.91 v1(248.71,115.97)
INT_EDP_AUXN: length 172.2
  TOP w0.14: v1(259.44,210.88) 261.64,210.88 261.87,210.65 261.87,210.19 262.01,210.05 262.38,210.05 262.52,210.19 262.52,210.65 262.66,210.79 263.82,210.79 263.9,210.87 v1(263.92,210.87)
  IN4 w0.086: v2(149.71,155.48) 149.71,155.37 149.54,155.2 148.99,155.2 148.63,155.56 148.63,164.09 155.25,170.71 171.69,170.71 173.92,172.94 190.07,172.94 197.5,180.37 203.83,180.37 206.02,182.57 206.02,184.18 211.36,189.52 220.56,189.52 221.03,189.99 229.46,189.99 229.99,189.46 235.47,189.46 236,189.99 260.35,189.99 260.84,189.5 264.54,189.5 265.85,190.8 265.85,193.56 265.85,198.14 264.9,199.09 264.9,204.68 264.9,204.69 264.9,208.91 265.25,209.26 265.25,211.29 265.04,211.51 264.43,211.51 264.24,211.32 264.24,210.94 264.1,210.81 263.96,210.81 263.92,210.85 v1(263.92,210.87)
  BOTTOM w0.079: v2(149.71,155.48) 149.71,155.38 149.86,155.23 150.18,155.23 150.53,154.88 150.53,153.75 150.59,153.68 150.77,153.68 150.85,153.76 U42.BA41
  BOTTOM w0.14: R706.2 259.62,210.7 v1(259.44,210.88)
INT_EDP_AUXN_R: length 1.7
  BOTTOM w0.14: R706.1 260.07,210.36 260.24,210.53 260.53,210.53 260.72,210.34 U37.11
INT_EDP_AUXP: length 172.2
  TOP w0.14: v1(264.63,210.85) 264.86,211.08 267.72,211.08 v1(267.74,211.05) 267.99,211.05 268.22,210.82 269.38,210.82 269.41,210.86 270.04,210.86 v1(270.16,210.74)
  IN4 w0.086: v2(149.74,154.88) 149.58,155.04 148.92,155.04 148.47,155.49 148.47,164.16 155.18,170.87 171.62,170.87 173.85,173.11 190,173.11 197.43,180.54 203.76,180.54 205.86,182.63 205.86,184.25 211.29,189.69 220.49,189.69 220.97,190.16 229.52,190.16 230.06,189.62 235.4,189.62 235.93,190.16 260.41,190.16 260.91,189.66 264.47,189.66 265.68,190.87 265.68,193.49 265.68,193.49 265.68,198.07 264.73,199.03 264.73,204.75 264.74,204.76 264.74,208.98 265.09,209.33 265.09,211.22 264.97,211.34 264.5,211.34 264.41,211.25 264.41,211.07 v1(264.63,210.85)
  BOTTOM w0.079: v2(149.74,154.88) 149.93,155.08 150.12,155.08 150.37,154.82 150.37,153.68 150.53,153.53 150.61,153.53 U42.BA40
  BOTTOM w0.14: R705.1 269.07,210.6 269.28,210.81 270.08,210.81 v1(270.16,210.74)
INT_EDP_AUXP_R: length 1.7
  BOTTOM w0.14: U37.5 268.05,210.97 R705.2
INT_EDP_TXN0: length 185
  IN4 w0.086: v1(269.47,214.36) 269.47,214.37 269.31,214.53 269.13,214.53 269.01,214.41 269.01,213.91 268.83,213.73 267.45,213.73 266.8,213.08 266.8,209.33 266.61,209.15 265.92,209.15 265.46,208.68 265.46,207.88 265.54,207.79 266.57,207.79 266.8,207.56 266.8,207.05 266.61,206.87 265.54,206.87 265.46,206.78 265.46,206.36 265.54,206.27 266.56,206.27 266.8,206.04 266.8,205.53 266.61,205.35 265.54,205.35 265.46,205.26 265.46,204.84 265.54,204.75 266.36,204.75 266.54,204.57 266.54,204.04 266.33,203.83 265.54,203.83 265.46,203.74 265.46,200.22 266.4,199.28 266.4,190.4 264.72,188.71 260.02,188.71 259.3,189.44 236.23,189.44 235.7,188.9 229.6,188.9 229.07,189.44 221.31,189.44 220.8,188.93 211.56,188.93 206.98,184.35 206.98,182.73 204.06,179.82 197.83,179.82 190.39,172.38 174.15,172.38 171.92,170.15 155.48,170.15 149.23,163.9 149.23,163.43 149.31,163.35 149.91,163.35 150.14,163.11 150.14,162.67 149.9,162.42 149.4,162.42 149.23,162.25 149.23,161.83 149.31,161.74 149.96,161.74 150.2,161.5 150.2,161.06 149.96,160.82 149.31,160.82 149.23,160.73 149.23,160.31 149.31,160.22 150.06,160.22 150.24,160.04 150.24,159.51 150.04,159.3 149.31,159.3 149.23,159.21 149.23,157.75 149.51,157.47 149.94,157.47 150.07,157.6 150.65,157.6 150.91,157.34 150.91,155.81 151.19,155.53 151.51,155.53 151.6,155.62 v2(151.6,155.8)
  BOTTOM w0.079: v2(151.6,155.8) 151.61,155.79 151.61,155.68 151.4,155.47 151.19,155.47 150.98,155.26 150.98,154.23 151.17,154.04 151.17,153.73 U42.AW40
  BOTTOM w0.14: C577.1 269.63,213.57 269.63,213.37 269.48,213.21 269.25,213.21 269.04,213.42 269.04,214.18 269.24,214.39 269.44,214.39 v1(269.47,214.36)
INT_EDP_TXN0_R: length 1.3
  BOTTOM w0.14: C577.2 270.4,213.26 270.77,213.26 270.8,213.29 U36.39
INT_EDP_TXN1: length 184.4
  IN4 w0.086: v2(152.76,152.31) 152.95,152.13 153.15,152.13 153.24,152.21 153.24,152.69 152.86,153.07 152.17,153.07 151.99,153.26 151.99,153.79 152.17,153.97 152.35,153.97 152.44,154.05 152.44,154.48 152.35,154.56 152.17,154.56 151.99,154.75 151.99,156.44 151.9,156.52 151.82,156.52 151.59,156.76 151.59,157.27 151.77,157.45 151.9,157.45 151.99,157.53 151.99,157.93 151.74,158.18 150.96,158.18 150.78,158.36 150.78,164.57 155.97,169.76 172.08,169.76 174.31,171.99 190.71,171.99 198.14,179.42 204.22,179.42 208.63,183.83 208.63,185.42 211.73,188.53 222.65,188.53 223.1,188.99 228.69,188.99 229.16,188.51 259.26,188.51 259.62,188.15 264.96,188.15 266.85,190.04 266.85,199.43 265.86,200.42 265.86,200.8 266.04,200.98 266.45,200.98 266.54,201.06 266.54,201.43 266.45,201.51 266.04,201.51 265.86,201.69 265.86,202.62 267.19,203.95 267.19,212.7 267.77,213.28 270.14,213.28 270.22,213.37 270.22,213.73 270.52,214.03 270.52,214.38 269.46,215.45 268.65,215.45 268.18,215.92 268.18,216.39 v1(267.81,216.76)
  BOTTOM w0.079: U42.AV38 152.44,151.99 v2(152.76,152.31)
  BOTTOM w0.14: v1(267.81,216.76) 268.09,217.03 268.09,217.33 268.38,217.62 272.13,217.62 272.61,217.14 272.61,216.51 272.5,216.4 272.5,216.28 272.61,216.17 C572.1
INT_EDP_TXN1_R: length 2
  BOTTOM w0.14: C572.2 272.51,215.53 272.51,215.4 272.99,214.92 272.99,214.63 273.2,214.42 U36.5
INT_EDP_TXN2: length 184.5
  IN4 w0.086: v1(277.05,217.6) 276.81,217.6 276.71,217.5 276.71,217.23 276.47,217 276,217 275.34,217.66 274,217.66 273.26,216.92 272.61,216.92 272.46,217.07 269.41,217.07 269.23,216.89 269.23,216.47 269.52,216.17 270.46,216.17 270.68,215.96 270.68,215.12 271.25,214.55 271.25,213.72 270.95,213.42 270.95,213.01 270.31,212.37 269.4,212.37 269.23,212.55 268.06,212.55 267.93,212.42 267.93,205.52 268.98,204.47 268.98,201.54 268.45,201 268.45,195.88 268.01,195.45 268.01,194.44 268.45,194 268.45,190.44 266.48,188.47 266.48,187.87 266.03,187.43 258.52,187.43 258.15,187.79 228.59,187.79 228.2,188.19 223.59,188.19 223.22,187.81 212.86,187.81 211.16,186.11 211.16,185.13 210.16,184.13 209.95,184.13 204.52,178.7 198.44,178.7 191.01,171.27 174.85,171.27 172.61,169.04 156.27,169.04 151.5,164.27 151.5,162.76 151.75,162.51 151.75,159.19 152.71,158.22 152.71,155.7 152.87,155.55 152.98,155.55 153.12,155.69 v2(153.12,155.76)
  BOTTOM w0.079: v2(153.12,155.76) 153.12,155.66 152.95,155.49 152.76,155.49 152.59,155.32 152.59,154.18 152.71,154.07 152.71,153.67 152.6,153.57 152.53,153.57 152.38,153.72 U42.AV41
  BOTTOM w0.14: v1(277.05,217.6) 276.98,217.6 276.8,217.43 276.8,216.38 276.94,216.24 C570.1
INT_EDP_TXN2_R: length 1.8
  BOTTOM w0.14: U36.14 276.8,214.42 276.72,214.49 276.72,214.92 276.77,214.97 276.77,215.57 C570.2
INT_EDP_TXN3: length 182.1
  IN4 w0.086: v1(274.32,206.66) 274.69,206.66 274.78,206.58 274.78,205.91 274.25,205.38 271.63,205.38 269.66,203.4 269.66,196.57 269.96,196.27 269.96,190.58 267.91,188.53 267.91,188.45 266.26,186.8 257.72,186.8 257.13,187.4 228.14,187.4 227.8,187.73 224.09,187.73 223.77,187.42 213.02,187.42 211.55,185.95 211.55,184.97 210.17,183.59 209.96,183.59 204.68,178.31 198.6,178.31 191.11,170.82 174.95,170.82 172.78,168.65 156.51,168.65 153.76,165.89 153.76,165.64 154.36,165.03 154.36,164.91 154.06,164.61 153.94,164.61 153.44,165.11 152.97,165.11 152.03,164.17 152.03,162.78 152.53,162.28 152.78,162.28 152.91,162.16 152.91,161.12 153.25,160.79 153.73,160.79 153.84,160.68 153.84,160.28 153.75,160.19 152.94,160.19 152.76,160.01 152.76,159.5 153.01,159.25 153.45,159.25 153.53,159.16 153.53,158.58 153.72,158.39 155.41,158.39 155.57,158.24 155.57,157.94 155.42,157.79 153.39,157.79 153.19,157.59 153.19,157.12 153.43,156.87 154.44,156.87 154.57,156.74 154.57,156.37 154.49,156.28 153.7,156.28 153.52,156.1 153.52,155.54 153.7,155.36 154.08,155.36 154.17,155.27 154.17,154.85 154.08,154.76 153.7,154.76 153.52,154.58 153.52,153.26 153.75,153.03 153.75,151.85 v2(153.54,151.64)
  BOTTOM w0.079: v2(153.54,151.64) 153.5,151.68 153.27,151.68 153.15,151.56 U42.AU37
  BOTTOM w0.14: C590.1 278.56,208.62 278.56,207.6 277.94,206.99 276.47,206.99 275.97,207.49 275.05,207.49 274.75,207.19 274.75,206.87 274.55,206.66 v1(274.32,206.66)
INT_EDP_TXN3_R: length 4
  BOTTOM w0.14: U36.20 277.41,211.69 277.52,211.8 277.68,211.8 278.04,211.43 278.04,210.46 278.68,209.83 278.68,209.35 278.54,209.21 278.39,209.21 278.31,209.29 C590.2
INT_EDP_TXP0: length 185
  IN4 w0.086: v2(151.6,155.16) 151.4,155.36 151.12,155.36 150.74,155.74 150.74,157.27 150.58,157.43 150.13,157.43 150.01,157.3 149.44,157.3 149.06,157.68 149.06,159.28 149.25,159.46 149.97,159.46 150.08,159.58 150.08,159.97 149.99,160.06 149.25,160.06 149.06,160.24 149.06,160.8 149.25,160.98 149.89,160.98 150.04,161.13 150.04,161.43 149.89,161.58 149.25,161.58 149.06,161.76 149.06,162.32 149.33,162.59 149.83,162.59 149.98,162.73 149.98,163.04 149.84,163.18 149.25,163.18 149.06,163.37 149.06,163.97 155.41,170.32 171.85,170.32 174.08,172.55 190.33,172.55 197.76,179.98 203.99,179.98 206.81,182.8 206.81,184.42 211.49,189.1 220.74,189.1 221.24,189.6 229.14,189.6 229.67,189.07 235.63,189.07 236.16,189.6 259.37,189.6 260.09,188.87 264.65,188.87 266.24,190.47 266.24,199.21 265.29,200.15 265.29,203.81 265.48,203.99 266.26,203.99 266.38,204.1 266.38,204.5 266.29,204.59 265.48,204.59 265.29,204.77 265.29,205.33 265.48,205.51 266.55,205.51 266.63,205.6 266.63,205.97 266.5,206.11 265.48,206.11 265.29,206.29 265.29,206.85 265.48,207.03 266.55,207.03 266.63,207.12 266.63,207.49 266.5,207.63 265.48,207.63 265.29,207.81 265.29,208.75 265.85,209.31 266.55,209.31 266.63,209.4 266.63,213.14 267.38,213.89 268.76,213.89 268.85,213.98 268.85,214.13 v1(268.61,214.36)
  BOTTOM w0.079: v2(151.6,155.16) 151.45,155.31 151.26,155.31 151.14,155.2 151.14,154.29 151.32,154.11 151.32,153.8 151.56,153.57 151.74,153.57 151.89,153.41 151.89,153.16 151.89,153.15 151.62,152.64 U42.AW39
  BOTTOM w0.14: v1(268.61,214.36) 268.78,214.2 268.78,213.3 269.14,212.94 269.5,212.94 C579.1
INT_EDP_TXP0_R: length 1.3
  BOTTOM w0.14: C579.2 270.25,212.99 270.64,212.99 270.75,212.89 U36.38
INT_EDP_TXP1: length 184.4
  IN4 w0.086: v1(268.66,216.76) 268.57,216.85 268.37,216.85 268.28,216.76 268.28,216.53 268.35,216.46 268.35,215.99 268.72,215.62 269.52,215.62 270.69,214.45 270.69,213.96 270.39,213.66 270.39,213.3 270.21,213.12 267.84,213.12 267.35,212.63 267.35,203.88 266.02,202.55 266.02,201.76 266.11,201.68 266.52,201.68 266.7,201.49 266.7,201 266.52,200.81 266.11,200.81 266.02,200.73 266.02,200.49 267.02,199.5 267.02,189.97 265.03,187.98 259.55,187.98 259.19,188.35 229.09,188.35 228.62,188.82 223.17,188.82 222.71,188.37 211.8,188.37 208.79,185.36 208.79,183.76 204.29,179.26 198.21,179.26 190.78,171.83 174.38,171.83 172.15,169.6 156.04,169.6 150.95,164.51 150.95,158.43 151.03,158.34 151.81,158.34 152.16,157.99 152.16,157.47 151.97,157.28 151.84,157.28 151.76,157.2 151.76,156.83 151.89,156.69 151.97,156.69 152.16,156.51 152.16,154.81 152.24,154.73 152.42,154.73 152.61,154.54 152.61,153.99 152.42,153.8 152.24,153.8 152.16,153.72 152.16,153.33 152.24,153.24 152.92,153.24 153.41,152.76 153.41,152.14 153.22,151.96 152.9,151.96 152.76,151.83 v2(152.76,151.66)
  BOTTOM w0.079: v2(152.76,151.66) 152.44,151.34 U42.AV37
  BOTTOM w0.14: v1(268.66,216.76) 268.49,216.76 268.35,216.9 268.35,217.21 268.49,217.35 272.02,217.35 272.34,217.03 272.34,216.62 272.23,216.51 272.23,216.34 272.07,216.17 C571.1
INT_EDP_TXP1_R: length 1.9
  BOTTOM w0.14: U36.4 272.8,214.44 272.72,214.52 272.72,214.81 272.24,215.29 272.24,215.47 C571.2
INT_EDP_TXP2: length 184.5
  IN4 w0.086: v2(153.12,155.12) 153.12,155.24 152.98,155.38 152.8,155.38 152.55,155.63 152.55,158.16 151.59,159.12 151.59,162.44 151.34,162.69 151.34,164.34 156.2,169.21 172.55,169.21 174.78,171.44 190.94,171.44 198.37,178.87 204.45,178.87 209.88,184.3 210.09,184.3 210.99,185.2 210.99,186.18 212.79,187.98 223.15,187.98 223.52,188.35 228.26,188.35 228.66,187.96 258.22,187.96 258.58,187.59 265.96,187.59 266.31,187.94 266.31,188.53 268.29,190.51 268.29,193.93 267.85,194.37 267.85,195.52 268.28,195.95 268.28,201.07 268.82,201.61 268.82,204.4 267.76,205.45 267.76,212.48 267.99,212.71 269.29,212.71 269.47,212.54 270.25,212.54 270.78,213.07 270.78,213.48 271.09,213.79 271.09,214.48 270.51,215.06 270.51,215.89 270.39,216.01 269.46,216.01 269.06,216.4 269.06,216.95 269.34,217.24 272.53,217.24 272.68,217.08 273.19,217.08 273.93,217.82 275.41,217.82 276.07,217.16 276.4,217.16 276.54,217.3 276.54,217.52 276.45,217.6 v1(276.2,217.6)
  BOTTOM w0.079: U42.AV40 152.51,153.41 152.67,153.41 152.86,153.61 152.86,154.13 152.74,154.25 152.74,155.25 152.82,155.33 152.96,155.33 153.12,155.16 v2(153.12,155.12)
  BOTTOM w0.14: v1(276.2,217.6) 276.54,217.27 276.54,216.5 C569.1
INT_EDP_TXP2_R: length 1.8
  BOTTOM w0.14: U36.13 276.4,214.44 276.46,214.5 276.46,215.03 276.51,215.08 276.51,215.57 C569.2
INT_EDP_TXP3: length 182.1
  IN4 w0.086: v1(275.17,206.66) 274.95,206.44 274.95,205.84 274.32,205.21 271.7,205.21 269.82,203.33 269.82,196.64 270.13,196.34 270.13,190.51 268.07,188.46 268.07,188.38 266.33,186.64 257.65,186.64 257.06,187.23 228.07,187.23 227.74,187.57 224.16,187.57 223.84,187.25 213.09,187.25 211.71,185.88 211.71,184.9 210.24,183.42 210.03,183.42 204.75,178.15 198.67,178.15 191.18,170.66 175.02,170.66 172.85,168.48 156.58,168.48 153.92,165.83 153.92,165.7 154.52,165.1 154.52,164.84 154.13,164.45 153.87,164.45 153.37,164.95 153.04,164.95 152.2,164.11 152.2,162.85 152.6,162.45 152.85,162.45 153.08,162.23 153.08,161.19 153.32,160.95 153.79,160.95 154,160.74 154,160.21 153.82,160.03 153.01,160.03 152.92,159.94 152.92,159.57 153.08,159.41 153.52,159.41 153.7,159.23 153.7,158.64 153.78,158.56 155.48,158.56 155.73,158.31 155.73,157.88 155.48,157.63 153.46,157.63 153.35,157.52 153.35,157.19 153.5,157.04 154.51,157.04 154.74,156.81 154.74,156.3 154.56,156.11 153.77,156.11 153.68,156.03 153.68,155.61 153.77,155.52 154.15,155.52 154.33,155.34 154.33,154.78 154.15,154.6 153.77,154.6 153.68,154.51 153.68,153.33 153.91,153.09 153.91,151.36 v2(153.54,150.99)
  BOTTOM w0.079: v2(153.54,150.99) 153.45,150.99 U42.AU36
  BOTTOM w0.14: v1(275.17,206.66) 275.02,206.81 275.02,207.08 275.16,207.22 275.86,207.22 276.36,206.72 278.06,206.72 278.82,207.49 278.82,208.62 C591.1
INT_EDP_TXP3_R: length 4
  BOTTOM w0.14: U36.19 277.44,212.09 277.46,212.06 277.79,212.06 278.31,211.54 278.31,210.57 278.95,209.94 278.95,209.44 C591.2
INT_ULT_DP_HPD: length 11
  TOP w0.14: R665.1 21.85,19.58 22.01,19.42 R666.1 22.41,20.23 v1(22.41,20.24) 22.94,20.77 24.14,20.77 24.38,20.53 26.63,20.53 26.78,20.68 26.78,21.82 26,22.6 26,23.27 25.9,23.37 R662.2
  BOTTOM w0.14: v1(22.41,20.24) 22.42,20.24 U56.32
JTAG_SEL: length 13
  TOP w0.102: v2(240.3,130.47) 239.83,130.01 239.83,129.08 244,124.91 244,124.68
  TOP w0.14: 244,124.68 244,123 243.18,122.18 TPG49.1 243.08,120.98 RG66.1
  BOTTOM w0.102: UG6.BL25 v2(240.3,130.47)
JTAG_TCK: length 7.5
  BOTTOM w0.102: UG6.BP25 240.27,128.4 240.27,127.8 240.55,127.51 240.55,127.11 240.01,126.57 240.01,123.22
  BOTTOM w0.14: 240.01,123.22 240.01,122.67 240.29,122.39 TPG56.1
JTAG_TCK_PCH: length 8.8
  BOTTOM w0.102: 218.29,84.34 218.06,84.34 217.76,84.04 217.76,83.5 217.82,83.44 217.82,82.63 217.6,82.41 217.52,82.41 216.93,81.82 216.93,80.86 216.52,80.45 216.52,79.18 216.74,78.96 216.74,78.67 216.77,78.64 216.77,78.04 216.69,77.96 216.69,77.67 216.7,77.66 U49.AM5
  BOTTOM w0.14: R873.1 TP139.1 218.29,84.34
JTAG_TDI: length 8.3
  BOTTOM w0.102: UG6.BT25 239.95,127.15 239.45,126.65 239.45,123.22
  BOTTOM w0.14: TPG59.1 240.71,120.93 239.45,122.19 239.45,123.22
JTAG_TDI_PCH: length 121
  TOP w0.102: 174.26,155.65 173.38,154.77 v2(173.38,152.85)
  TOP w0.14: 174.26,155.65 176.99,158.38 178.01,158.38 179.74,160.11 v1(179.74,160.6)
  IN2 w0.089: v1(220.93,83.69) 220.93,83.93 219.84,85.03 219.18,85.03 218.46,85.75 218.46,88.43 218.11,88.78 217.97,88.93 217.97,91.6 217.04,92.53 217.04,95.4 215.46,96.97 215.46,97.68 213.62,99.52 210.73,99.52 209.76,100.49 209.76,101.69 210.05,101.97 210.05,102.86 208.73,104.18 208.73,105.11 206.66,107.19 206.66,108.47 201.68,113.45 198,113.45 186.55,124.89 186.55,146.13 178.74,153.94 178.74,159.6 v1(179.74,160.6)
  BOTTOM w0.102: v2(173.38,152.85) 173.38,152.72 U42.F39 ; R907.1 220.53,83.19 220.35,83.01 220.35,82.9 220.04,82.6 220.04,82.4 219.62,81.98 219.4,81.98 218.9,81.47 218.65,81.47 218.35,81.18 218.35,81.01 217.94,80.6 217.94,79.78 217.64,79.48 217.64,78.79 217.6,78.75 217.6,78.46 217.46,78.32 U49.AN4
  BOTTOM w0.14: R907.1 220.93,83.44 v1(220.93,83.69) 220.93,83.96 220.6,84.29 R884.2 ; v1(179.74,160.6) 179.04,160.6 TP88.1 178.87,160.62 R765.1
JTAG_TDO: length 8.2
  BOTTOM w0.102: 239.73,123.22 239.73,126.63 240.3,127.2 240.3,127.47 239.95,127.82 UG6.BR25
  BOTTOM w0.14: TPG58.1 240.36,121.88 240.16,121.88 239.73,122.31 239.73,123.22
JTAG_TDO_PCH: length 119.4
  TOP w0.14: v1(175.43,160.41) 175.54,160.3 175.54,158.39 172.27,155.12 172.27,152.62 171.97,152.32 171.97,152.31 v2(171.96,152.3)
  IN2 w0.089: v1(219,83.78) 219,84.37 218.08,85.29 218.08,85.53 217.47,86.15 217.47,86.9 217.15,87.22 217.15,88.77 216.88,89.04 216.88,89.84 217.59,90.54 217.59,91.41 216.66,92.33 216.66,95.24 215.08,96.81 215.08,97.52 213.46,99.14 210.57,99.14 209.38,100.33 209.38,101.84 209.67,102.13 209.67,102.71 208.72,103.65 207.75,103.65 205.92,105.48 205.92,108.67 201.53,113.07 197.84,113.07 186.17,124.73 186.17,145.97 178.08,154.06 178.08,156.87 177.32,157.62 176.92,157.62 175.43,159.1 v1(175.43,160.41)
  BOTTOM w0.102: U49.AM3 217,78.4 217.22,78.61 217.22,78.91 217.23,78.92 217.23,79.65 217.54,79.95 217.54,80.46 217.33,80.66 217.33,81.65 217.69,82 217.77,82 218.23,82.46 218.23,82.87 R899.1 ; U42.G39 171.99,152.3 v2(171.96,152.3)
  BOTTOM w0.14: R764.1 175.63,159.64 TP94.1 175.41,160.38 v1(175.43,160.41) ; RS1.1 219.08,83.86 v1(219,83.78) 218.59,83.37 R899.1
JTAG_TMS: length 12
  BOTTOM w0.102: 239.17,123.22 239.17,126.74 239.63,127.2 239.63,129.1 UG6.BN25
  BOTTOM w0.14: TPG60.1 240.57,119.02 240.25,119.34 240.25,120.86 239.17,121.93 239.17,123.22
JTAG_TMS_PCH: length 113.6
  IN2 w0.089: v1(220.29,83.78) 220.29,84.31 219.76,84.84 218.97,84.84 218.27,85.54 218.27,86.61 217.34,87.55 217.34,88.85 217.07,89.12 217.07,89.76 217.78,90.46 217.78,91.49 216.85,92.41 216.85,95.32 215.27,96.89 215.27,97.6 213.54,99.33 210.65,99.33 209.57,100.41 209.57,101.77 209.86,102.05 209.86,102.78 208.54,104.1 208.54,105.03 206.47,107.11 206.47,108.39 201.61,113.26 197.92,113.26 186.36,124.81 186.36,146.05 178.27,154.14 178.27,157.26 v1(177.65,157.87)
  BOTTOM w0.102: R901.1 220.03,82.87 219.84,82.68 219.84,82.49 219.53,82.18 219.32,82.18 218.82,81.68 218.57,81.68 218.15,81.26 218.15,81.09 217.74,80.69 217.74,79.87 217.44,79.56 217.44,78.86 217.41,78.83 217.41,78.54 217.23,78.36 217.23,78.12 U49.AM4
  BOTTOM w0.14: R901.1 220.03,83.52 v1(220.29,83.78) 220.29,84.12 R883.2
  BOTTOM w0.203: U42.G41 172.33,154.54 173.27,155.48 174.74,155.48 176.82,157.56 TP109.1 177.33,157.56 v1(177.65,157.87) 177.31,158.21 177.31,158.4 R773.1
JTAG_TRST#: length 12
  TOP w0.102: v2(240.29,129.78) 240.29,128.91 244.3,124.9 244.3,124.68
  TOP w0.14: 244.3,124.68 244.28,124.65 244.28,121.32 v1(244.48,121.12) 244.48,120.99 243.84,120.36 RG67.2
  BOTTOM w0.102: UG6.BM25 v2(240.29,129.78)
JTAGX_PCH: length 108.2
  IN2 w0.089: v1(177.2,156.73) 177.55,156.39 177.55,153.97 185.14,146.37 185.14,125.15 197.66,112.63 201.35,112.63 205.49,108.5 205.49,105.3 208.95,101.84 208.95,100.15 210.39,98.71 212.02,98.71 216.18,94.55 216.18,88.99 216.72,88.45 216.72,87.04 216.94,86.81 216.94,86.02 217.58,85.39 217.58,84.26 v1(218.16,83.67)
  BOTTOM w0.102: v1(218.16,83.67) 218.03,83.54 218.03,82.55 217.69,82.21 217.6,82.21 217.13,81.74 217.13,80.58 217.33,80.38 217.33,80.04 217.03,79.73 217.03,79.11 216.97,79.05 U49.AM2
  BOTTOM w0.203: U42.G40 172.33,153.4 172.77,153.84 172.77,154.44 173.43,155.11 175.25,155.11 176.3,156.16 176.63,156.16 v1(177.2,156.73) 177.22,156.75 177.27,156.75 177.57,157.05 177.91,157.05 TP103.1 178.58,158.11 R771.1
KB_INT#_C: length 4.4
  TOP w0.14: R619.1 185.5,48.12 185.73,48.35 Q57.3 186.13,47.3 186.63,46.81 v1(186.63,46.36)
  BOTTOM w0.14: v1(186.63,46.36) 186.15,45.88 CN19.4
L_SPK+: length 64.4
  IN4 w0.762: 310.11,74.77 309.38,74.77 307.84,73.22 307.84,72.16 306.94,71.26 304.47,71.26 304.02,71.72 299.85,71.72 298.45,73.11 289.95,73.11 289.44,72.61 287.38,72.61 286.01,71.24 285.63,71.24 284.35,69.96 284.35,69.3 283.59,68.54 282.29,68.54 280.94,67.19 280.94,60.76 281.81,59.89 281.81,58.82 280.8,57.81 280.11,57.81 274.04,51.74 271.55,51.74 270.18,50.37 269.23,50.37 266.22,47.36 265.76,47.36
  vias: v1(264.92,48.39) v1(265.64,48.4) v1(310.96,74.74) v1(311.61,74.74)
L_SPK+_C: length 5.8
  IN1 w0.762: v1(265.9,41.02) 265.09,41.83 265.09,44.43 v1(265.17,44.51)
  BOTTOM w0.762: CN20.2 v1(265.9,41.02)
L_SPK-: length 66.5
  IN4 w0.762: 263.96,47.31 264.82,46.44 266.6,46.44 269.61,49.46 270.55,49.46 271.93,50.83 274.42,50.83 280.48,56.89 281.17,56.89 282.72,58.44 282.72,60.27 281.85,61.14 281.85,66.81 282.67,67.63 283.97,67.63 285.27,68.93 285.27,69.58 286.01,70.32 286.39,70.32 287.76,71.69 289.82,71.69 290.33,72.2 298.07,72.2 299.47,70.8 303.64,70.8 304.09,70.35 307.31,70.35 308.75,71.78 308.75,72.84 309.69,73.78 310.06,73.78
  vias: v1(263.57,48.4) v1(264.24,48.4) v1(310.85,73.67) v1(311.51,73.67)
L_SPK-_C: length 9.2
  IN1 w0.762: v1(264.17,44.51) 264.17,41.36 265.42,40.1 266.5,40.1 267.15,40.76 v1(267.15,41.1)
  BOTTOM w0.762: CN20.1 v1(267.15,41.1)
LAN_DISABLE: length 4.6
  BOTTOM w0.102: U49.AK46 215.86,56.87 215.86,56.2 215.86,55.91 215.92,55.85 215.92,54.81 216.21,54.53 216.21,53.69 216.62,53.28 216.62,53.25
  BOTTOM w0.14: TP160.1 216.62,53.25
LAN_PWR#: length 194
  TOP w0.14: R132.2 R136.2 301.76,97.58 301.18,97 v1(301.18,96.86) ; R483.1 162.94,65.37 v1(162.84,65.27)
  IN3 w0.089: v1(301.18,96.86) 301.18,96.29 300.04,95.16 300.04,92.76 297.11,89.83 297.11,88.49 296.57,87.94 294.48,87.94 293.84,87.3 293.84,86.28 292.19,84.63 291.18,84.63 288.17,81.62 288.17,80.13 284.57,76.54 284.1,76.54 282.2,74.64 282.2,73.42 281.5,72.72 279.76,72.72 279.22,72.18 279.22,71.61 279.83,71 279.83,70.48 279.21,69.85 278.36,69.85 277.54,69.03 277.54,63.03 278.97,61.6 278.97,59.71 278.3,59.04 278.3,58.16 277.64,57.5 276.67,57.5 276.09,56.92 274.56,56.92 273.68,56.05 271.58,56.05 270.8,56.82 265.79,56.82 264.44,55.47 263.09,55.47 260.63,53.01 257.12,53.01 256.81,53.32 252.46,53.32 251.93,52.79 250.7,52.79 249.7,53.79 247.51,53.79 246.85,53.13 243.31,53.13 241.29,51.11 237.84,51.11 236.97,50.23 232.99,50.23 232.83,50.07 230.23,50.07 229.82,49.66 224.89,49.66 223.75,48.52 223.53,48.52 222.51,47.49 221.48,47.49 220.94,46.96 220.94,46.24 220.38,45.68 218.79,45.68 218.65,45.54 211.92,45.54 211.65,45.8 210.15,45.8 208.42,44.08 200.37,44.08 199.72,44.73 197.89,44.73 197.69,44.93 194.85,44.93 194.2,45.59 191.06,45.59 187.6,49.05 184.58,49.05 183.51,50.12 183.51,50.21 182.98,50.74 182.24,50.74 181.97,51.01 179.22,51.01 177.07,53.15 173.56,53.15 173.21,52.79 172.32,52.79 171.48,53.63 170.97,53.63 170.77,53.83 170.77,55.25 169.62,56.41 164.81,56.41 v1(164.7,56.51)
  BOTTOM w0.14: v1(164.7,56.51) 164.7,57.48 163.54,58.64 163.54,61.69 163.89,62.03 163.89,62.96 163.35,63.5 163.35,64.76 v1(162.84,65.27)
LAN_WAKE#: length 5.1
  BOTTOM w0.102: U49.AH48 214.63,56.18 214.23,55.79 214.23,55 214.38,54.85 214.38,54.04 214.57,53.86 214.57,53.41 214.68,53.3 214.68,53.25
  BOTTOM w0.14: R1082.2 215.28,51.95 214.77,52.46 214.77,53.03 214.68,53.12 214.68,53.25
LANVCC: length 6.7
  TOP w0.508: Q18.3 v1(306.78,99.15) 307.14,99.51 310.1,99.51 310.61,99 v1(310.61,97.67)
LCD_BL_PWM: length 78.4
  TOP w0.14: QG2.5 284.37,171.82 284.11,171.57 284.11,171.07 283.93,170.88 283.27,170.88 282.69,170.31 v1(282.69,160.74) 282.69,156.95 281.01,155.27 281.01,136.13 v1(277.97,133.08)
  IN2 w0.089: v1(260.56,119.43) 260.6,119.47 260.6,122.98 258.35,125.23 v1(258.35,126.55) 261.22,129.43 264,129.43 265.09,130.52 275.4,130.52 277.96,133.08 v1(277.97,133.08)
  BOTTOM w0.102: v1(258.35,126.55) 258.57,126.77 258.57,129.02 256.77,130.82 UG6.BL1
  BOTTOM w0.14: v1(260.56,119.43) 260.54,119.41 RG167.1
LCD_BLEN: length 42.4
  TOP w0.14: TP19.1 279.86,122.04 276.81,125.08 272.44,125.08 272,124.64 269.91,124.64 268.28,123 268.28,122.42 268.53,122.16 268.53,121.48 268.3,121.25 267.67,121.25 266.85,122.06 v1(266.85,124.18)
  IN4 w0.086: v1(266.85,124.18) 266.44,124.6 263.75,124.6 261.23,127.12 261.23,127.4 259.25,129.38 259.25,130.92 257.95,132.22 257.2,132.22 255.78,133.64 253.27,133.64 v2(252.9,133.27)
  BOTTOM w0.102: UG6.BG7 v2(252.9,133.27)
  BOTTOM w0.14: v1(266.85,124.18) 266.74,124.07 U45.2 266.74,122.99 266.96,122.77 266.96,122.45 266.87,122.36 RG149.1
LCD_VDD: length 28.5
  TOP w0.102: 258.97,130.86 258.81,130.86 258.59,130.65 256.95,130.65 256.56,131.03 255.65,131.03 v2(255.62,131.06)
  TOP w0.14: 258.97,130.86 260.5,130.86 260.74,131.11 261.13,131.11 261.39,130.85 262.27,130.85 262.84,131.42 263.39,131.42 263.69,131.72 265.45,131.72 266.53,130.63 267.71,130.63 268.35,131.28 TP17.1
  IN4 w0.086: v2(255.62,131.06) 255.64,131.08 256.07,131.08 257.49,129.65 257.49,129.1 259.29,127.31 259.29,126.39 v1(259.88,125.8)
  BOTTOM w0.102: UG6.BK3 255.35,131.33 v2(255.62,131.06)
  BOTTOM w0.14: RG147.1 262.03,122.77 261.88,122.92 U43.2 261.88,124.03 261.25,124.66 260.1,124.66 259.88,124.88 v1(259.88,125.8)
LCDVCC: length 14.7
  IN2 w0.508: v1(284.86,189.42) 286.31,190.87 286.31,199.2 283.39,202.12 v1(283.39,202.27)
  vias: v1(269.99,209.51) v1(270.32,210.07) v1(270.64,209.5) v1(281.63,201.38) v1(282.16,200.93) v1(282.52,200.24)
