# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ61: length 49.5
  IN4 w0.102: 173.68,124.46 172.87,125.27 172.5,125.27 171.9,125.88 171.9,127.07 170.97,127.99 170.97,131.71 170.61,132.07 170.61,133.11 170.42,133.3 170.42,133.75 v2(169.98,134.19)
  IN4 w0.127: 173.68,124.46 176.62,121.52 178.31,121.52 180.95,118.88 180.95,110.09 183.39,107.65 183.39,107.25 183.51,107.12 183.89,107.12 184.01,107 184.01,101.98 182.39,100.36 182.39,98.99 182.27,98.86 181.98,98.86 181.86,98.74 181.86,98.47 181.98,98.34 182.47,98.34 182.61,98.2 182.61,97.92 182.47,97.77 181.81,97.77 v1(181.36,98.22)
  BOTTOM w0.102: v2(169.98,134.19) 169.66,133.86 U42.L9
  BOTTOM w0.216: JDIM1.232 181.08,97.17 180.91,97.34 180.91,97.77 v1(181.36,98.22)
M_B_DQ62: length 47.3
  IN4 w0.102: 175.24,127.37 174.24,128.37 174.24,128.75 173.38,129.61 173.38,131.61 172.95,132.04 172.95,132.46 171.78,133.63 v2(171.78,134.19)
  IN4 w0.127: v1(186.34,98.95) 186.74,98.95 186.87,99.08 186.87,99.51 186.74,99.63 186.23,99.63 186.1,99.76 186.1,100.03 186.23,100.16 186.4,100.16 186.52,100.29 186.52,102.51 186.76,102.74 186.76,103.23 186.8,103.27 186.8,107.42 183.62,110.6 183.62,119.39 179.17,123.84 177.85,123.84 177.14,124.56 177.14,125.47 175.24,127.37
  BOTTOM w0.102: U42.H9 171.46,133.86 v2(171.78,134.19)
  BOTTOM w0.216: v1(186.34,98.95) 186.29,98.95 185.58,98.23 JDIM1.250
M_B_DQ63: length 47.4
  IN4 w0.102: v2(171.8,132.24) 171.8,132.11 172.16,131.75 172.16,131.25 172.3,131.11 172.96,130.46 172.96,129.46 173.58,128.83 173.58,127.94 175.24,126.29
  IN4 w0.127: 175.24,126.29 176.37,125.15 176.37,124.24 177.57,123.05 178.89,123.05 182.86,119.08 182.86,110.28 186.04,107.11 186.04,103.58 185.99,103.54 185.99,103.06 185.76,102.82 185.76,100.79 184.73,99.76 184.73,99.36 184.52,99.15 184.24,99.15 184.06,99.33 184.06,100.36 185.29,101.59 v1(185.29,101.71)
  BOTTOM w0.102: U42.G7 172.12,132.56 v2(171.8,132.24)
  BOTTOM w0.216: JDIM1.245 184.33,102.67 v1(185.29,101.71)
M_B_DQSN0: length 63.5
  IN4 w0.102: v2(133.07,140.95) 132.83,141.2 132.83,141.39 132.61,141.61 132.09,141.61 132,141.52 130.87,141.52 130.73,141.65 122.85,141.65 122.83,141.67 122.81,141.67
  IN4 w0.127: 122.81,141.67 122.5,141.67 117.71,136.88 117.71,128.24 116.13,126.66 116.13,110.85 123.89,103.09 123.89,101.08 123.65,100.84 123.4,100.84 v1(123.16,101.08)
  BOTTOM w0.102: v2(133.07,140.95) 133.07,141.1 U42.CJ21
  BOTTOM w0.152: JDIM1.11 123.83,103.27 123.95,103.14 123.95,101.02 123.72,100.79 123.39,100.79 123.16,101.01 v1(123.16,101.08)
M_B_DQSN1: length 58.1
  IN4 w0.102: 122.98,135.22 122.99,135.23 122.99,135.26 124.44,136.71 125.88,136.71 126.07,136.89 129.38,136.89 130.37,137.88 131.29,137.88 131.56,137.61 132.53,137.61 132.87,137.95 132.87,138.2 v1(133.06,138.39)
  IN4 w0.127: v1(130.04,98.92) 129.79,98.67 129.6,98.67 129.47,98.81 129.47,99.97 129.93,100.43 129.93,103.24 120.19,112.98 120.19,118.56 122.65,121.02 122.65,134.88 122.98,135.22
  BOTTOM w0.102: U42.CJ16 132.73,138.06 v1(133.06,138.39)
  BOTTOM w0.152: JDIM1.32 129.08,97.23 129.24,97.39 129.24,98.35 129.53,98.64 129.76,98.64 v1(130.04,98.92)
M_B_DQSN2: length 45
  IN4 w0.102: v2(130.59,133.57) 130.42,133.39 130.25,133.39 129.87,133.01 129.87,131.72 129.45,131.29 129.42,131.29 129.35,131.22
  IN4 w0.127: v1(134.96,101.4) 134.79,101.56 134.13,101.56 133.87,101.83 133.87,102.8 134.52,103.46 134.52,103.72 130.54,107.7 130.54,120.6 131.09,121.15 131.09,121.44 131.42,121.77 131.42,121.99 131.2,122.21 130.92,122.21 130.52,121.81 130.14,121.81 129.68,122.27 129.68,122.65 130.14,123.11 130.14,123.29 129.85,123.59 129.67,123.59 129.25,123.17 128.93,123.17 128.52,123.58 128.52,124.22 128.94,124.64 128.94,125.07 128.55,125.47 128.55,126 128.92,126.38 128.92,126.84 128.55,127.22 128.55,127.75 128.95,128.16 128.95,128.57 128.61,128.91 128.61,130.48 129.35,131.22
  BOTTOM w0.102: U42.CN9 130.29,133.86 v2(130.59,133.57)
  BOTTOM w0.152: JDIM1.53 134.33,103.31 134.27,103.25 134.27,101.92 134.56,101.62 134.73,101.62 v1(134.96,101.4)
M_B_DQSN3: length 43.5
  IN4 w0.102: 134.59,125.28 134.58,125.29 134.56,125.29 134.32,125.54 134.32,129.36 134.32,129.36 134.32,133.59 133.83,134.08 v2(133.83,134.16)
  IN4 w0.127: v1(140.18,99.06) 140.18,98.96 140.05,98.83 139.49,98.83 139.36,98.96 139.36,99.18 139.69,99.51 139.69,99.89 139.36,100.21 139.36,105.69 139.06,105.99 138.89,105.99 138.48,106.4 138.48,106.57 138.1,106.94 137.94,106.94 137.69,107.19 137.69,107.36 137.33,107.72 137.16,107.72 136.84,108.04 136.84,108.2 136.36,108.69 136.19,108.69 135.91,108.97 135.91,109.14 135.69,109.35 135.69,124.18 134.59,125.28
  BOTTOM w0.102: U42.CH9 133.41,133.93 133.65,134.16 v2(133.83,134.16)
  BOTTOM w0.152: v1(140.18,99.06) 140.18,99.01 140.03,98.86 139.61,98.86 139.25,98.49 139.25,97.54 139.58,97.21 JDIM1.74
M_B_DQSN4: length 43.1
  IN4 w0.102: 159.7,124.17 159.72,124.19 159.72,125.31 159.14,125.89 159.14,128.19 159.41,128.46 160.06,128.46 160.37,128.77 160.37,133.75 160.59,133.97 160.68,133.97 v1(160.9,134.19)
  IN4 w0.127: v1(168.28,101.33) 168.12,101.48 167.6,101.48 167.33,101.75 167.33,106.73 162.83,111.23 162.83,111.7 163.1,111.97 163.1,112.37 162.97,112.49 162.87,112.49 162.59,112.77 162.59,113.35 162.85,113.61 162.97,113.61 163.1,113.74 163.1,118.15 159.7,121.55 159.7,124.17
  BOTTOM w0.102: U42.AF9 160.81,134.19 v1(160.9,134.19)
  BOTTOM w0.152: v1(168.28,101.33) 168.12,101.49 167.79,101.49 167.33,101.95 JDIM1.177
M_B_DQSN5: length 45
  IN4 w0.102: v1(164.29,133.59) 164.29,133.47 164.39,133.36 164.57,133.36 164.79,133.14 164.79,132.44 164.45,132.09 164.45,130.26 164.13,129.94 164.13,127.28 163.74,126.89 163.74,124.21 163.76,124.19
  IN4 w0.127: 163.76,124.19 163.76,123.24 167.16,119.84 167.16,113.15 173.92,106.4 173.92,102.55 174.01,102.45 174.01,101.11 172.63,99.73 172.63,98.91 172.76,98.78 172.94,98.78 173.14,98.99 v1(173.14,99.06)
  BOTTOM w0.102: v1(164.29,133.59) 164.1,133.59 U42.Y9
  BOTTOM w0.152: v1(173.14,99.06) 173.14,98.97 172.99,98.81 172.74,98.81 172.4,98.47 172.4,97.39 172.58,97.22 JDIM1.198
M_B_DQSN6: length 45.3
  IN4 w0.102: 168.5,124.34 168.48,124.36 168.45,124.36 167.75,125.06 167.75,125.32 167.93,125.49 167.93,125.91 167.74,126.09 167.74,126.26 168.01,126.53 168.01,132.98 168.4,133.37 168.4,133.72 168.09,134.03 167.78,134.03 167.6,134.22 v1(167.6,134.22)
  IN4 w0.127: 168.5,124.34 168.84,124 169.02,124 169.13,124.11 169.51,124.11 169.92,123.7 169.92,123.32 169.81,123.21 169.81,123.03 170.05,122.79 170.67,122.79 170.98,122.48 170.98,114.74 174.35,111.38 175.21,111.38 179.65,106.94 179.65,103.77 179.24,103.36 179.24,101.79 178.97,101.52 178.59,101.52 v1(178.43,101.36)
  BOTTOM w0.102: U42.R9 167.16,133.98 167.4,134.22 v1(167.6,134.22)
  BOTTOM w0.152: JDIM1.219 177.83,103.33 177.57,103.08 177.57,101.81 177.87,101.51 178.28,101.51 v1(178.43,101.36)
M_B_DQSN7: length 48.2
  IN4 w0.102: 174.34,125.13 174.29,125.17 173.9,125.17 173.24,125.83 172.7,125.83 172.38,126.15 172.38,127.42 171.39,128.41 171.39,132 171.2,132.2 171.2,132.93 171.45,133.19 171.45,133.71 171.23,133.94 171.03,133.94 170.87,134.1 v2(170.87,134.19)
  IN4 w0.127: v1(183.62,99.27) 183.62,99.18 183.42,98.98 183.21,98.98 183.07,99.13 183.07,100.06 184.69,101.68 184.69,107.3 181.63,110.37 181.63,119.16 178.58,122.2 177.26,122.2 174.34,125.13
  BOTTOM w0.102: v2(170.87,134.19) 170.87,134.18 U42.K9
  BOTTOM w0.152: v1(183.62,99.27) 183.46,99.1 183.11,99.1 182.82,98.81 182.82,97.49 183.08,97.23 JDIM1.240
M_B_DQSN8: length 2.3
  TOP w0.14: v1(144.58,103) 144.47,103.11 R115.1
  BOTTOM w0.14: v1(144.58,103) 144.83,103.24 JDIM1.95
M_B_DQSP0: length 63.5
  IN4 w0.102: 122.81,141.43 122.83,141.43 122.85,141.45 130.65,141.45 130.78,141.32 132.08,141.32 132.17,141.41 132.52,141.41 132.62,141.31 132.62,141.15 v1(132.41,140.94)
  IN4 w0.127: 122.81,141.43 122.6,141.43 117.95,136.78 117.95,128.14 116.37,126.56 116.37,110.95 124.13,103.19 124.13,100.98 123.75,100.6 123.45,100.6 v1(123.18,100.32)
  BOTTOM w0.102: U42.CK21 132.41,141.11 v1(132.41,140.94)
  BOTTOM w0.152: JDIM1.13 124.33,103.27 124.2,103.14 124.2,100.92 123.82,100.54 123.33,100.54 123.18,100.39 v1(123.18,100.32)
M_B_DQSP1: length 58.2
  IN4 w0.102: v2(132.41,138.36) 132.52,138.36 132.66,138.21 132.66,138.03 132.45,137.81 131.65,137.81 131.38,138.08 130.28,138.08 129.3,137.1 125.98,137.1 125.8,136.91 124.36,136.91 122.86,135.41 122.83,135.41 122.81,135.39
  IN4 w0.127: v1(130.08,98.25) 129.89,98.43 129.5,98.43 129.23,98.71 129.23,100.07 129.69,100.53 129.69,103.14 119.95,112.88 119.95,118.66 122.4,121.12 122.4,134.98 122.81,135.39
  BOTTOM w0.102: v2(132.41,138.36) 132.08,138.03 U42.CK16
  BOTTOM w0.152: v1(130.08,98.25) 129.93,98.4 129.63,98.4 129.48,98.25 129.48,97.32 129.58,97.23 JDIM1.34
M_B_DQSP2: length 45
  IN4 w0.102: 129.52,131.05 129.59,131.12 129.59,131.15 130.08,131.63 130.08,132.93 130.34,133.19 130.54,133.19 130.65,133.07 130.65,132.92 130.6,132.87 v2(130.6,132.87)
  IN4 w0.127: v1(134.94,102.28) 134.94,101.96 134.78,101.8 134.23,101.8 134.11,101.93 134.11,102.7 134.76,103.36 134.76,103.82 130.78,107.8 130.78,120.5 131.33,121.05 131.33,121.34 131.66,121.67 131.66,122.09 131.3,122.45 130.82,122.45 130.42,122.05 130.24,122.05 129.92,122.37 129.92,122.55 130.39,123.01 130.39,123.39 129.95,123.83 129.57,123.83 129.15,123.41 129.03,123.41 128.76,123.68 128.76,124.12 129.18,124.54 129.18,125.17 128.79,125.57 128.79,125.9 129.17,126.28 129.17,126.94 128.79,127.32 128.79,127.65 129.2,128.06 129.2,128.67 128.85,129.01 128.85,130.38 129.52,131.05
  BOTTOM w0.102: U42.CN8 130.14,133.14 130.14,133 130.27,132.86 130.6,132.86 v2(130.6,132.87)
  BOTTOM w0.152: JDIM1.55 134.83,103.47 134.51,103.15 134.51,102.02 134.66,101.86 134.81,101.86 134.94,101.99 v1(134.94,102.28)
M_B_DQSP3: length 43.5
  IN4 w0.102: v2(133.78,133.53) 133.86,133.61 134.01,133.61 134.11,133.51 134.11,129.28 134.11,129.28 134.11,125.46 134.29,125.28 134.29,125.28 134.41,125.15 134.41,125.12 134.42,125.11
  IN4 w0.127: v1(140.18,98.24) 140.18,98.46 140.05,98.59 139.39,98.59 139.12,98.86 139.12,99.28 139.44,99.61 139.44,99.79 139.12,100.11 139.12,105.59 138.96,105.74 138.79,105.74 138.23,106.3 138.23,106.47 138,106.7 137.84,106.7 137.44,107.09 137.44,107.26 137.23,107.48 137.06,107.48 136.6,107.94 136.6,108.1 136.26,108.45 136.09,108.45 135.67,108.87 135.67,109.04 135.45,109.25 135.45,124.08 134.42,125.11
  BOTTOM w0.102: U42.CH8 133.41,133.43 133.58,133.59 133.72,133.59 v2(133.78,133.53)
  BOTTOM w0.152: v1(140.18,98.24) 140.18,98.46 140.03,98.62 139.71,98.62 139.49,98.39 139.49,97.64 140.08,97.05 JDIM1.76
M_B_DQSP4: length 43.1
  IN4 w0.102: v2(160.97,133.54) 160.97,133.64 160.84,133.77 160.68,133.77 160.58,133.66 160.58,128.69 160.15,128.26 159.5,128.26 159.34,128.1 159.34,125.97 159.92,125.39 159.92,124.21 159.94,124.19 159.94,124.17
  IN4 w0.127: v1(168.28,102.16) 168.33,102.1 168.33,101.92 168.13,101.72 167.7,101.72 167.57,101.85 167.57,106.83 163.07,111.33 163.07,111.6 163.34,111.87 163.34,112.47 163.07,112.74 162.97,112.74 162.83,112.87 162.83,113.25 162.95,113.37 163.07,113.37 163.34,113.64 163.34,118.26 159.94,121.65 159.94,124.17
  BOTTOM w0.102: v2(160.97,133.54) 160.9,133.61 160.65,133.61 160.45,133.4 160.45,133.26 U42.AF8
  BOTTOM w0.152: v1(168.28,102.16) 168.3,102.13 168.3,101.91 168.12,101.73 167.89,101.73 167.57,102.05 167.57,103.17 167.83,103.43 JDIM1.179
M_B_DQSP5: length 45
  IN4 w0.102: 163.52,124.17 163.52,124.19 163.54,124.21 163.54,126.97 163.93,127.36 163.93,130.03 164.25,130.35 164.25,132.17 164.59,132.52 164.59,133.06 164.49,133.16 164.28,133.16 164.19,133.07 164.19,132.93 v2(164.21,132.91)
  IN4 w0.127: 163.52,124.17 163.52,123.14 166.92,119.74 166.92,113.05 173.68,106.3 173.68,102.45 173.77,102.35 173.77,101.21 172.39,99.83 172.39,98.81 172.66,98.54 172.66,98.54 172.67,98.53 173.02,98.53 173.14,98.4 v1(173.14,98.24)
  BOTTOM w0.102: U42.Y8 163.82,133.16 164.07,132.91 v2(164.21,132.91)
  BOTTOM w0.152: JDIM1.200 173.08,97.06 172.64,97.49 172.64,98.37 172.84,98.57 172.99,98.57 173.14,98.42 v1(173.14,98.24)
M_B_DQSP6: length 45.3
  IN4 w0.102: v2(167.62,133.45) 167.62,133.73 167.72,133.83 168.01,133.83 168.2,133.64 168.2,133.45 167.81,133.06 167.81,126.61 167.54,126.34 167.54,126.01 167.73,125.82 167.73,125.58 167.55,125.4 167.55,124.97 168.31,124.21 168.31,124.19 168.33,124.17
  IN4 w0.127: 168.33,124.17 168.74,123.76 169.12,123.76 169.23,123.87 169.41,123.87 169.68,123.6 169.68,123.42 169.57,123.31 169.57,122.93 169.95,122.55 170.57,122.55 170.74,122.38 170.74,114.64 174.25,111.14 175.11,111.14 179.41,106.83 179.41,103.87 179,103.46 179,101.89 178.87,101.77 178.53,101.77 178.4,101.9 v1(178.4,102.19)
  BOTTOM w0.102: U42.R8 167.39,132.98 167.49,132.98 167.62,133.11 v2(167.62,133.45)
  BOTTOM w0.152: v1(178.4,102.19) 178.4,101.91 178.23,101.75 177.97,101.75 177.81,101.91 177.81,102.98 178.07,103.23 178.33,103.49 JDIM1.221
M_B_DQSP7: length 48.2
  IN4 w0.102: 174.17,124.96 174.16,124.97 173.82,124.97 173.16,125.63 172.62,125.63 172.18,126.07 172.18,127.33 171.19,128.32 171.19,131.92 171,132.11 171,133.02 171.25,133.27 171.25,133.63 171.14,133.74 171.01,133.74 170.87,133.6 v2(170.87,133.54)
  IN4 w0.127: 174.17,124.96 177.16,121.96 178.48,121.96 181.38,119.06 181.38,110.27 184.44,107.2 184.44,101.78 182.82,100.16 182.82,99.03 183.11,98.74 183.52,98.74 183.62,98.63 v1(183.62,98.44)
  BOTTOM w0.102: v2(170.87,133.54) 170.84,133.52 170.84,133.5 170.56,133.21 U42.K8
  BOTTOM w0.152: JDIM1.242 183.58,97.07 183.06,97.59 183.06,98.71 183.21,98.86 183.47,98.86 183.62,98.71 v1(183.62,98.44)
M_B_DQSP8: length 3.7
  TOP w0.203: R117.1 144.64,101.8 v1(144.55,101.7)
  BOTTOM w0.14: JDIM1.97 145.33,102.48 v1(144.55,101.7)
M_B_PARITY: length 50.5
  IN4 w0.114: 149.46,127.08 149.46,129.41 148.82,130.05 148.82,131.47 148.7,131.59 v2(148.43,131.59)
  IN4 w0.127: v1(157.59,102.8) 157.72,102.92 157.72,105.89 149.43,114.17 149.43,114.35 149.69,114.61 149.69,114.95 149.56,115.08 148.68,115.08 148.56,115.21 148.56,115.46 148.68,115.59 149.56,115.59 149.69,115.72 149.69,115.95 149.55,116.1 148.68,116.1 148.56,116.22 148.56,116.48 148.68,116.61 149.56,116.61 149.69,116.73 149.69,116.97 149.54,117.11 148.71,117.11 148.56,117.27 148.56,117.49 148.68,117.62 149.56,117.62 149.69,117.75 149.69,117.99 149.56,118.13 148.68,118.13 148.56,118.26 148.56,118.5 148.69,118.64 149.56,118.64 149.69,118.76 149.69,119 149.55,119.15 148.69,119.15 148.56,119.28 148.56,119.53 148.68,119.65 149.56,119.65 149.69,119.78 149.69,120.02 149.55,120.16 148.69,120.16 148.56,120.29 148.56,120.54 148.68,120.67 149.56,120.67 149.69,120.8 149.69,121.05 149.56,121.18 148.68,121.18 148.56,121.3 148.56,121.56 148.68,121.69 149.02,121.69 149.15,121.81 149.15,122.1 149.27,122.23 149.56,122.23 149.69,122.35 149.69,122.6 149.56,122.73 149.31,122.73 149.18,122.86 149.18,123.11 149.31,123.24 149.56,123.24 149.69,123.37 149.69,123.62 149.56,123.75 149.41,123.75 149.28,123.88 149.28,124.2 149.71,124.63 149.71,124.89 149.28,125.32 149.28,126.62 149.46,126.79 149.46,127.08
  BOTTOM w0.102: U42.BE6 148.1,131.91 v2(148.43,131.59)
  BOTTOM w0.216: v1(157.59,102.8) 157.34,102.8 156.83,103.31 JDIM1.143
M_B_RAS#: length 56.1
  IN4 w0.102: 152.1,130.62 151.52,131.2 151.23,131.2 150.73,131.71 150.73,132.72 150.9,132.88 v2(151.36,132.88)
  IN4 w0.127: 152.1,130.62 152.1,130.41 151.98,130.28 151.93,130.28 151.8,130.15 151.8,129.9 151.93,129.77 151.98,129.77 152.1,129.64 152.1,129.39 151.98,129.26 151.93,129.26 151.8,129.14 151.8,128.88 151.93,128.75 151.98,128.75 152.1,128.63 152.1,127.83 151.35,127.08 151.35,125.69 152.89,124.15 152.89,123.81 153.01,123.68 153.47,123.68 153.62,123.53 153.62,123.3 153.5,123.17 153.08,123.17 152.95,123.04 152.95,122.79 153.08,122.66 153.56,122.66 153.68,122.54 153.68,122.28 153.56,122.16 153.08,122.16 152.95,122.03 152.95,113.1 159.71,106.34 159.71,105.87 159.9,105.69 160.3,105.69 160.4,105.59 160.4,104.7 159.98,104.28 159.98,103.04 159.85,102.91 159.74,102.91 159.61,102.78 159.61,102.53 159.74,102.4 159.85,102.4 159.98,102.27 159.98,102.02 159.85,101.89 159.74,101.89 159.61,101.77 159.61,101.51 159.74,101.38 159.85,101.38 159.98,101.26 159.98,100.63 160.62,99.99 160.62,96.8 160.44,96.62 160.19,96.62 160.06,96.75 160.06,99.76 159.56,100.27 v1(159.13,100.27)
  BOTTOM w0.102: U42.AW8 151.43,132.88 v2(151.36,132.88)
  BOTTOM w0.216: v1(159.13,100.27) 159.67,99.73 159.67,98.86 159.84,98.69 160.89,97.63 160.89,97.23 161.08,97.05 JDIM1.152
M_B_WE#: length 57.5
  IN4 w0.127: v1(161.73,101.54) 161.4,101.54 161.27,101.66 161.27,103.74 161.69,104.16 161.69,106.19 154.24,113.64 154.24,115.21 154.98,115.94 154.98,124 152.56,126.42 152.56,126.71 153.77,127.92 153.77,133.19 153.55,133.41 153.55,133.71 153.78,133.94 153.78,135.6 154.06,135.88 158.95,135.88 159.07,135.75 159.07,135.44 158.95,135.31 158.77,135.31 158.64,135.18 158.64,134.78 158.51,134.65 157.62,134.65 157.49,134.78 157.49,134.92 157.36,135.05 157.11,135.05 156.98,134.92 156.98,134.78 156.85,134.65 156.54,134.65 156.41,134.78 156.41,135.2 156.28,135.32 155.13,135.32 154.91,135.09 154.91,134.64 154.7,134.44 154.7,133.28 v2(155.1,132.89)
  BOTTOM w0.102: U42.AR7 154.77,132.56 v2(155.1,132.89)
  BOTTOM w0.216: JDIM1.151 160.83,102.44 v1(161.73,101.54)
MAIND: length 152.7
  TOP w0.14: PQ21.2 251.27,63.46 251.27,61.61 PQ28.3 250.56,59.45 PC214.1 251.34,58.54 250.72,57.91 250.72,57.44 250.49,57.21 250.49,54.81 v1(251.23,54.07)
  IN3 w0.089: v1(251.23,54.07) 250.29,55.01 247,55.01 246.35,54.35 242.81,54.35 241.55,53.09 239.13,53.09 238.36,52.33 237.34,52.33 236.55,51.54 235.15,51.54 234.77,51.91 230.35,51.91 229.6,51.17 227.56,51.17 227.32,51.41 224.91,51.41 223.24,49.74 223.02,49.74 222,48.71 220.73,48.71 219.8,47.78 219.8,47.53 219.16,46.9 218.28,46.9 218.15,46.76 212.42,46.76 212.16,47.02 209.64,47.02 209.09,46.47 208.6,46.47 208.37,46.69 205.38,46.69 204.92,46.24 198.52,46.24 198.32,46.44 195.48,46.44 194.36,47.56 193.19,47.56 192.53,48.22 190.57,48.22 188.1,50.69 187.68,50.69 187.35,51.01 185.64,51.01 184.3,52.35 182.76,52.35 181.96,53.15 179.21,53.15 177.7,54.67 177.37,54.67 177.01,55.02 176.02,55.02 175.52,54.52 172.5,54.52 170.03,56.99 165.23,56.99 165.02,57.21 164.14,57.21 163.32,56.38 156.93,56.38 155.79,55.24 151.58,55.24 149.13,57.69 138.68,57.69 137.25,59.13 125.64,59.13 v1(123.62,57.11)
  vias: v1(122.76,56.25)
MAINON: length 413.6
  TOP w0.14: v1(131.79,70.03) 131.75,70.07 PR253.1 ; v1(206.53,186.18) 206.53,187.01 206.18,187.35 206.18,188.55 205.84,188.89 R67.1 ; v1(163.32,76.13) 163.46,76.13 165.07,77.73 167.11,77.73 169.06,79.68 171.33,79.68 171.78,79.23 174.05,79.23 174.19,79.09 174.19,77.91 174.01,77.73 174.01,76.76 v1(174.19,76.58) ; PR142.1 88.05,86.88 87.98,86.95 PQ16.2 87.12,86.95 v1(86.65,87.42) ; v1(158.9,59) 159.46,58.45 160.9,58.45 161.13,58.69 163.81,58.69 164.05,58.45 R560.1 164.05,58.27 165.29,58.27 166.72,59.7 U23.30 ; v1(142.45,69.04) 142.75,69.35 PR256.1 ; v1(91.62,67.88) 91.18,67.44 91.18,65.84 86.72,61.38 74.8,61.38 73.03,59.61 60.24,59.61 PQ27.2 59.02,60.23 58.95,60.3 PR292.1
  IN1 w0.086: v1(110.63,45.72) 111.92,44.44 112.66,44.44 v1(112.67,44.44)
  IN2 w0.089: v1(91.62,67.88) 92.09,67.88 92.76,67.21 95.26,67.21 96.56,65.91 119.31,65.91 123.85,70.44 131.38,70.44 v1(131.79,70.03) ; v1(158.9,59) 158.55,59 157.63,59.93 152.87,59.93 152.26,60.54 151.31,60.54 150.68,59.9 150.68,59.57 149.03,57.92 142.2,57.92 140.9,59.22 138.61,59.22 137.48,58.09 132.4,58.09 131.97,58.52 126.01,58.52 123.9,56.41 121.14,56.41 115.33,50.6 115.33,49.93 112.68,47.28 112.68,44.45 v1(112.67,44.44)
  IN3 w0.089: v1(206.53,186.18) 206.53,186.65 206.18,187 204.42,187 203.79,187.62 200.5,187.62 195.48,182.6 195.48,179.47 192.25,176.24 192.25,173.69 188.71,170.16 187.47,170.16 186.79,169.47 186.79,164.71 188.02,163.49 188.02,152.77 188.89,151.9 188.89,110.44 190.39,108.94 190.39,106.08 193.2,103.26 193.2,89.98 192.19,88.96 192.19,79.24 187.87,74.92 185.44,74.92 184.32,76.04 183.02,76.04 181.93,77.13 174.74,77.13 v1(174.19,76.58)
  BOTTOM w0.14: PR647.2 112.83,44.59 112.69,44.44 v1(112.67,44.44) ; v1(163.32,76.13) 161.52,76.13 161.07,75.67 161.07,73.24 160.56,72.73 159.17,72.73 158.24,71.81 158.24,70.8 158.85,70.19 158.85,64.22 159.37,63.7 159.37,63.7 159.82,63.25 159.82,60.71 159.68,60.57 158.98,60.57 158.27,59.86 158.27,59.45 158.72,59 v1(158.9,59) ; v1(131.79,70.03) 132.27,69.55 141.86,69.55 142.37,69.04 v1(142.45,69.04) ; v1(86.65,87.42) 88.87,87.42 89.48,86.81 89.48,84.08 88.8,83.4 88.8,68.94 88.94,68.8 90.71,68.8 v1(91.62,67.88) 91.18,67.44 91.18,63.09 92.75,61.52 92.75,54.89 99.59,48.05 108.3,48.05 v1(110.63,45.72)
MAINON_ON_G: length 228.9
  TOP w0.14: PQ28.2 248.43,62 PQ22.2 v1(247.43,63.53)
  IN2 w0.089: v1(202.59,53.49) 202.59,53.59 200.15,56.04 200.15,57.25 198.6,58.8 198.37,58.8 196.78,60.39 193.55,60.39 193.17,60.77 192.55,60.77 191.85,61.47 188.95,61.47 187.26,63.16 187.26,63.82 185.26,65.83 184.46,65.83 183.72,66.56 182.17,66.56 181.82,66.22 179.82,66.22 179.13,66.92 178.33,66.92 177.44,67.81 172.41,67.81 172.22,67.62 165.89,67.62 164.43,69.08 158.68,69.08 158.02,69.74 133.96,69.74 129.63,65.41 121,65.41 119.69,64.09 113.91,64.09 111.78,61.97 110.79,61.97 106.47,57.65 103.91,57.65 101.02,54.76 94.46,54.76 88.82,49.12 64.8,49.12 63.75,50.17 60.73,50.17 59.43,51.46 59.43,60.5 60.63,61.69 61.39,61.69 v1(62.27,62.57)
  IN3 w0.089: v1(247.43,63.53) 247.37,63.59 238.79,63.59 238.79,63.6 235.19,63.6 233.66,62.06 233.66,59.82 233.24,59.4 232.69,59.4 231.88,60.21 231.5,60.21 231.04,59.75 231.04,59.38 230.48,58.81 230.48,58.43 230.34,58.3 229.43,58.3 228.78,58.94 228.35,58.94 227.38,57.98 226.72,57.98 226.32,58.38 225.89,58.38 225.33,57.82 223.2,57.82 222.36,56.99 220.76,56.99 220.64,56.87 218.14,56.87 217.95,57.06 214.08,57.06 213.5,56.49 210.93,56.49 209.51,55.07 209.17,55.07 208.97,54.88 208.04,54.88 207.01,53.85 202.95,53.85 v1(202.59,53.49)
MB_THRMTRIP#_2: length 5.4
  BOTTOM w0.14: U46.4 213.45,104.35 v1(214.74,103.06) 215.21,102.58 R822.2 215.21,100.25 D56.1
MBCLK: length 186.3
  TOP w0.14: R337.1 177.58,76.87 177.58,76.42 177.37,76.21 177.37,75.36 177.06,75.05 R357.1 176.79,74.84 176.92,74.71 176.92,74 176.71,73.79 U23.110 176.71,72.2 176.49,71.98 176.49,66.53 177.61,65.41 v1(177.61,64.88) ; PD5.1 74.62,43.81 73.98,43.17 PR324.2 73.66,43.04 PC256.1 73.91,42.64 74.21,42.64 74.67,43.1 v1(74.84,43.1) ; PR334.2 v1(33.91,41.24)
  IN2 w0.089: v1(33.91,41.24) 33.97,41.3 35.18,41.3 36.01,42.13 36.01,44.1 37.01,45.11 39.88,45.11 42.49,47.72 42.49,48.24 44.01,49.77 47.83,49.77 48.43,50.37 58.71,50.37 62.54,46.55 69.93,46.55 70.73,45.74 73.52,45.74 75.05,44.22 75.05,43.32 v1(74.84,43.1)
  IN3 w0.089: v1(74.84,43.1) 75.11,43.38 75.11,49.77 78.2,52.86 95.57,52.86 98.57,55.85 101.01,55.85 102.43,57.27 112.02,57.27 113.59,58.85 118.02,58.85 118.91,59.74 122.5,59.74 123.42,60.66 139.69,60.66 143.54,64.51 146.79,64.51 148.31,66.03 153.7,66.03 153.91,65.82 158.71,65.82 159.23,65.3 161.19,65.3 161.62,64.87 163.68,64.87 164.17,65.36 164.92,65.36 165.94,66.38 169.99,66.38 170.54,65.83 176.95,65.83 177.61,65.16 v1(177.61,64.88)
MBCLK1_GPU: length 222.9
  TOP w0.14: PR195.1 266.07,78.54 v1(266.43,78.54) 266.78,78.19 PR198.1 ; QG12.3 259.79,114.45 v1(259.91,114.56) ; v1(257.75,209.76) 257.58,209.93 257.58,210.19 R34.2
  IN1 w0.086: v1(283.43,112.99) 283.2,112.76 282.39,112.76 282.15,112.52 260.59,112.52 259.43,113.68 259.43,114.38 259.61,114.56 v1(259.91,114.56)
  IN2 w0.089: v1(266.43,78.54) 266.18,78.3 265.99,78.3 265.88,78.41 265.88,78.83 266.06,79.01 266.7,79.01 267.19,79.5 267.19,80.3 269.89,83 272.91,83 275.26,85.35 279.85,85.35 283.68,89.19 285.58,89.19 286.12,88.65 291.65,88.65 292.57,89.57 292.57,92.17 292.91,92.51 292.91,95.57 293.46,96.12 293.46,107.44 289.46,111.43 288.9,111.43 287.44,112.89 284.73,112.89 284.58,112.73 283.69,112.73 v1(283.43,112.99)
  IN3 w0.089: v1(281.93,207.61) 281.66,207.34 281.66,206.59 281.4,206.33 280.68,206.33 280,207.01 280,207.73 278.11,209.62 276.07,209.62 275.02,210.68 274.42,210.68 273.79,211.3 270.71,211.3 269.44,212.58 266.09,212.58 265.91,212.76 264.98,212.76 264.65,213.09 263.85,213.09 260.99,210.23 258.37,210.23 258.17,210.42 257.59,210.42 257.49,210.32 257.49,210.02 v1(257.75,209.76)
  IN4 w0.086: v1(283.43,112.99) 283.19,112.74 282.49,112.74 282.12,113.11 282.12,114.44 282.21,114.53 282.21,140.62 282.01,140.82 282.01,151.51 283.11,152.6 283.11,173.35 283.46,173.7 283.46,176.85 283.6,177 283.6,178.87 283.09,179.38 283.09,181.95 283.38,182.23 283.38,188.97 285.3,190.89 285.3,196.84 284.08,198.06 284.08,203.43 281.63,205.88 281.63,207.31 v1(281.93,207.61)
MBCLK1_OVRM: length 0.7
  TOP w0.14: RG1.1 226.52,215.48 PR16.2
MBCLK_CONN: length 3.5
  TOP w0.14: PR324.1 73.79,43.75 v1(74.32,44.29)
  BOTTOM w0.14: v1(74.32,44.29) 74.32,45.1 73.55,45.87 PJ19.5
MBDATA: length 186.6
  TOP w0.14: R336.1 176.01,77.08 175.87,76.94 175.87,76.14 175.66,75.93 175.66,75.19 175.8,75.05 R356.1 176.23,75.05 176.67,74.61 176.67,74.1 176.31,73.73 U23.111 176.31,72.2 175.97,71.86 175.97,66.31 176.96,65.32 v1(176.96,64.88) ; PD4.1 77.94,43.91 77.32,43.3 PR323.2 PC257.1 76.87,42.39 76.17,43.09 v1(75.79,43.09) ; PR333.2 33.91,42 v1(33.78,41.87)
  IN2 w0.089: v1(75.79,43.09) 75.52,43.37 75.52,44.41 73.72,46.21 70.93,46.21 70.12,47.02 62.73,47.02 58.91,50.84 48.23,50.84 47.63,50.24 43.27,50.24 42.96,49.93 42.96,49.38 42.02,48.44 42.02,47.91 39.69,45.58 36.82,45.58 35.54,44.3 35.54,42.32 34.99,41.77 33.88,41.77 v1(33.78,41.87)
  IN3 w0.089: v1(176.96,64.88) 176.49,65.36 170.34,65.36 169.79,65.91 166.14,65.91 165.11,64.89 164.37,64.89 163.88,64.4 161.43,64.4 161,64.83 159.04,64.83 158.87,64.99 157.66,64.99 157.3,65.35 153.71,65.35 153.5,65.56 148.5,65.56 146.98,64.04 143.73,64.04 139.89,60.19 123.76,60.19 122.83,59.26 119.09,59.26 118.21,58.38 113.79,58.38 111.69,56.28 110.46,56.28 109.94,56.81 103.13,56.81 98.71,52.39 78.39,52.39 75.58,49.57 75.58,43.31 v1(75.79,43.09)
MBDATA1_GPU: length 223.3
  TOP w0.14: v1(258.91,114.57) 258.79,114.68 QG12.6 ; R33.2 257.27,210.04 v1(257.01,209.77) ; PR204.1 266.99,77.57 266.7,77.86 v1(266.43,77.86) 266.35,77.94 PR200.1
  IN1 w0.086: v1(258.91,114.57) 259.26,114.21 259.26,113.61 260.52,112.35 282.21,112.35 282.46,112.59 283.19,112.59 v1(283.46,112.33)
  IN2 w0.089: v1(283.46,112.33) 283.67,112.54 284.65,112.54 284.81,112.7 287.36,112.7 288.82,111.24 289.38,111.24 293.27,107.36 293.27,96.2 292.72,95.65 292.72,92.59 292.38,92.25 292.38,89.65 291.57,88.84 286.2,88.84 285.66,89.38 283.6,89.38 279.77,85.54 275.18,85.54 272.83,83.19 269.81,83.19 267,80.38 267,79.57 266.62,79.2 265.99,79.2 265.69,78.91 265.69,78.33 265.91,78.1 266.06,78.1 266.18,78.11 v1(266.43,77.86)
  IN3 w0.089: v1(281.14,207.61) 281.47,207.28 281.47,206.67 281.32,206.52 280.76,206.52 280.19,207.09 280.19,207.81 278.19,209.81 276.15,209.81 275.1,210.87 274.5,210.87 273.87,211.49 270.79,211.49 269.52,212.77 266.17,212.77 265.99,212.95 265.06,212.95 264.72,213.28 263.77,213.28 260.91,210.42 258.45,210.42 258.25,210.61 257.51,210.61 257.3,210.4 257.3,210.06 v1(257.01,209.77)
  IN4 w0.086: v1(283.46,112.33) 283.21,112.58 282.42,112.58 281.95,113.05 281.95,114.51 282.04,114.6 282.04,140.55 281.85,140.75 281.85,151.57 282.94,152.67 282.94,173.42 283.29,173.77 283.29,176.92 283.44,177.07 283.44,178.8 282.93,179.31 282.93,182.01 283.21,182.3 283.21,189.03 285.13,190.96 285.13,196.77 283.92,197.99 283.92,203.36 281.46,205.81 281.46,207.28 v1(281.14,207.61)
MBDATA1_OVRM: length 0.7
  TOP w0.14: PR25.2 225.48,213.65 225.53,213.7 RG2.1
MBDATA_CONN: length 3.8
  TOP w0.14: PR323.1 76.65,43.75 v1(76.09,44.3)
  BOTTOM w0.14: v1(76.09,44.3) 75.74,44.3 75.55,44.49 PJ19.4
MCU_INT#: length 185.7
  TOP w0.14: Q9.1 v1(154.91,206.91) 156.91,206.91 157.43,206.39 159.68,206.39 v1(160.14,205.93) 160.17,205.93 160.66,206.42 R44.2 ; U23.113 175.51,73.75 176.2,74.44 v1(176.24,74.44)
  IN1 w0.086: v1(166.05,175.42) 166.24,175.42 166.96,174.7 166.96,173.68 169.42,171.22 183.25,171.22 v1(186.24,168.24)
  IN3 w0.089: v1(160.14,205.93) 160.44,205.63 160.44,201.63 160.81,201.26 160.81,199.79 164.8,195.8 164.8,185.11 164.71,185.01 164.71,181.48 166.61,179.57 166.61,175.98 v1(166.05,175.42) ; v1(176.24,74.44) 175.84,74.03 173.48,74.03 173.29,74.22 173.29,75.24 173.74,75.7 173.74,76.87 174.3,77.42 182.06,77.42 183.14,76.33 184.44,76.33 185.56,75.22 187.75,75.22 191.9,79.36 191.9,89.08 192.91,90.1 192.91,103.14 190.1,105.96 190.1,108.82 188.6,110.32 188.6,151.78 187.72,152.65 187.72,162.18 186.24,163.67 v1(186.24,168.24)
ME_WR#: length 68.2
  TOP w0.14: v1(176.91,71.04) 176.91,72.01 177.11,72.2 U23.109
  IN2 w0.089: v1(176.91,71.04) 180.83,71.04 181.07,70.81 185.3,70.81 185.63,71.15 186.4,71.15 187.06,70.48 188.01,70.48 189.44,69.06 191.78,69.06 193.23,67.6 196.17,67.6 197.54,66.23 201.73,66.23 203.11,64.84 203.11,64.03 203.54,63.6 204.27,63.6 205.37,62.49 205.59,62.49 205.88,62.21 207.85,62.21 208.32,61.74 209.65,61.74 209.88,61.5 209.88,59.65 211.43,58.1 213.36,58.1 213.59,57.88 214.25,57.88 214.54,58.17 214.54,59.15 215.46,60.07 216.39,60.07 216.81,59.65 217.61,59.65 217.75,59.52 219.04,59.52 220,58.55 221.63,58.55 221.88,58.8 222.81,58.8 223.32,58.29 225.36,58.29 226.37,59.3 228.69,59.3 229.75,58.23 231.41,58.23 v1(231.62,58.44)
  BOTTOM w0.102: v1(231.62,58.44) 231.55,58.37 231.25,58.37 231.02,58.14 R1036.2
MEM_VDD_CTRL: length 144.6
  TOP w0.14: v1(263.57,121.94) 263.46,122.04 261.86,122.04 260.73,120.91 RG65.1 ; PR35.2 263.49,213.31 263.72,213.31 264.06,212.97 264.06,212.75 263.98,212.67 263.9,212.6 263.9,211.69 v1(263.88,211.67)
  IN2 w0.089: v1(263.88,211.67) 264.5,211.67 264.74,211.91 265.35,212.52 266.03,212.52 266.4,212.16 266.4,207.43 270.64,203.19 270.64,202.78 274.01,199.41 274.01,198.31 275.72,196.6 278.2,196.6 278.91,195.9 278.91,193.85 278.31,193.26 277.38,193.26 277.18,193.06 275.07,193.06 274.58,192.56 273.76,192.56 273.35,192.15 273.35,189.48 275.75,187.08 275.75,186.58 274.69,185.52 274.69,178.91 279.59,174.01 279.59,153.99 278.52,152.93 278.52,140.24 277.13,138.84 273.07,138.84 272.71,138.48 272.71,135.27 272.23,134.8 272.23,133.97 271.3,133.03 267.16,133.03 266.49,132.37 260.95,132.37 260.95,132.37 253.48,132.37 253.17,132.05 253.17,131.63 v2(253.7,131.11)
  IN4 w0.086: v2(253.7,131.11) 254.17,131.11 254.6,131.54 255.32,131.54 255.36,131.5 256.22,131.5 257.83,129.88 257.83,129.25 259.63,127.45 259.63,126.71 260.28,126.06 260.28,125.72 261.79,124.22 261.79,123.9 263.57,122.12 v1(263.57,121.94)
  BOTTOM w0.102: v2(253.7,131.11) 253.67,131.11 253.26,131.52 UG6.BK6
MEM_VREF_CTL: length 144.1
  TOP w0.102: v2(255,131.17) 255.32,131.48 256.69,131.48 256.75,131.54 257.72,131.54 257.97,131.79 258.97,131.79
  TOP w0.14: 258.97,131.79 260.3,131.79 260.47,131.96 v1(261.12,131.96)
  IN2 w0.089: v1(261.12,131.96) 261.12,131.97 261.29,131.97 261.5,132.18 266.57,132.18 267.17,132.77 271.31,132.77 272.42,133.89 272.42,134.72 272.9,135.19 272.9,138.4 273.15,138.65 277.21,138.65 278.71,140.16 278.71,152.85 279.78,153.91 279.78,174.09 274.88,178.99 274.88,185.44 275.94,186.5 275.94,187.16 273.54,189.56 273.54,192.07 273.84,192.37 274.66,192.37 275.15,192.87 277.26,192.87 277.46,193.07 278.39,193.07 279.1,193.77 279.1,195.98 278.28,196.8 275.79,196.8 274.2,198.39 274.2,199.49 270.84,202.84 270.84,203.29 266.59,207.54 266.59,212.23 266.09,212.73 264.95,212.73 263.9,213.79 262.25,213.79 262.02,213.56 260.22,213.56 259.32,214.46 257.57,214.46 255.47,216.55 254.38,216.55 253.51,215.68 253.51,214.99 253.31,214.79 249.09,214.79 248.87,214.58 247.27,214.58 246.85,214.16 246.85,213.6 247.25,213.2 v1(247.25,212.67)
  BOTTOM w0.102: UG6.BK4 v2(255,131.17)
  BOTTOM w0.14: v1(261.12,131.96) 261.12,131.97 261.8,131.97 262.03,132.2 RG125.1 ; v1(247.25,212.67) 247.3,212.72 PR379.2
MIC2-L: length 4
  TOP w0.203: U20.30 316.82,66.23
  TOP w0.381: v1(317.8,66.02) 317.39,66.02 317.17,66.23 316.82,66.23
  BOTTOM w0.305: v1(317.8,66.02) 317.6,66.22 317.08,66.22 316.89,66.41 CN10.41
MIC2-R: length 3.1
  TOP w0.203: U20.31 316.55,66.63
  TOP w0.381: v1(317.43,66.73) 317.39,66.76 316.68,66.76 316.55,66.63
  BOTTOM w0.305: v1(317.43,66.73) 317.25,66.91 CN10.40
MIC2-VREFO-L: length 7.9
  TOP w0.203: U20.28 316.75,65.43
  TOP w0.381: 316.75,65.43 317.22,64.96 318.49,64.96 v1(318.93,65.39)
  BOTTOM w0.305: v1(318.93,65.39) 318.75,65.39 318.44,65.7 318.44,66.99 318.03,67.41 CN10.39
MIC2-VREFO-R: length 7.8
  TOP w0.203: U20.29 316.93,65.83 317.31,65.46 317.41,65.46
  TOP w0.381: 317.41,65.46 317.41,65.46 318.2,65.46 318.8,66.05 v1(318.95,66.05)
  BOTTOM w0.305: CN10.38 318.21,67.91 318.95,67.17 v1(318.95,66.05)
MIC-JD: length 26.3
  TOP w0.14: v1(309.76,79.71) 309.76,79.7 309.5,79.44 v1(309.5,78.45) 309.19,78.45 307.93,77.19 307.93,75.19 308.5,74.62 R376.1
  IN4 w0.086: v1(318.65,68.7) 318.06,69.28 318.06,69.84 317.93,69.98 317.05,69.98 316.18,70.84 316.18,77.23 313.71,79.71 v1(309.76,79.71)
  BOTTOM w0.102: v1(318.65,68.7) 318.17,68.21 317.06,68.21 316.87,68.41 CN10.37
MIC-JD_R: length 6
  TOP w0.14: U20.47 310.55,70.03 310.37,70.2 309.67,70.2 308.32,71.55 308.32,73.47 R387.2 308.32,73.91 R376.2
MIC_VCC: length 0.9
  BOTTOM w0.508: v1(272.16,185.89) 272.07,185.99 v1(271.35,185.99)
MKB_INT#: length 64
  TOP w0.14: v1(185.58,57.65) 185.27,57.35 185.27,54.59 v1(185.77,54.09) 187.21,52.64 187.21,49.15 Q57.1 187.91,48.45 R620.1 ; U23.76 184.57,63.3 185.04,63.77 v1(185.04,63.78) ; R533.1 222.09,60.76 221.9,60.57 221.82,60.57 221.19,59.93 v1(221.19,59.63)
  IN3 w0.089: v1(185.58,57.65) 186.8,57.65 187.6,56.85 189.91,56.85 190.28,57.22 192.39,57.22 193.84,55.77 193.84,55.35 194.2,54.99 197.52,54.99 198.46,54.05 198.65,53.86 200.07,53.86 201.5,55.29 205.6,55.29 206.04,54.86 206.58,54.86 206.96,55.23 206.96,55.64 209.33,58.01 213.78,58.01 213.91,57.88 214.52,57.88 214.98,58.34 214.98,59.7 215.47,60.19 216.09,60.19 216.63,59.65 217.53,59.65 217.68,59.5 219.08,59.5 219.81,58.76 220.53,58.76 221.19,59.42 v1(221.19,59.63)
  BOTTOM w0.14: v1(185.04,63.78) 184.78,63.51 184.78,59.34 185.18,58.93 185.18,58.81 185.58,58.41 v1(185.58,57.65)
MKB_INT#_R: length 1.4
  TOP w0.14: R533.2 221.47,60.96 v1(221.01,60.49)
  BOTTOM w0.102: v1(221.01,60.49) 221.04,60.52 U49.AY38
MKB_PWR_EN: length 73.8
  TOP w0.14: R1234.1 212.91,39.51 208.37,39.51 v1(207.89,39.03) ; R1233.1 189.6,39.33 v1(189.52,39.41) ; R477.1 163.3,66.26 v1(162.83,66.26)
  BOTTOM w0.14: v1(162.83,66.26) 163.63,65.46 163.63,63.62 164.17,63.08 164.17,61.92 163.82,61.57 163.82,58.76 165.56,57.02 169.56,57.02 170.39,56.2 170.39,54.19 171.09,53.48 172.04,53.48 172.87,52.65 177.44,52.65 180.42,49.67 180.42,49.02 181.36,48.08 181.36,46.85 180.19,45.68 180.19,43.67 183.12,40.74 188.04,40.74 189.37,39.41 v1(189.52,39.41) 190.48,38.44 207.45,38.44 207.89,38.89 v1(207.89,39.03)
MODE: length 1.7
  TOP w0.14: R496.2 22.49,63.38 22.26,63.15 21.88,63.15 21.87,63.15 21.72,63.3 U24.30
MODEM_CLKREQ: length 67
  TOP w0.14: R463.1 268.79,66.08 268.99,65.88 U22.2 ; R463.1 268.85,66.53 U22.1 271.32,66.53 272.12,65.72 R482.1 ; R463.1 268.53,66.46 268.39,66.6 268.39,69.1 267.49,70 265.34,70 264.79,69.45 v1(264.79,69.25)
  IN2 w0.089: v1(221.46,64.09) 221.75,64.09 221.8,64.05 223.03,64.05 223.52,63.56 223.52,63.56 223.95,63.13 224.95,63.13 225.8,63.99 226.53,63.99 226.86,64.32 226.86,64.97 227.21,65.32 229.75,65.32 230.01,65.05 231.19,65.05 233.13,63.11 233.92,63.11 235.09,61.94 238.85,61.94 238.93,62.03 247.65,62.03 248.33,61.35 250.84,61.35 253.57,64.08 253.57,67.28 254.36,68.07 255.54,69.25 v1(264.79,69.25)
  BOTTOM w0.102: v1(221.46,64.09) 221.04,63.67 U49.AY33
MODEM_CLKREQ_L: length 4.3
  TOP w0.14: U22.4 273.14,65.23 273.18,65.27 R482.2 273.69,64.7 v1(273.51,64.52)
  BOTTOM w0.14: CN12.14 273.79,64.24 v1(273.51,64.52)
MUX_CNTL: length 143.1
  TOP w0.14: QG1.5 268.92,215.49 267.91,214.48 v1(267.66,214.48)
  IN3 w0.089: v1(267.66,214.48) 267.66,213.9 268.28,213.28 271.03,213.28 271.49,213.74 274.53,213.74 274.73,213.54 274.73,211.94 275.31,211.37 276.18,211.37 276.93,210.63 278.03,210.63 280.2,208.46 281.64,208.46 282.46,207.65 282.46,201.43 284.81,199.08 284.81,194.54 283.9,193.63 283.9,187.29 284.21,186.97 284.21,180.42 283.83,180.04 283.83,174.65 282.97,173.79 282.97,154.48 280.81,152.32 280.81,119.66 277.16,116 271.07,116 270.48,116.6 269.21,116.6 268.83,116.22 v1(267.87,116.22)
  IN4 w0.086: v1(267.66,214.48) 267.52,214.62 267.52,215.78 267.34,215.96 267.34,217.29 267.78,217.72 272.93,217.72 v1(273.05,217.6)
  BOTTOM w0.14: v1(267.87,116.22) 268.03,116.06 269.93,116.06 270.55,115.44 UG11.4 ; v1(273.05,217.6) 273.84,217.6 TP83.1 273.86,217.54 273.46,217.13 273.46,216.75 273.67,216.54 273.67,216 273.87,215.79 R688.2
MUX_CNTL_C: length 10.2
  TOP w0.14: QG1.6 269.17,214.99 v1(269.15,215.01)
  IN1 w0.086: v1(269.15,215.01) 269.15,215.71 269.23,215.79 272.42,215.79 272.91,215.3 v1(273.27,215.3)
  BOTTOM w0.14: v1(269.15,215.01) 269.14,215.02 268.6,215.02 268.14,214.56 268.14,213.75 267.91,213.51 U37.1 ; v1(273.27,215.3) 273.27,214.71 273.6,214.39 U36.6
MUX_CNTL_INTERNAL: length 30.3
  TOP w0.102: TP18.1 252.83,131.94 253.29,131.48 253.29,130.93 253.5,130.72 253.8,130.72 253.9,130.62 253.9,130.21 254.29,129.82 254.95,129.82 v2(255,129.77)
  IN4 w0.086: v1(268.17,118.31) 268.13,118.35 267.8,118.69 267.03,118.69 266.08,117.74 265.38,117.74 264.91,118.21 264.91,120.29 265.12,120.51 265.12,120.84 264.81,121.15 263.84,121.15 262.88,120.19 262.22,120.19 261.98,120.43 261.98,122.64 261.28,123.34 260.66,123.34 259.29,124.71 258.7,124.71 257.07,126.33 256.23,126.33 255.9,126.67 255.9,127.2 255.16,127.94 254.9,127.94 254.62,128.22 254.62,129.44 254.95,129.77 v2(255,129.77)
  BOTTOM w0.102: UG6.BM4 v2(255,129.77)
  BOTTOM w0.14: v1(268.17,118.31) 268.49,118.31 RG169.1 268.75,118.98 RG165.1
MUX_CTRL_EC: length 159.9
  TOP w0.14: v1(265.24,121.75) 265.24,120.51 265.12,120.39 265.12,118.36 265.24,118.25 265.87,117.62 266.5,117.62 267.27,116.85 268.15,116.85 268.33,116.67 268.33,115.89 267.62,115.19 267.52,115.19 267.3,114.97 267.3,114.46 267.46,114.3 RG91.1 267.81,114.28 RG92.1 ; R593.2 178.11,55.7 v1(178.43,56.02) 178.71,56.3 U23.56
  IN1 w0.086: v1(198.5,59.65) 195.61,59.65 194.06,58.11 194.06,56.24 193.79,55.97 192.31,55.97 189.74,58.54 185.37,58.54 185.21,58.7 179.16,58.7 178.43,57.97 v1(178.43,56.02)
  IN3 w0.089: v1(198.5,59.65) 197.36,60.79 197.36,63.91 197.66,64.21 197.66,67.27 197.27,67.66 197.27,76.92 197.42,77.07 197.42,86.65 198.51,87.74 198.51,93.79 202.15,97.43 202.63,97.43 203.72,98.52 203.72,99.34 205.38,100.99 205.98,100.99 206.8,101.81 206.8,105.08 207.79,106.08 207.79,110.67 212.22,115.09 217.26,115.09 217.37,115.2 229.9,115.2 230.25,115.55 231.24,115.55 231.8,114.98 240.01,114.98 240.3,115.27 243.4,115.27 244.45,116.32 248.08,116.32 248.68,116.91 249.45,116.91 249.82,116.54 254.1,116.54 254.93,117.37 256.96,117.37 257.1,117.5 260.4,117.5 261.1,118.2 261.1,119.45 261.69,120.04 262.61,120.04 263.71,121.15 264.63,121.15 v1(265.24,121.75)
MUX_CTRL_PCH: length 167.2
  TOP w0.14: v1(268.62,120.37) 268.62,120.96 268.94,121.27 268.94,122.95 270.18,124.19 272.14,124.19 272.63,124.68 276.5,124.68 280.62,120.56 TP22.1
  IN3 w0.089: v1(208.54,58.71) 208.54,59.12 208.13,59.53 207.54,59.53 207.06,59.05 207.06,58.07 206.54,57.55 205.92,57.55 205.78,57.69 204.84,57.69 204.62,57.47 203.9,57.47 203.64,57.73 203.64,58.78 201.7,60.72 199.24,60.72 198.64,61.32 198.64,63.96 198.23,64.37 198.23,67.51 198,67.75 198,68.37 198.1,68.47 198.39,68.47 198.62,68.71 198.62,69.44 198.34,69.72 198.34,76.48 198.55,76.69 198.55,80.44 198.65,80.55 198.65,86.37 199.58,87.3 199.58,93.34 202.58,96.35 203.1,96.35 207.87,101.12 207.87,102.86 208.56,103.55 208.56,105.33 209.32,106.09 209.32,110.04 209.87,110.59 209.87,111.06 212.73,113.92 240.45,113.92 240.74,114.2 244.18,114.2 244.67,113.71 247.86,113.71 248.28,114.13 260.91,114.13 261.15,114.38 261.15,115.15 261.15,116.18 263.21,118.24 264.03,118.24 265.21,119.42 266.01,119.42 266.96,120.37 v1(268.62,120.37)
  BOTTOM w0.102: 208.46,52.06 208.75,52.34 208.75,52.72 209.43,53.41 209.43,54.25 209.67,54.49 210.28,55.1 210.28,55.68 210.59,56 210.59,56.43 210.77,56.61 210.77,56.83 211.08,57.14 U49.Y46 211.08,57.41 210.72,57.77 210.21,57.77 209.63,58.36 209.02,58.36 208.74,58.64 208.61,58.64 v1(208.54,58.71)
  BOTTOM w0.14: RG170.1 267.88,118.96 267.88,120.09 268.16,120.37 v1(268.62,120.37) 269.05,120.37 269.52,119.91 269.52,118.64 RG173.1 ; 208.46,52.06 TP165.1 208.04,51.63 R1100.1
NBSWON#: length 268.5
  TOP w0.14: R54.1 268.55,197.94 268.79,198.18 v1(268.97,198.18) ; R358.1 177.73,74 177.91,73.83 U23.107 177.91,70.91 177.54,70.55 177.54,66.95 178.65,65.84 178.65,64.27 177.8,63.42 177.8,62.22 176.78,61.19 v1(176.78,60.71)
  IN3 w0.089: v1(268.97,198.18) 268.91,198.12 268.91,196.99 270.26,195.64 270.26,192.47 269.4,191.61 268.79,191.61 268.6,191.41 268.6,190.58 268.41,190.4 268.41,190.07 268.91,189.57 272.2,189.57 272.54,189.91 277.79,189.91 281.3,186.4 281.3,154.16 279.86,152.71 279.86,138.4 277.02,135.56 277.02,135.3 271.77,130.05 269.2,130.05 266.52,127.36 264.81,127.36 263.08,125.63 261.74,125.63 260,123.89 258.56,123.89 256.89,122.21 255.91,122.21 255.37,121.68 255.37,119.8 254.33,118.76 252.44,118.76 252.16,118.48 246.89,118.48 246.61,118.2 244.76,118.2 244.4,118.56 244.4,118.83 242.7,120.53 241.46,120.53 240.28,119.35 240.1,119.35 239.59,118.84 238.49,118.84 236.06,121.27 234.84,121.27 234.48,121.62 233.41,121.62 231.23,119.44 225.78,119.44 224.86,118.52 216.9,118.52 215.78,117.4 211.25,117.4 205.48,111.64 205.48,107.22 203.49,105.23 203.29,105.23 200.09,102.02 199.77,102.02 196.44,98.7 196.32,98.57 196.32,88.69 195.3,87.67 195.3,77.95 195.15,77.8 195.15,66.31 195.51,65.95 195.51,62.44 195.97,61.98 195.97,60.14 194.5,58.68 193.32,58.68 v1(193.3,58.65) 193.27,58.65 192.03,57.41 190.13,57.41 189.76,57.04 187.68,57.04 186.67,58.05 185.15,58.05 183.92,59.29 181.83,59.29 181.75,59.37 180.44,59.37 179.79,60.03 177.46,60.03 v1(176.78,60.71)
  BOTTOM w0.14: v1(268.97,198.18) 269.54,198.18 270.01,197.72 C602.1 269.5,196.91 269.43,196.98 D54.1 ; v1(193.3,58.65) 193.3,58.68 192.9,59.07 SW1.1 192.19,59.07 191.71,59.55 191.51,59.55 191.37,59.41 C790.2 191.37,58.51 R1027.1 191.35,58.14 192.11,57.38 192.11,56.54 SW1.2
NBSWON#_C: length 2
  TOP w0.14: R54.2 268.1,197.79 267.84,198.05 CN1.8
NGFF1_PEDET1: length 2.1
  BOTTOM w0.14: TP124.1 110.75,92.29 110.69,92.23 CN6.69
NGFF1_RST#: length 7.6
  TOP w0.14: R197.1 99.46,88.17 99.55,88.16 99.68,88.04 99.68,87.92 99.87,87.72 R198.2 100.08,87.06 99.97,86.95 U12.4 99.97,86.51 103.01,86.51 v1(103.38,86.88)
  BOTTOM w0.14: v1(103.38,86.88) 103.38,87.19 103.09,87.48 CN6.50
NGFF2_RST#: length 5.5
  TOP w0.14: U25.4 99.48,62.69 100,63.21 R495.1 100.34,62.98 100.47,62.85 100.59,62.85 100.79,62.65 R504.2 100.79,62.06 v1(100.57,61.85)
  BOTTOM w0.14: CN13.50 101.15,62.43 v1(100.57,61.85) 100.57,61.67 v1(100.21,61.3)
NRESET: length 22.7
  TOP w0.14: R1196.1 v1(196.5,52.41) 196.5,52.59 v1(197.18,53.27) 196.19,53.27 195.61,52.69 194.69,52.69 194.32,53.06 Q124.1 193.81,53.29 193.66,53.15 R1210.1
  IN3 w0.089: v1(197.18,53.27) 200.29,53.27 201.73,54.72 205.37,54.72 205.8,54.29 206.81,54.29 207.53,55 207.53,55.39 209.38,57.23 v2(209.68,57.23)
  BOTTOM w0.079: U49.W45 210.41,57.19 209.73,57.19 v2(209.68,57.23)
NRESET_R: length 26.3
  TOP w0.14: v1(190.63,50.1) 190.88,50.1 v1(191.91,51.13) 192.17,51.39 192.17,51.98 192.61,52.41 195.08,52.41 195.99,51.5 195.99,50.35 195.79,50.15 195.62,50.15 R1192.2 195.57,49.87 R1194.1 R1195.1 ; v1(185.96,46.39) 186.03,46.32 R1193.2
  BOTTOM w0.14: v1(185.96,46.39) 185.96,46.13 185.65,45.82 CN19.5 185.65,44.36 186.08,43.92 189.84,43.92 191.08,45.16 191.08,47.86 192.12,48.91 192.12,49.37 191.34,50.15 190.68,50.15 v1(190.63,50.1)
NVVDD: length 65.8
  TOP w0.102: CG341.2 CG340.2 252.53,133.72 252.28,133.97 v2(251.51,133.97)
  TOP w0.508: PR162.1 286.31,85.1 v1(286.26,85.15)
  IN4 w0.508: v1(268.43,74.88) 268.43,76.88 268.58,77.03 268.58,78.62 269.5,79.53 269.5,81.85 270.87,83.23 271.9,83.23 274.56,85.88 277.54,85.88 278.39,86.74 282.6,86.74 283.47,85.87 285.55,85.87 v1(286.26,85.15) 286.29,85.15 286.34,85.1 292.36,85.1 292.99,85.74 292.99,94.38 292.69,94.68 292.69,103.82 v3(291.09,105.41)
  BOTTOM w0.203: UG6.BD25 239.95,135.73 v2(239.6,136.07) 239.6,136.07 UG6.BD26 ; UG6.BD32 235.41,135.36 235.44,135.36 ; UG6.BD21 UG6.BD22 v2(241.7,136.07) ; UG6.BD17 245.55,135.72 v2(245.19,136.07) 244.85,135.73 UG6.BD18 ; UG6.BD29 237.15,135.68 v2(237.5,135.32) 237.5,135.37 UG6.BD28 ; 235.44,135.36 235.44,135.41 UG6.BD31 ; 235.44,135.36 v2(235.44,135.3)
  BOTTOM w0.254: UG6.BD35 UG6.BD36 232.22,135.72 231.87,135.36 v2(231.87,135.33) ; v2(230.5,135.38) 230.16,135.72 UG6.BD39 UG6.BD40
  vias: v1(246.41,109.54) v2(220.01,128.38) v2(219.99,127.67) v2(220.7,129.08) v2(220.7,128.36) v2(220.7,127.67) v2(221.39,129.07) v2(221.41,128.39) v2(222.08,129.78) v2(222.08,129.05) v2(222.81,129.76) v2(224.9,131.87) v2(226.3,139.56) v2(226.83,135.22) v2(227.01,157.08) v2(226.99,154.97) v2(226.99,154.27) v2(227,153.58) v2(227,152.17) v2(226.99,150.78) v2(227.01,147.27) v2(226.99,143.77) v2(226.99,143.06) v2(227.01,141.66) v2(227,140.26) v2(227,138.17) v2(226.99,136.77) v2(227.7,156.38) v2(227.7,153.56) v2(227.7,152.16) v2(227.7,150.77) v2(227.7,149.36) v2(227.71,146.57) v2(227.69,145.17) v2(227.7,143.77) v2(227.7,142.37) v2(227.7,141.66) v2(227.7,140.27) v2(227.7,139.57) v2(227.7,138.17) v2(227.7,136.77) v2(227.71,147.97) v2(228.4,156.38) v2(228.4,154.98) v2(228.4,147.97) v2(228.4,145.87) v2(229.1,156.36) v2(229.1,150.78) v2(229.1,145.86) v2(229.1,142.37) v2(229.1,140.97) v2(229.1,139.57) v2(229.1,138.17) v2(229.1,136.77) v2(229.12,143.77) v2(229.8,157.08) v2(229.81,156.38) v2(229.79,154.27) v2(229.8,145.87) v2(230.5,157.06) v2(230.5,156.37) v2(230.5,154.97) v2(230.5,153.57) v2(230.5,152.17) v2(230.5,147.98) v2(230.49,145.87) v2(230.5,142.37) v2(230.5,140.97) v2(230.5,139.57) v2(230.5,138.17) v2(230.5,136.77) v2(231.21,156.38) v2(231.2,154.96) v2(231.19,145.86) v2(231.89,157.07) v2(231.9,156.36) v2(231.89,154.97) v2(231.9,145.17) v2(231.9,143.77) v2(231.9,142.37) v2(231.89,140.97) v2(231.9,139.58) v2(231.89,136.78) v2(231.91,138.18) v2(232.6,157.08) v2(232.6,153.58) v2(232.6,152.18) v2(233.3,156.37) v2(233.31,154.97) v2(233.29,153.56) v2(233.3,152.16) v2(233.3,150.77) v2(233.3,146.57) v2(233.3,142.37) v2(233.3,140.97) v2(233.3,136.78) v2(234,157.08) v2(234,156.37) v2(234,150.07) v2(234.01,145.87) v2(234.7,156.37) v2(234.7,154.97) v2(234.7,150.07) v2(234.7,145.17) v2(234.7,143.77) v2(234.7,142.37) v2(234.7,140.98) v2(234.7,139.56) v2(234.7,136.76) v2(235.4,157.07) v2(235.4,156.36) v2(235.41,140.97) v2(236.1,156.37) v2(236.1,154.98) v2(236.11,152.18) v2(236.1,150.78) v2(236.1,150.06) v2(236.1,140.97) v2(236.1,139.57) v2(236.1,138.17) v2(236.1,136.77) v2(236.11,153.58) v2(236.79,157.07) v2(236.8,156.38) v2(236.8,154.96) v2(236.8,150.06) v2(236.8,144.46) v2(236.8,140.97) v2(237.5,156.37) v2(237.5,154.28) v2(237.49,150.76) v2(237.5,148.66) v2(237.51,147.27) v2(237.5,145.16) v2(237.51,140.97) v2(237.5,139.57) v2(237.5,138.17) v2(237.49,136.77) v2(238.19,157.07) v2(238.2,154.98) v2(238.21,147.98) v2(238.2,147.25) v2(238.2,145.86) v2(238.21,142.37) v2(238.2,136.76) v2(238.91,157.06) v2(238.89,156.37) v2(238.91,154.97) v2(238.9,153.57) v2(238.9,150.77) v2(238.9,145.88) v2(238.9,143.06) v2(238.9,142.37) v2(238.9,140.97) v2(238.9,139.57) v2(238.9,138.17) v2(238.9,136.77) v2(239.6,157.07) v2(239.61,156.37) v2(239.6,154.98) v2(239.61,145.86) v2(239.59,142.38) v2(240.3,156.37) v2(240.31,154.98) v2(240.29,154.27) v2(240.3,145.86) v2(240.3,143.77) v2(240.3,142.37) v2(240.3,140.97) v2(240.3,139.58) v2(240.3,138.18) v2(240.3,137.45) v2(240.31,150.77) v2(241.01,156.37) v2(241,147.26) v2(241,138.18) v2(241,136.77) v2(241.01,147.96) v2(241.7,156.37) v2(241.7,154.98) v2(241.7,153.56) v2(241.7,152.86) v2(241.7,150.77) v2(241.7,146.58) v2(241.7,142.37) v2(241.7,140.97) v2(241.7,139.57) v2(241.69,138.17) v2(242.4,156.36) v2(242.4,154.97) v2(242.4,150.78) v2(242.41,138.17) v2(243.1,156.37) v2(243.1,154.97) v2(243.1,146.57) v2(243.1,145.17) v2(243.1,143.77) v2(243.09,142.37) v2(243.1,140.98) v2(243.1,139.57) v2(243.1,138.17) v2(243.1,136.77) v2(243.79,157.06) v2(243.8,156.39) v2(243.8,154.97) v2(243.8,149.37) v2(243.8,142.38) v2(243.79,136.78) v2(244.5,157.06) v2(244.5,154.97) v2(244.49,142.37) v2(244.5,140.97) v2(244.5,139.57) v2(244.5,138.17) v2(244.5,136.77) v2(245.2,156.37) v2(245.19,154.96) v2(245.19,147.96) v2(245.2,142.38) v2(245.89,157.08) v2(245.9,156.37) v2(245.9,154.97) v2(245.9,145.18) v2(245.9,143.76) v2(245.9,140.97) v2(245.9,139.57) v2(245.9,138.17) v2(245.9,136.78) v2(246.6,156.38) v2(246.59,154.97) v2(246.61,147.97) v2(246.61,145.17) v2(246.6,143.06) v2(246.61,136.77) v2(247.3,156.37) v2(247.3,154.97) v2(247.29,149.36) v2(247.3,147.97) v2(247.3,145.17) v2(247.3,143.77) v2(247.3,142.37) v2(247.3,140.96) v2(247.29,140.28) v2(247.3,138.18) v2(247.3,136.77) v2(247.99,157.08) v2(248,156.37) v2(248,149.37) v2(248,146.57) v2(248,141.66) v2(248,138.17) v2(248,137.48) v2(248.01,136.78) v2(248.01,136.06) v2(248.7,145.17) v2(248.68,140.27) v2(248.7,137.47) v2(248.76,146.49) v2(248.75,143.85) v2(248.73,142.39) v2(248.73,138.88) v2(248.71,136.08) v2(248.87,153.66) v2(248.82,141.57) v2(249.31,138.21) v2(254.3,136.76) v2(254.29,136.07) v2(255.01,136.76) v2(255,136.07) v2(255.67,136.78) v2(255.7,136.06) v2(256.38,136.77) v2(256.4,136.07) v2(267.57,134.06) v2(267.62,134.71) v2(268.05,133.48) v2(268.27,134.73) v2(268.26,134.09) v2(268.75,133.47) v2(268.93,134.73) v2(268.95,134.1) v2(269.64,134.75) v3(214.33,110.02) v3(214.36,109.16) v3(215.22,110.02) v3(215.24,109.16) v3(216.11,110.02) v3(216.13,109.16) v3(217,110.02) v3(217.02,109.16) v3(217.05,108.29) v3(217.89,110.02) v3(217.91,109.16) v3(217.94,108.29) v3(220.53,110.25) v3(221.42,110.25) v3(222.31,110.25) v3(223.38,110.11) v3(223.38,109.22) v3(223.38,108.33) v3(223.38,107.44) v3(223.38,106.55) v3(223.38,105.67) v3(224.03,109.68) v3(224.03,108.79) v3(224.03,107.9) v3(224.03,107.01) v3(224.03,106.12) v3(224.67,108.34) v3(224.67,107.46) v3(224.67,106.57) v3(224.67,105.68) v3(224.79,109.94) v3(224.79,109.18) v3(225.5,109.63) v3(225.5,108.79) v3(225.46,108) v3(225.45,107.21) v3(225.45,106.37) v3(225.45,105.44) v3(226.39,109.63) v3(226.39,108.79) v3(227.28,110.47) v3(227.28,109.61) v3(227.28,108.79) v3(228.17,110.47) v3(229.06,110.52) v3(229.82,110.25) v3(230.71,110.25) v3(231.6,110.25) v3(232.49,110.25) v3(233.38,110.25) v3(234.22,110.17) v3(234.48,109.42) v3(234.48,108.54) v3(234.48,107.65) v3(234.48,106.76) v3(234.48,105.87) v3(234.9,110.63) v3(235.13,109.88) v3(235.13,108.99) v3(235.13,108.1) v3(235.13,107.21) v3(235.13,106.33) v3(235.77,110.33) v3(235.77,109.44) v3(235.77,108.55) v3(235.77,107.66) v3(235.77,106.77) v3(235.77,105.88) v3(236.6,110.44) v3(236.6,109.65) v3(236.6,108.87) v3(237.31,109.22) v3(237.49,110.44) v3(238.38,110.44) v3(239.22,110.44) v3(239.93,110.17) v3(240.82,110.17) v3(241.63,110.48) v3(242.04,109.77) v3(242.17,108.94) v3(242.64,110.41) v3(243.04,109.72) v3(243.13,108.9) v3(243.46,110.37) v3(243.84,109.64) v3(244,108.85) v3(244.27,105.34) v3(244.41,110.37) v3(244.62,109.32) v3(244.85,108.54) v3(244.85,107.65) v3(244.85,106.76) v3(244.85,105.87) v3(245.12,110.01) v3(245.46,109.25) v3(245.61,108.4) v3(245.74,107.65) v3(245.74,106.76) v3(245.74,105.87) v3(245.88,110.02) v3(246.23,108.85) v3(246.46,110.51) v3(247.22,110.47) v3(250.18,110.17) v3(251.07,110.17) v3(251.53,109.53) v3(251.96,110.2) v3(251.96,108.88) v3(252.36,109.56) v3(252.74,108.9) v3(252.84,110.2) v3(253.18,109.52) v3(253.52,108.85) v3(253.63,110.25) v3(253.95,109.52) v3(254.39,110.22) v3(254.39,108.8) v3(254.66,107.91) v3(254.66,107.02) v3(254.66,106.13) v3(254.74,109.52) v3(255.17,110.24) v3(255.14,108.55) v3(255.55,109.59) v3(255.55,107.91) v3(255.55,107.02) v3(255.55,106.13) v3(255.9,108.85) v3(255.93,110.25) v3(256.35,109.49) v3(256.73,110.25) v3(257.53,110.25) v3(258.31,110.24) v3(259.44,110.21) v3(260.33,110.21) v3(261,108.89) v3(261.02,105.34) v3(261.22,110.21) v3(261.57,109.51) v3(261.81,105.38) v3(261.93,108.84) v3(262.11,110.21) v3(262.35,109.48) v3(262.66,105.35) v3(263.06,110.53) v3(263.06,109.74) v3(263.06,108.85) v3(263.47,105.4) v3(263.95,110.53) v3(263.95,109.74) v3(263.95,108.85) v3(264.42,107.65) v3(264.42,106.76) v3(264.42,105.87) v3(264.66,109.3) v3(264.65,108.42) v3(264.84,110.53) v3(265.28,109.74) v3(265.28,108.85) v3(265.3,107.16) v3(265.3,106.28) v3(265.3,105.39) v3(265.33,108.01) v3(265.73,110.53) v3(266.62,110.53) v3(267.51,110.53) v3(268.39,110.53) v3(269.23,110.17) v3(270.12,110.17) v3(270.56,109.55) v3(270.87,110.45) v3(271.04,108.91) v3(271.3,109.81) v3(271.76,110.45) v3(271.82,109.23) v3(272.57,110.55) v3(272.57,109.71) v3(272.57,108.84) v3(273.46,110.55) v3(273.46,109.71) v3(273.46,108.84) v3(274.14,108.54) v3(274.14,107.65) v3(274.14,106.76) v3(274.14,105.87) v3(274.26,110.55) v3(274.26,109.66) v3(274.92,110.19) v3(274.92,109.3) v3(275.03,108.54) v3(275.03,107.65) v3(275.03,106.76) v3(275.03,105.87) v3(275.7,110.55) v3(276.59,110.55) v3(277.47,110.55) v3(278.27,110.55) v3(279.13,110.55) v3(279.99,110.55) v3(280.18,105.37) v3(280.31,109.76) v3(280.31,108.92) v3(280.86,110.55) v3(280.98,105.39) v3(281.19,109.81) v3(281.19,108.92) v3(281.72,110.55) v3(281.83,105.43) v3(282.08,109.81) v3(282.08,108.92) v3(282.53,110.55) v3(282.67,105.41) v3(282.97,109.81) v3(282.97,108.92) v3(283.42,110.64) v3(283.56,105.45) v3(283.86,109.81) v3(283.86,108.92) v3(284.01,108.11) v3(284.01,107.23) v3(284.01,106.34) v3(284.31,110.64) v3(284.44,105.52) v3(284.75,109.81) v3(284.75,108.92) v3(284.89,108.1) v3(284.89,107.21) v3(284.89,106.32) v3(285.19,110.64) v3(286.08,110.64) v3(286.97,110.64) v3(290.19,105.41)
