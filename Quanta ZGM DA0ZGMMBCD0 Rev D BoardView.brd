# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VMD_WCK45: length 28.3
  IN4 w0.102: v2(250.09,156.35) 250.37,156.07 250.37,155.82 250.84,155.36 251.32,155.36 252.4,156.44 258.1,156.44 260.14,158.48 260.14,158.92 261.21,159.99 265.69,159.99 266.39,160.7 271.82,160.7 272.27,161.14 272.27,161.73 v2(272.45,161.91)
  BOTTOM w0.102: UG6.P10 250.45,156.71 v2(250.09,156.35) ; v2(272.45,161.91) 272.27,162.09 272.27,162.43 272.25,162.44 272.25,162.92 271.97,163.2 VRAM5.R4
VMD_WCK45#: length 28.4
  IN4 w0.102: v2(250.8,156.35) 250.68,156.35 250.58,156.25 250.58,155.9 250.92,155.56 251.23,155.56 252.31,156.64 258.01,156.64 259.94,158.56 259.94,159 261.13,160.2 265.6,160.2 266.31,160.9 271.74,160.9 272.06,161.23 272.06,161.85 271.96,161.95 v2(271.67,161.95)
  BOTTOM w0.102: VRAM5.R5 271.96,162.45 272.06,162.34 272.06,161.59 271.96,161.49 271.78,161.49 271.67,161.6 v2(271.67,161.95) ; v2(250.8,156.35) 250.77,156.38 250.77,156.52 250.97,156.72 UG6.P9
VMD_WCK67: length 35.1
  IN4 w0.102: v2(250.09,152.16) 250.25,152.16 250.35,152.06 250.35,151.82 250.58,151.6 252.05,151.6 252.62,152.16 255.83,152.16 256.36,152.69 256.36,153.31 257.17,154.12 259.66,154.12 259.88,154.34 259.88,154.59 259.99,154.71 260.18,154.71 260.28,154.61 260.28,154.34 260.5,154.12 265.16,154.12 265.75,154.7 265.75,155.19 266.02,155.45 267.12,155.45 267.36,155.69 267.36,158.09 266.25,159.19 266.25,159.69 266.74,160.18 267.27,160.18 267.37,160.08 267.37,160.03 267.59,159.81 267.96,159.81 268.18,160.03 268.18,160.08 268.28,160.18 268.49,160.18 268.59,160.08 268.59,160.03 268.81,159.81 269.18,159.81 269.4,160.03 269.4,160.08 269.5,160.18 269.71,160.18 269.81,160.08 269.81,160.03 270.03,159.81 270.4,159.81 270.62,160.03 270.62,160.08 270.72,160.18 271.63,160.18 271.73,160.07 271.73,159.35 271.63,159.25 v2(271.45,159.25)
  BOTTOM w0.102: UG6.Y10 250.45,152.52 v2(250.09,152.16)
  BOTTOM w0.114: VRAM5.R11 271.49,158.33 271.49,159.21 v2(271.45,159.25)
VMD_WCK67#: length 35.1
  IN4 w0.102: v2(250.8,152.19) 250.66,152.19 250.56,152.08 250.56,151.9 250.66,151.8 251.96,151.8 252.53,152.37 255.75,152.37 256.16,152.78 256.16,153.4 257.08,154.32 259.57,154.32 259.67,154.42 259.67,154.68 259.91,154.91 260.27,154.91 260.49,154.69 260.49,154.42 260.59,154.32 265.08,154.32 265.55,154.79 265.55,155.27 265.94,155.66 267.03,155.66 267.15,155.78 267.15,158 266.05,159.1 266.05,159.77 266.66,160.38 267.35,160.38 267.57,160.16 267.57,160.11 267.67,160.01 267.88,160.01 267.98,160.11 267.98,160.16 268.2,160.38 268.57,160.38 268.79,160.16 268.79,160.11 268.89,160.01 269.1,160.01 269.2,160.11 269.2,160.16 269.42,160.38 269.79,160.38 270.01,160.16 270.01,160.11 270.11,160.01 270.32,160.01 270.42,160.11 270.42,160.16 270.64,160.38 271.72,160.38 271.94,160.16 271.94,159.31 272.04,159.21 272.22,159.21 v2(272.26,159.25)
  BOTTOM w0.102: UG6.Y9 251.14,152.52 v2(250.8,152.19)
  BOTTOM w0.114: VRAM5.R10 271.86,158.71 271.86,159.44 271.96,159.53 272.14,159.53 272.26,159.41 v2(272.26,159.25)
VMD_WCKB01: length 29.5
  IN4 w0.114: v2(271.59,144.87) 271.72,144.87 271.88,144.7 271.88,144.38 271.77,144.26 271.06,144.26 270.02,143.23 270.02,142.45 269.39,141.82 269.39,139.98 268.35,138.94 257.93,138.94 255.97,140.91 250.99,140.91 250.69,141.21 250.69,141.4 250.65,141.44 250.65,141.55 250.77,141.67 v2(250.79,141.67)
  BOTTOM w0.102: v2(250.79,141.67) 250.76,141.7 250.76,141.85 250.93,142.02 UG6.AR9
  BOTTOM w0.114: VRAM7.D4 271.88,143.54 271.52,143.9 271.52,144.04 271.52,144.05 271.52,144.34 271.64,144.47 271.64,144.81 v2(271.59,144.87)
VMD_WCKB01#: length 29.3
  IN4 w0.114: v2(272.24,144.87) 272.11,144.74 272.11,144.28 271.86,144.04 271.15,144.04 270.25,143.13 270.25,142.36 269.62,141.73 269.62,139.88 268.45,138.71 257.84,138.71 255.87,140.68 250.9,140.68 250.46,141.12 250.46,141.31 250.14,141.63 v2(250.03,141.63)
  BOTTOM w0.102: v2(250.03,141.63) 250.43,142.02 UG6.AR10
  BOTTOM w0.114: v2(272.24,144.87) 271.88,144.51 VRAM7.D5
VMD_WCKB23: length 26.8
  IN4 w0.102: v2(272.21,147.06) 272.08,147.06 271.98,146.96 271.98,146.54 271.37,145.93 260.04,145.93 259.31,145.19 258.16,145.19 257.47,145.88 256.87,145.88 255.85,144.87 250.58,144.87 250.35,145.09 250.35,145.62 v2(250.11,145.87)
  BOTTOM w0.102: v2(250.11,145.87) 250.45,146.21 UG6.AJ10
  BOTTOM w0.114: v2(272.21,147.06) 272.21,147.07 272.21,148.36 VRAM7.D11
VMD_WCKB23#: length 26.8
  IN4 w0.102: v2(250.8,145.86) 250.66,145.86 250.56,145.76 250.56,145.17 250.66,145.07 255.77,145.07 256.78,146.08 257.56,146.08 258.24,145.4 259.22,145.4 259.96,146.13 271.29,146.13 271.78,146.62 271.78,147.04 271.79,147.05 271.79,147.23 271.68,147.34 271.5,147.34 271.4,147.23 v2(271.4,147)
  BOTTOM w0.102: v2(250.8,145.86) 250.78,145.88 250.78,146.03 250.97,146.22 UG6.AJ9
  BOTTOM w0.114: VRAM7.D10 272,147.82 272,147.4 271.82,147.22 271.82,147.04 271.7,146.93 271.47,146.93 v2(271.4,147)
VMD_WCKB45: length 18.6
  IN4 w0.102: v2(263.28,161.96) 263.37,161.96 263.47,161.86 263.47,161.6 263.36,161.49 260.51,161.49 258.85,159.83 255.25,159.83 254.88,159.45 254.88,159.02 254.64,158.78 250.63,158.78 250.33,158.48 250.33,157.3 v2(250.09,157.06)
  BOTTOM w0.102: UG6.N10 v2(250.09,157.06) ; VRAM5.D4 263.57,163.2 263.25,162.88 263.25,162 v2(263.28,161.96)
VMD_WCKB45#: length 18.6
  IN4 w0.102: v2(263.93,161.96) 263.77,161.96 263.67,161.86 263.67,161.51 263.44,161.29 260.59,161.29 258.93,159.63 255.34,159.63 255.08,159.37 255.08,158.93 254.72,158.58 250.72,158.58 250.54,158.4 250.54,157.16 250.64,157.06 v2(250.8,157.06)
  BOTTOM w0.102: UG6.N9 251.15,157.54 251.05,157.64 250.85,157.64 250.75,157.55 250.75,157.11 v2(250.8,157.06) ; VRAM5.D5 263.63,162.18 263.85,161.96 v2(263.93,161.96)
VMD_WCKB67: length 18.5
  IN4 w0.102: v2(251.49,153.56) 251.3,153.37 251.3,153.2 251.59,152.9 252.08,152.9 252.64,153.47 255.21,153.47 256.41,154.66 256.41,155.52 256.81,155.91 258.06,155.91 260.41,158.26 260.41,158.63 260.71,158.94 262.76,158.94 262.92,158.77 263.17,158.77 263.27,158.87 263.27,159.05 v2(263.02,159.31)
  BOTTOM w0.102: UG6.W9 v2(251.49,153.56) ; VRAM5.D11 263.25,158.32 263.25,159.07 v2(263.02,159.31)
VMD_WCKB67#: length 18.3
  IN4 w0.102: v2(263.71,159.31) 263.47,159.07 263.47,158.79 263.25,158.57 262.84,158.57 262.67,158.73 260.8,158.73 260.61,158.55 260.61,158.17 258.15,155.71 256.89,155.71 256.61,155.43 256.61,154.58 255.3,153.26 252.73,153.26 252.17,152.7 251.51,152.7 251.09,153.12 251.09,153.29 v2(250.8,153.59)
  BOTTOM w0.102: UG6.W10 250.45,153.24 v2(250.8,153.59) ; v2(263.71,159.31) 263.63,159.22 VRAM5.D10
VR_SVID_ALERT#: length 131.7
  IN2 w0.089: v1(181.08,155.19) 182.38,156.49 182.38,164.48 181.28,165.58 181.28,168.42 177.32,172.38 118.67,172.38 116.97,174.08 116.97,174.42 110.21,181.18 110.21,195.08 111.01,195.88 111.01,197.81 110.71,198.1 110.71,203.26 113.01,205.56 113.94,205.56 115.14,206.76 115.76,206.76 117.91,208.92 117.91,212.72 118.95,213.76 v2(118.95,215.11)
  BOTTOM w0.14: R790.2 v1(181.08,155.19) R791.1 ; PR358.2 118.95,215.34 v2(118.95,215.11) 118.95,214.89 PR372.1
VR_SVID_CLK: length 131.5
  IN2 w0.089: v2(119.57,215.06) 119.57,213.71 118.38,212.52 118.38,208.72 115.95,206.29 115.33,206.29 114.13,205.09 113.21,205.09 111.18,203.07 111.18,198.3 111.48,198 111.48,195.02 110.68,194.22 110.68,181.37 117.44,174.61 117.44,174.27 118.86,172.85 177.51,172.85 183.23,167.13 v1(183.23,166)
  BOTTOM w0.14: PR359.2 119.5,215.12 v2(119.57,215.06) 119.77,214.86 119.77,214.81 PR370.1 ; v1(183.23,166) 183.8,165.43 183.8,158.85 181.66,156.71 R789.2 R788.2
VR_SVID_CLK_R: length 11.1
  IN1 w0.086: v1(179.59,155.83) 179.37,155.83 178.08,154.54 178.08,152.42 176.18,150.52 175.27,150.52 173.86,149.11 173.86,148.98 v2(173.87,148.97)
  BOTTOM w0.102: v2(173.87,148.97) 173.86,148.97 173.71,148.82 U42.E32
  BOTTOM w0.14: R788.1 179.84,156.08 v1(179.59,155.83)
VR_SVID_DATA: length 131.7
  IN2 w0.089: v2(118.34,215.11) 118.34,213.81 117.44,212.91 117.44,209.11 115.56,207.23 114.94,207.23 113.74,206.03 112.82,206.03 110.24,203.46 110.24,197.91 110.54,197.61 110.54,196.07 109.74,195.28 109.74,180.98 115.85,174.87 115.85,174.04 117.98,171.91 177.12,171.91 180.81,168.23 180.81,155.71 v1(179.56,154.47)
  BOTTOM w0.14: PR357.2 117.98,215.54 118.34,215.18 v2(118.34,215.11) 118.34,214.78 PR371.1 ; v1(179.56,154.47) 179.73,154.3 R792.2
VRALERT#: length 19.7
  TOP w0.14: v1(221.39,62.73) 221.39,62.88 221.81,63.3 222.39,63.3 223.65,62.04 R510.1 ; v1(230.88,60.95) 230.83,61 230.83,63.52 230.64,63.72 230.64,64.35 230.45,64.53 Q48.3
  IN2 w0.089: v1(221.39,62.73) 221.39,62.17 223.49,60.07 226.05,60.07 226.51,59.61 228.58,59.61 229,60.03 230.05,60.03 230.3,60.29 230.3,60.62 230.64,60.95 v1(230.88,60.95)
  BOTTOM w0.102: U49.AY35 221.35,62.58 221.35,62.69 v1(221.39,62.73)
VRON: length 266.5
  TOP w0.14: v1(111.96,91.6) 110.29,89.94 110.29,83.6 110.03,83.33 110.03,76.48 109.71,76.17 109.71,75.23 109,74.51 109,69.39 110.63,67.76 110.63,64.49 110.37,64.22 110.37,59.52 111.35,58.54 v1(111.4,58.54) ; v1(123.25,213.6) 123.48,213.38 123.48,211.84 123.79,211.53 124.35,211.53 124.55,211.32 PU3.1 ; R534.1 185.9,60.83 184.83,60.83 184.5,60.5 U23.69 182.58,60.5 v1(182.4,60.32)
  IN1 w0.086: v1(111.96,91.6) 111.96,95.89 114.27,98.2 114.27,117.26 113.34,118.19 113.34,121.76 113.12,121.97 113.12,122.54 115.96,125.38 115.96,136.19 119.02,139.26 119.02,143.5 119.94,144.42 119.94,154.78 115.63,159.09 v1(115.6,159.09)
  IN2 w0.089: v1(111.4,58.54) 113.76,60.9 121.91,60.9 125.15,64.14 130.05,64.14 130.91,65 148.1,65 148.35,65.25 156.88,65.25 157.44,65.81 158.14,65.81 159.16,64.78 160.05,64.78 161.45,63.38 161.56,63.38 161.66,63.29 163.68,63.29 164.5,62.47 164.76,62.47 164.84,62.4 167.88,62.4 168.67,61.6 169.32,61.6 170.03,60.89 174.64,60.89 174.92,61.18 180.74,61.18 181.6,60.32 v1(182.4,60.32)
  IN3 w0.089: v1(121.8,216.52) 122.59,215.73 122.9,215.73 123.39,215.24 123.39,213.74 v1(123.25,213.6)
  IN4 w0.086: v1(115.6,159.09) 115.58,159.07 112.12,159.07 108.98,162.21 108.98,195.7 109.77,196.49 109.77,201.81 112.08,204.11 117.97,204.11 118.73,204.88 118.73,205.27 123.25,209.8 v1(123.25,213.6)
  BOTTOM w0.14: v1(121.8,216.52) PR362.1
VSTBY_FSPI: length 6.3
  TOP w0.203: U23.106 178.31,74.39 178.22,74.48
  TOP w0.381: 178.22,74.48 178.22,75.25 178.46,75.5 C376.2 179.12,75.9 v1(179.12,76.23) 179.12,76.81 R338.2 179.55,78.2 R319.2
WIGIG_LED: length 3.1
  BOTTOM w0.14: TP153.1 272.87,62.58 273.35,62.1 274.4,62.1 274.54,62.24 CN12.6
WLAN_CLKREQ#: length 1.6
  BOTTOM w0.14: CN12.53 284.4,73.99 v1(284.55,73.84)
  vias: v1(283.51,72.07)
WLAN_RST#: length 3.2
  BOTTOM w0.14: CN12.52 274.29,73.74 273.9,73.35 v1(273.61,73.35) 272.7,73.35 R951.1
WLAN_WAKE_R#: length 4.3
  TOP w0.14: v1(284.99,74.32) 284.78,74.32 284.28,74.81 Q38.1 283.52,74.81 283.4,74.93 R365.2
  BOTTOM w0.14: v1(284.99,74.32) 284.81,74.49 CN12.55
WLANPWR#: length 140.4
  TOP w0.14: v1(269.07,72.43) 268.79,72.15 R403.1 ; U23.83 184.52,66.1 184.76,65.86 185.71,65.86 186.08,66.23 186.08,66.7 186.48,67.1 188.89,67.1 190.03,65.97 192.15,65.97 192.64,65.49 192.64,64.58 191.05,63 191.05,57.08 189.78,55.82 v1(189.78,52.13) 189.78,51.09 v1(189.62,50.93)
  IN3 w0.089: v1(269.07,72.43) 269.07,72.46 269.52,72.91 271.24,72.91 271.77,73.45 272.99,73.45 273.54,72.89 273.54,66.24 272.44,65.14 272.44,64.37 272.14,64.07 270.87,64.07 270.16,63.36 270.16,61.79 270.67,61.28 270.67,60.01 269.65,59 264.89,59 263.35,57.45 262.27,57.45 259.81,54.99 257.94,54.99 257.63,55.3 251.63,55.3 250.97,55.96 246.61,55.96 245.95,55.3 239.44,55.3 238.2,54.06 238.2,53.54 237.93,53.28 236.94,53.28 236.15,52.49 235.54,52.49 235.17,52.87 229.91,52.87 229.28,52.24 228.79,52.24 228.3,52.73 227.88,52.73 227.51,52.36 224.52,52.36 222.85,50.69 222.63,50.69 221.61,49.67 220.74,49.67 220.02,50.39 216.03,50.39 214.97,49.34 214.97,48.03 214.68,47.74 212.79,47.74 212.55,47.98 209.42,47.98 209.31,48.09 208.66,48.09 207.96,48.79 206.91,48.79 206.22,48.1 204.78,48.1 203.49,46.81 198.76,46.81 198.55,47.01 195.72,47.01 194.59,48.13 193.42,48.13 192.77,48.79 190.84,48.79 189.78,49.85 189.78,50.76 v1(189.62,50.93)
WRST#: length 142.3
  TOP w0.14: D34.2 160.5,70.06 v1(159.83,69.39) 159.48,69.05 159.48,68.35 159.96,67.86 163.39,67.86 163.68,67.58 R458.1 163.87,67.4 164.53,66.74 165.05,66.74 165.3,66.49 C448.1 165.46,66.1 U23.14 168.72,66.1 169.51,65.31 169.51,64.22 169.19,63.9 169.19,63.48 v1(169.66,63.01) ; Q53.6 258.26,56.29 258.32,56.35 v1(258.45,56.35)
  IN2 w0.089: v1(169.66,63.01) 169.93,62.75 170.8,62.75 170.98,62.56 172.09,62.56 172.41,62.25 173.13,62.25 174.04,63.16 174.53,63.16 175.24,62.45 178.02,62.45 178.68,63.1 180.89,63.1 181.34,63.55 181.83,63.55 182.18,63.21 182.18,62.81 183.67,61.32 183.67,59.81 185.02,58.45 185.89,58.45 187.98,56.35 189.99,56.35 192.03,54.32 192.03,54.01 197.01,49.03 200.94,49.03 201.49,49.57 208.25,49.57 208.45,49.37 214.5,49.37 217.08,51.95 226.97,51.95 228.08,50.84 231.05,50.84 231.4,51.19 231.4,51.66 231.7,51.95 232.82,51.95 234.04,50.74 238.48,50.74 238.81,50.41 243.93,50.41 244.29,50.77 249.25,50.77 249.65,51.17 254.65,51.17 254.95,51.47 258.95,51.47 259.39,51.91 265.41,51.91 266.71,53.22 268.33,53.22 v1(268.69,53.58)
  BOTTOM w0.14: v1(258.45,56.35) 258.48,56.35 258.53,56.41 267.99,56.41 268.69,55.7 v1(268.69,53.58)
WWAN_ANTCTL0: length 2.3
  BOTTOM w0.14: CN7.59 299.87,78.75 299.22,79.41 TP143.1
WWAN_ANTCTL1: length 2.8
  BOTTOM w0.14: TP144.1 298.73,78.17 299.06,77.84 299.65,77.84 300.06,78.25 CN7.61
WWAN_ANTCTL2: length 3.2
  BOTTOM w0.14: CN7.63 300.17,77.75 299.98,77.56 297.95,77.56 TP145.1
WWAN_ANTCTL3: length 2.1
  TOP w0.14: v1(302.1,77.51) 302.1,77.02 TP48.1
  BOTTOM w0.14: CN7.65 301.85,77.25 v1(302.1,77.51)
WWAN_CLK_C_N: length 5.5
  BOTTOM w0.14: CN7.53 300.05,80.25 299.88,80.43 299.88,83.19 299.36,83.71 298.83,83.71 R890.1
WWAN_CLK_C_P: length 5.6
  BOTTOM w0.14: R900.1 298.77,83.44 299.25,83.44 299.61,83.08 299.61,80.32 300.17,79.75 CN7.55
WWAN_CONFIG0: length 1.8
  BOTTOM w0.14: R857.1 299.7,88.55 299.99,88.25 CN7.21
WWAN_CONFIG1: length 3.1
  BOTTOM w0.14: R940.1 298.5,76.21 298.74,76.45 v1(299.29,76.45) 299.87,76.45 300.06,76.25 CN7.69
WWAN_CONFIG2: length 2.5
  BOTTOM w0.14: CN7.75 299.71,74.75 299.47,74.99 v1(299.19,74.99) R944.1
WWAN_CONFIG3: length 1.9
  BOTTOM w0.14: CN7.1 300.05,93.25 299.75,93.56 R838.1
WWAN_DPR_SAR_ODL: length 64.9
  TOP w0.14: v1(280.15,62.25) 280.15,61.87 281.03,60.99 281.03,59.29 281.29,59.03 D45.2 282.33,59.03 282.82,58.53 R559.2 ; v1(299.14,80.63) 299.9,81.4 299.9,81.95 298.55,83.3 298.55,85.72 299.55,86.72 v1(299.55,87.21)
  IN2 w0.089: v1(299.14,80.63) 298.86,80.63 297.93,79.71 296.05,79.71 295.46,80.29 293.02,80.29 292.8,80.51 291.11,80.51 290.01,79.41 289.17,79.41 288.63,78.87 287.34,78.87 282.75,74.28 282.75,71.81 282.4,71.46 282.07,71.14 281.69,71.14 281.61,71.06 281.55,71.06 280.47,69.98 280.47,69.3 279.63,68.46 279.63,66.36 280.15,65.83 v1(280.15,62.25)
  BOTTOM w0.14: Q107.1 298.64,85.57 298.78,85.43 299.78,85.43 299.94,85.59 299.94,86.82 v1(299.55,87.21) 299.59,87.25 CN7.25 ; v1(280.15,62.25) 277.94,62.25 276.51,60.82 276.51,60.01 276.28,59.79 275.11,59.79 274.06,58.73 272.21,58.73 271.66,58.18 R1231.1 270.76,58.15 D70.2
WWAN_PCIE_WAKE_ODL_R: length 5.1
  TOP w0.14: v1(310.64,81.66) 310.64,82.41 R262.1 311.16,82.93 Q27.1
  BOTTOM w0.14: v1(310.64,81.66) 310.64,81.18 310.16,80.7 309.91,80.7 309.21,80 CN7.54
WWAN_PST_L_EC: length 197.7
  TOP w0.14: D15.1 311.42,89.98 v1(311.42,90.58) ; v1(167.98,57.87) 167.57,57.46 R1189.2 167.57,56.44 167.9,56.11 168.46,56.11 169.14,55.43 R585.2 170.71,56.21 U23.36
  IN3 w0.089: v1(311.42,90.58) 311.21,90.79 311.21,91.59 311.95,92.33 311.95,93.41 311.66,93.71 309.75,93.71 309.33,93.29 309.14,93.29 308.77,93.66 308.77,94.12 307.48,95.4 304.67,95.4 301.87,92.6 301.87,90.7 298.65,87.48 298.65,86.77 297.59,85.71 297.59,84.49 296,82.9 293.01,82.9 287.35,77.24 287.35,76.13 285.99,74.77 284.74,74.77 283.98,74 283.98,71.71 282.22,69.96 282.22,69.2 281.21,68.18 281.21,63.9 281.58,63.53 281.58,59.58 280.12,58.13 279.43,58.13 276.26,54.95 275.17,54.95 274.86,55.27 273.36,55.27 273.17,55.08 271.23,55.08 270.29,56.02 267.63,56.02 266.45,54.85 265.15,54.85 264.46,54.15 262.85,54.15 260.95,52.25 256.8,52.25 256.49,52.56 252.78,52.56 252.24,52.02 250.39,52.02 249.39,53.03 247.82,53.03 247.14,52.35 243.61,52.35 241.43,50.17 238.07,50.17 237.21,49.31 231.04,49.31 230.37,48.63 224.94,48.63 221.22,44.91 219.11,44.91 218.97,44.78 210.22,44.78 208.76,43.31 200.5,43.31 200.25,43.06 198.48,43.06 197.41,44.13 191.44,44.13 187.29,48.28 183.46,48.28 v1(183.14,48.6)
  BOTTOM w0.14: v1(167.98,57.87) 168.43,58.33 169.74,58.33 174.86,53.21 177.67,53.21 180.98,49.9 180.98,49.25 181.48,48.75 182.2,48.75 182.33,48.88 182.86,48.88 v1(183.14,48.6)
WWAN_RESET#: length 188.4
  TOP w0.14: v1(181.24,76.58) 181.24,76.18 181.74,75.68 R362.2 ; v1(302.2,88.08) 301.55,88.08 300.9,87.43 R202.1 300.9,86.71 300.93,86.68 Q26.3
  IN3 w0.089: v1(182.17,50.1) 181.81,50.1 181.41,49.7 181.41,48.59 182.31,47.69 186.62,47.69 190.75,43.56 197.17,43.56 198.24,42.49 200.75,42.49 201,42.74 209.98,42.74 211.44,44.21 219.21,44.21 219.34,44.34 221.46,44.34 225.18,48.06 230.6,48.06 231.28,48.74 237.45,48.74 237.52,48.81 238.39,48.81 239,49.42 241.49,49.42 243.84,51.77 247.38,51.77 248.06,52.46 249.15,52.46 250.31,51.29 261.07,51.29 263,53.22 264.75,53.22 265.61,54.09 266.77,54.09 267.94,55.26 269.97,55.26 270.92,54.31 273.03,54.31 273.45,53.9 276.28,53.9 279.75,57.36 280.44,57.36 282.34,59.27 282.34,63.84 281.98,64.2 281.98,67.88 282.98,68.88 282.98,69.15 284.74,70.91 284.74,72.44 287.32,75.02 288.67,75.02 289.07,75.41 289.07,77.88 293.32,82.14 296.42,82.14 298.35,84.07 298.35,85.39 299.34,86.37 300.5,86.37 v1(302.2,88.08)
  BOTTOM w0.14: v1(182.17,50.1) 182.25,50.18 182.25,51.39 182.68,51.83 182.68,52.62 182.35,52.95 182.35,53.5 182.02,53.82 182.02,57.33 181.03,58.33 181.03,61.81 179.47,63.37 179.47,66.7 179.26,66.91 179.26,68.29 180.1,69.13 180.1,72.88 181.48,74.26 181.48,76.35 v1(181.24,76.58)
WWAN_RESET#_C: length 14.6
  TOP w0.14: Q26.1 301.43,84.32 301.48,84.27 R239.1 301.48,83.58 301.53,83.53 C308.2 301.53,82.18 301.92,81.79 302.81,81.79 302.9,81.7 303.29,81.31 303.68,81.31 303.94,81.58 305.41,81.58 v1(305.46,81.52)
  BOTTOM w0.14: v1(305.46,81.52) 304.24,80.31 304.24,78.6 302.4,76.75 CN7.67
WWAN_SAR#: length 185.9
  TOP w0.14: R488.2 165.38,64.37 v1(164.82,63.82) ; v1(303.06,79.68) 303.28,79.9 303.28,80.93 302.7,81.51 301.05,81.51 299.04,83.53 v1(299.04,84.28)
  IN2 w0.089: v1(303.06,79.68) 301.79,79.68 301.25,80.23 298.76,80.23 298.05,79.52 295.97,79.52 295.36,80.13 292.92,80.13 292.72,80.32 291.19,80.32 290.09,79.22 289.25,79.22 288.71,78.68 287.42,78.68 282.94,74.2 282.94,71.27 282.01,70.34 281.09,70.34 280.66,69.9 280.66,69.22 279.82,68.38 279.82,67.32 280.53,66.6 280.53,62.38 280.84,62.08 280.84,58.9 280.24,58.31 279.37,58.31 277.52,56.47 277.52,55.4 276.7,54.58 276.7,54.51 274.09,51.9 270.77,51.9 270.03,52.65 267.28,52.65 265.3,50.67 254.96,50.67 253.91,49.62 249.2,49.62 248.62,50.2 245.86,50.2 245.49,49.84 238.57,49.84 238.24,50.17 231.46,50.17 231.24,49.95 220.41,49.95 219.88,49.43 219.88,48.08 218.86,47.05 215.39,47.05 214.71,47.74 208.56,47.74 207.28,46.46 205.19,46.46 205.16,46.43 201.4,46.43 200.79,47.04 195.14,47.04 194.43,47.74 193.67,47.74 191.92,49.5 191.92,50.77 189.19,53.5 v1(189.19,54.8)
  IN3 w0.089: v1(188.77,58.95) 187.81,58.95 186.82,59.95 185.26,59.95 183.69,61.51 181.64,61.51 181.1,62.05 178.04,62.05 175.58,64.51 169.99,64.51 169.44,65.06 166.49,65.06 165.25,63.82 v1(164.82,63.82)
  BOTTOM w0.14: v1(189.19,54.8) 188.77,55.22 v1(188.77,58.95)
WWAN_SIM1_CLK: length 105.1
  IN2 w0.089: v1(312.68,86.35) 312.3,85.97 311.49,85.97 310.69,86.78 310.69,88.02 309.34,89.36 308.73,89.36 308.18,89.91 306.08,89.91 305.65,90.34 305.24,90.34 304.24,91.34 304.24,91.89 303.92,92.21 302.8,92.21 302.4,91.82 298.39,91.82 296.55,89.98 296.55,88.48 296.28,88.21 294.37,88.21 293.29,87.13 293.29,86.05 292.68,85.44 289.07,85.44 288.9,85.28 287.75,85.28 287.42,85.6 283.96,85.6 280.8,82.45 276.84,82.45 275.49,81.1 275.49,77.74 274.44,76.69 274.44,75.52 273.87,74.95 273.87,72.02 271.25,69.39 271.25,67.79 270.06,66.61 268.98,66.61 267.09,64.71 265.76,64.71 264.19,63.15 260.94,63.15 259.47,61.68 258.21,61.68 257.38,62.51 252.84,62.51 251.09,60.75 247.79,60.75 247.11,61.43 242.71,61.43 241.19,59.92 v1(240.5,59.92)
  BOTTOM w0.14: v1(240.5,59.92) 240.55,59.87 240.55,58.24 240.28,57.97 R1025.2 ; v1(312.68,86.35) 312.4,86.08 D68.1 312.04,85.64 311.67,86.01 309.95,86.01 309.45,85.51 CN7.32
WWAN_SIM1_CLK_C: length 2.6
  BOTTOM w0.14: LG7.2 239.08,60 239.37,60.29 240.01,60.29 240.64,60.92 J1.3
WWAN_SIM1_DATA: length 99.4
  IN2 w0.089: v1(241.86,58.75) 241.86,58.76 244.06,60.96 246.92,60.96 247.59,60.28 251.28,60.28 253.03,62.04 257.18,62.04 258.01,61.21 259.66,61.21 261.13,62.68 264.39,62.68 265.95,64.24 267.29,64.24 269.18,66.14 270.26,66.14 271.72,67.6 271.72,69.19 274.34,71.82 274.34,74.75 274.91,75.33 274.91,76.5 275.96,77.55 275.96,80.9 277.04,81.98 281.94,81.98 283.97,84.01 285.78,84.01 286.58,84.81 289.1,84.81 289.26,84.97 292.88,84.97 293.76,85.85 293.76,86.84 294.66,87.74 296.57,87.74 297.06,88.23 297.06,89.82 298.59,91.35 303.56,91.35 305.04,89.87 305.46,89.87 305.89,89.44 307.79,89.44 310.1,87.12 310.1,86.7 311.29,85.51 v1(311.43,85.51)
  BOTTOM w0.14: v1(241.86,58.75) 241.86,58.64 242.34,58.16 R1026.2 ; v1(311.43,85.51) 311.58,85.36 311.58,84.61 D69.1 310.57,85.37 309.97,85.37 309.61,85 CN7.34
WWAN_SIM1_DATA_C: length 1.9
  BOTTOM w0.14: LG8.2 241.22,59.82 241.91,60.51 J1.7
WWAN_SIM1_DET_OD: length 16.6
  TOP w0.14: QG16.1 313.15,85.31 313.15,83.95 313.17,83.93 R251.1 313.17,83.47 313.03,83.33 312.78,83.33 312.52,83.07 R258.2 312.54,82.88 R259.1 313.18,82.67 313.39,82.46 314,82.46 v1(314.15,82.61)
  BOTTOM w0.14: v1(314.15,82.61) 313.64,82.11 312.56,82.11 312.36,81.91 312.36,79.6 311.96,79.2 311.96,77.73 311.61,77.37 311.29,77.37 310.88,76.96 310.88,76.71 D61.1 310.69,76.53 309.79,76.53 309.32,77 CN7.66
WWAN_SIM1_PWR: length 9.2
  IN1 w0.508: v1(243.23,58.73) 243.23,59.04 242.83,59.45 241.33,59.45 240.97,59.09 239.86,59.09 239.3,59.65 236.86,59.65 236.5,60.01 235.92,60.01 v1(235.87,60.06)
  BOTTOM w0.203: v1(243.23,58.73) 242.89,59.06 R1018.1
  vias: v1(309.76,84.16)
WWAN_SIM1_RST: length 109.9
  IN2 w0.089: v1(242.55,58.78) 244.26,60.49 246.72,60.49 247.4,59.81 252.72,59.81 252.8,59.9 259.65,59.9 261.42,61.68 265.18,61.68 266.53,63.02 266.53,63.46 266.84,63.77 268.3,63.77 270.19,65.67 270.45,65.67 272.19,67.4 272.19,69 274.81,71.63 274.81,74.56 275.38,75.13 275.38,76.3 276.43,77.35 276.43,80.71 277.23,81.51 282.14,81.51 284.16,83.54 285.97,83.54 286.77,84.34 289.29,84.34 289.45,84.5 293.07,84.5 294.11,85.54 295.66,85.54 296.04,85.92 296.78,85.92 297.69,86.83 297.69,89.74 298.83,90.88 303.36,90.88 304.85,89.4 305.26,89.4 305.69,88.97 307.59,88.97 309.63,86.93 309.63,86.4 311.25,84.77 311.78,84.77 311.91,84.9 312.38,84.9 313.44,85.97 313.44,87.04 v1(312.7,87.78)
  BOTTOM w0.14: CN7.30 309.21,86 309.73,86.53 311.57,86.53 312.11,87.07 D67.1 312.42,87.26 312.7,87.54 v1(312.7,87.78) ; v1(242.55,58.78) 242.62,58.71 242.62,58.26 242.65,58.23 242.65,57.67 242.11,57.14 241.29,57.14 240.64,56.49 238.45,56.49 238.07,56.86 R1022.2
WWAN_SIM1_RST_C: length 1.8
  BOTTOM w0.14: J1.2 238.1,60.64 237.71,60.25 LG6.2
WWAN_SIM2_DETECT_M: length 1.8
  BOTTOM w0.14: CN7.40 309.65,83.5 309.88,83.27 R896.2
WWAN_WAKE#: length 45
  IN2 w0.089: v1(304.3,87.06) 304.39,87.06 305.36,86.09 305.36,83.91 306.02,83.25 306.02,82.68 307.34,81.36 307.74,81.36 308.69,80.41 308.69,79.01 310.33,77.36 313,77.36 313.28,77.65 313.28,77.95 313.82,78.49 v1(314.26,78.49)
  BOTTOM w0.14: Q102.1 301.46,98.71 301.51,98.66 304.12,98.66 304.9,97.88 304.9,97.03 304.65,96.78 304.65,95.95 304.5,95.8 304.5,94.18 305.48,93.2 305.48,88.24 v1(304.3,87.06) 304.68,86.69 304.68,85.43 304.04,84.8 303.53,84.8 303.2,85.13 303.2,86.58 302.28,87.49 302.13,87.49 301.87,87.75 CN7.23 299.95,87.75 299.91,87.8 R861.1 ; Q109.1 313.66,80.35 314.35,79.66 314.35,78.57 v1(314.26,78.49)
WWAN_WAKE#_EC: length 190.3
  TOP w0.14: v1(169.03,64.5) U23.18 165.85,64.5 R488.1
  IN3 w0.089: v1(305.01,92.41) 304.94,92.41 304.87,92.34 302.94,92.34 302.44,91.85 302.44,90.47 300.46,88.48 300.46,86.93 300.09,86.56 299.26,86.56 298.16,85.47 298.16,84.15 296.34,82.33 293.24,82.33 288.81,77.9 288.81,75.55 288.53,75.27 287.3,75.27 284.55,72.52 284.55,70.99 282.79,69.23 282.79,68.96 281.78,67.95 281.78,64.14 282.15,63.77 282.15,59.35 280.36,57.55 279.67,57.55 276.5,54.38 274.93,54.38 274.62,54.7 273.6,54.7 273.41,54.51 271,54.51 270.05,55.45 267.87,55.45 266.69,54.28 265.39,54.28 264.7,53.58 263.09,53.58 260.99,51.48 250.39,51.48 249.23,52.65 247.98,52.65 247.3,51.96 243.76,51.96 241.41,49.61 238.92,49.61 238.31,49 237.44,49 237.37,48.93 231.2,48.93 230.52,48.25 225.1,48.25 221.38,44.53 219.26,44.53 219.13,44.4 211.36,44.4 209.9,42.93 200.92,42.93 200.67,42.68 198.32,42.68 197.25,43.75 191.28,43.75 187.13,47.9 182.36,47.9 181.77,48.5 181.77,49.37 v1(181.89,49.49)
  BOTTOM w0.14: v1(305.01,92.41) 305.01,92.44 305.04,92.46 305.04,92.51 305.18,92.66 305.18,93.1 304.21,94.07 304.21,95.93 304.23,95.95 R826.1 ; v1(169.03,64.5) 168.05,63.51 168.05,60.81 174.32,54.55 177.12,54.55 181.54,50.13 181.54,50 181.89,49.65 v1(181.89,49.49)
WWAN_WAKE#_PCH: length 130.9
  TOP w0.14: v1(254.1,51.88) 254.1,52.46 253.44,53.13 v1(250.84,53.13) 250.14,53.13 248.95,54.31 247.05,54.31 244.97,56.4 236.53,56.4 v1(233,59.93)
  IN3 w0.089: v1(254.1,51.88) 254.12,51.87 261.11,51.87 263.01,53.77 264.62,53.77 265.31,54.47 266.61,54.47 267.79,55.64 270.13,55.64 271.07,54.7 273.33,54.7 273.52,54.89 274.7,54.89 275.01,54.57 276.42,54.57 279.59,57.74 280.28,57.74 281.96,59.43 281.96,63.69 281.59,64.06 281.59,68.03 282.6,69.04 282.6,69.31 284.36,71.06 284.36,72.59 287.4,75.64 287.73,75.97 287.73,77.09 293.16,82.52 296.26,82.52 297.97,84.23 297.97,85.55 299.18,86.75 300.01,86.75 300.27,87.01 300.27,88.56 302.25,90.54 302.25,91.93 302.86,92.53 304.13,92.53 304.5,92.91 v1(304.58,92.91) ; v1(233,59.93) 232.53,60.4 231.42,60.4 230.92,59.91 230.48,59.91 230.33,60.06 229.42,60.06 228.95,60.53 228.95,63.05 228.65,63.35 228.08,63.35 227.66,62.93 227.66,62.22 227.75,62.13 227.75,60.24 227.18,59.67 226.36,59.67 225.91,60.11 225.91,61.53 225.5,61.94 224.54,61.94 223.98,62.5 223.98,63.3 221.71,65.57 v1(221.31,65.57)
  BOTTOM w0.102: U49.AU29 219.82,65.72 221.16,65.72 v1(221.31,65.57)
  BOTTOM w0.14: R824.1 303.51,96.26 303.93,95.83 303.93,93.96 304.5,93.38 304.5,92.98 v1(304.58,92.91)
WWAN_WLAN_COEX1: length 2
  BOTTOM w0.14: R928.2 309.64,77.85 309.29,77.5 CN7.64
WWAN_WLAN_COEX2: length 2.1
  BOTTOM w0.14: R925.2 309.82,78.62 309.21,78 CN7.62
WWAN_WLAN_COEX3: length 2.2
  BOTTOM w0.14: R920.2 310.08,79.38 309.21,78.5 CN7.60
XCLK_RBIAS: length 5.8
  BOTTOM w0.102: 208.06,81.23 208.06,80.5 208.1,80.46 208.1,78.86 207.97,78.73 U49.P3
  BOTTOM w0.14: 207.48,82.32 207.48,81.81 208.06,81.23
  BOTTOM w0.254: R891.2 207.48,82.76 207.48,82.32
XDP_BPM0: length 14.1
  TOP w0.102: 176.99,150.05 172.89,150.05 v2(171.95,151)
  TOP w0.14: 176.99,150.05 183.29,150.05 TP12.1 184.03,148.91 183.93,148.81 R101.1
  BOTTOM w0.102: U42.H37 171.61,151.34 v2(171.95,151)
XDP_BPM1: length 12.9
  TOP w0.102: 176.99,152.36 174.01,152.36 v2(173.45,151.81)
  TOP w0.14: 176.99,152.36 178.57,152.36 178.76,152.55 180.74,152.55 180.85,152.44 183.14,152.44 183.31,152.62 R98.1 183.93,151.95 TP10.1
  BOTTOM w0.102: v2(173.45,151.81) 173.4,151.75 172.57,151.75 U42.G38
XDP_BPM2: length 8
  BOTTOM w0.079: U42.H40 172.05,153.77 172.05,154.77 172.11,154.83
  BOTTOM w0.14: 172.11,154.83 173.11,155.83 174.5,155.83 175.76,157.1 TP102.1 175.76,158.12 R772.1
XDP_BPM3: length 12.2
  BOTTOM w0.102: 176.79,155.59 176.55,155.34 175.96,155.34 175.41,154.79 173.48,154.79 173.09,154.41 173.09,153.8 172.68,153.39 172.68,153.19 172.45,152.95 171.88,152.95 U42.H39
  BOTTOM w0.14: 176.79,155.59 177.83,156.63 178.22,156.63 179.33,157.73 TP104.1 179.85,158.06 179.39,158.52 R774.1
XDP_PRDY#: length 109.1
  TOP w0.14: v2(172.79,150.85) 172.79,150.85 172.81,150.85 173.22,150.43 183.87,150.43 TP11.1 184.8,150.58 184.94,150.72 R100.1
  IN2 w0.089: v1(213.84,83.36) 213.91,83.36 214.02,83.46 214.02,86.28 214.3,86.56 214.3,92.42 214.14,92.59 214.14,92.99 213.79,93.34 213.79,93.53 211.68,95.64 211.35,95.64 211.11,95.88 210.87,95.88 210.46,96.29 207.95,96.29 206.64,97.6 206.64,100.68 206.35,100.97 203.57,100.97 203.03,101.51 203.03,103.26 200.1,106.19 200.1,108.22 198,110.32 196.7,110.32 179.25,127.77 179.25,146.9 175.85,150.31 173.33,150.31 v2(172.79,150.85)
  BOTTOM w0.102: U49.AF3 213.94,78.84 213.94,79.52 213.68,79.79 213.68,80.47 213.79,80.59 213.79,81.34 214.15,81.7 214.15,83.12 213.99,83.28 ; v2(172.79,150.85) 172.5,150.85 U42.G36
  BOTTOM w0.14: 213.99,83.28 213.92,83.36 v1(213.84,83.36)
XDP_PREQ#: length 111.7
  TOP w0.102: v2(171.18,149.74) 171.24,149.74 171.56,150.07 171.56,152.5 171.78,152.72
  TOP w0.14: 171.78,152.72 171.78,156.68 v1(174.73,159.63) ; v1(213.18,83.36) 213.77,83.95 213.77,84.56 TP40.1
  IN2 w0.089: v2(171.18,149.74) 171.21,149.71 175.78,149.71 178.96,146.53 178.96,127.79 196.62,110.13 197.92,110.13 199.91,108.14 199.91,105.95 202.84,103.02 202.84,101.43 203.49,100.78 206.25,100.78 206.45,100.58 206.45,97.52 207.95,96.02 210.46,96.02 210.79,95.69 211.03,95.69 211.27,95.45 211.6,95.45 213.6,93.45 213.6,93.26 213.95,92.91 213.95,92.51 214.11,92.35 214.11,86.64 213.83,86.35 213.83,83.93 213.26,83.36 v1(213.18,83.36)
  BOTTOM w0.102: U49.AF4 213.74,78.54 213.74,79.44 213.47,79.7 213.47,80.55 213.59,80.67 213.59,81.43 213.95,81.78 213.95,82.54 213.59,82.89 ; U42.H34 171.57,149.41 171.27,149.71 171.21,149.71 v2(171.18,149.74)
  BOTTOM w0.14: 213.59,82.89 213.18,83.31 v1(213.18,83.36) ; v1(174.73,159.63) 174.73,160.04 R767.1
XDP_TRST#: length 120.6
  TOP w0.14: v1(212.73,86.15) 212.8,86.22 213.44,86.22 TP34.1
  IN2 w0.089: v1(212.73,86.15) 213.31,86.15 213.92,86.75 213.92,92.27 213.76,92.43 213.76,92.84 213.41,93.18 213.41,93.37 211.52,95.26 211.19,95.26 210.95,95.5 210.71,95.5 210.38,95.83 207.87,95.83 206.26,97.44 206.26,100.5 206.17,100.59 203.41,100.59 202.65,101.35 202.65,102.94 199.72,105.87 199.72,106.61 198.69,107.63 198.69,109.09 197.84,109.94 196.54,109.94 178.69,127.79 178.69,146.53 175.7,149.52 171.69,149.52 171.4,149.24 171.07,149.24 170.81,149.5 170.81,150.9 170.74,150.97 170.74,151.35 170.95,151.55 170.95,151.96 172.34,153.35 175.11,153.35 176,154.24 v1(176,154.5)
  BOTTOM w0.102: U49.AE4 213.59,78.22 213.49,78.32 213.34,78.32 213.16,78.5 213.16,79.44 213.06,79.54 213.06,79.82 212.2,80.68 212.2,80.78 211.56,81.42 211.1,81.42 210.47,82.06 210.47,82.72 210.59,82.84 ; U42.E40 173.95,153.53 173.95,154.03 174.27,154.34 175.85,154.34 v1(176,154.5) 176.51,154.5 177.43,155.42
  BOTTOM w0.14: R775.1 180.42,158.22 180.42,157.56 180.06,157.21 179.33,157.21 178.24,156.12 178.13,156.12 177.43,155.42 ; 210.59,82.84 210.87,83.12 212.04,83.12 212.52,83.61 212.52,85.21 212.73,85.41 v1(212.73,86.15)
XTAL38P4_IN: length 6.4
  TOP w0.14: v1(211.86,76.54) 212.25,76.92 212.25,77.88 210.81,79.32 210.81,80.28 210.74,80.35 L3.2 R281.1
  BOTTOM w0.102: U49.AC8 211.89,76.54 v1(211.86,76.54)
XTAL38P4_IN_L: length 5.5
  TOP w0.14: Y2.1 211.01,84.92 210.39,84.3 210.39,83.39 210.78,83 C310.2 210.78,82.64 211.18,82.24 R269.1 211.18,81.6 210.74,81.17 L3.1 211.18,81.09 211.23,81.14 R281.2
XTAL38P4_OUT: length 6.2
  TOP w0.14: R282.1 209.55,80.54 209.75,80.54 209.95,80.74 210.24,80.74 L3.3 210.29,80.41 210.11,80.23 210.11,79.93 210.29,79.75 210.29,79.1 210.53,78.86 210.53,78.44 210.7,78.27 v1(210.95,78.27) 211.13,78.27 211.71,77.69 211.71,77.26 v1(211.76,77.2)
  BOTTOM w0.102: v1(211.76,77.2) 211.99,77.2 U49.AC6
XTAL38P4_OUT_L: length 4.8
  TOP w0.14: R282.2 209.45,81.09 L3.4 210.29,81.32 210.4,81.42 210.59,81.42 210.73,81.56 R269.2 C312.2 210.03,82.17 209.87,82.33 209.87,82.46 209.94,82.53 210.29,82.53 210.43,82.67 210.43,82.95 210.29,83.09 210.09,83.09 210.03,83.03 R257.1
XTAL_OUT: length 0.9
  TOP w0.14: R257.2 209.58,83.27 209.64,83.33 Y2.3
XTAL_TCP0_25MHZ_IN: length 8.4
  TOP w0.079: 37.7,94.6 37.7,94.45 37.95,94.2 37.95,92.84 37.84,92.59 U9.L9
  TOP w0.14: 37.7,94.6 37.7,95.3 36.48,96.51 C192.2 36.48,96.93 36.19,97.22 36.19,98.89 Y1.1
XTAL_TCP0_25MHZ_OUT: length 8.2
  TOP w0.079: 37.32,94.58 37.32,94.5 37.71,94.1 U9.M9
  TOP w0.14: Y1.3 35.36,98.57 35.74,98.57 35.88,98.43 35.88,98.13 35.7,97.95 35.7,97.68 35.89,97.49 35.89,97.11 35.66,96.87 C191.2 35.66,96.62 35.8,96.48 36.01,96.48 36.37,96.13 36.37,95.86 36.6,95.63 36.9,95.63 37.32,95.22 37.32,94.58
XTAL_TCP1_25MHZ_IN: length 8.5
  TOP w0.079: 33.12,77.33 33.12,77.18 33.36,76.94 33.36,75.53 33.27,75.32 U16.L9
  TOP w0.14: 33.12,77.33 33.12,78.04 31.91,79.26 C336.2 31.91,79.6 31.6,79.91 31.6,81.6 Y3.1
XTAL_TCP1_25MHZ_OUT: length 8.2
  TOP w0.079: U16.M9 33.14,76.83 32.74,77.23 32.74,77.31
  TOP w0.14: 32.74,77.31 32.74,77.66 32.52,77.88 32.52,78.22 32.28,78.47 31.94,78.47 31.75,78.65 31.75,78.96 31.53,79.18 31.23,79.18 31.09,79.32 C335.2 31.09,79.71 31.32,79.94 31.32,80.33 31.16,80.48 31.16,80.77 31.3,80.91 31.3,81.14 31.16,81.28 30.78,81.28 Y3.3
XTALOUT_RC: length 1.3
  BOTTOM w0.14: RG145.1 256.22,122.8 256.12,122.71 CG519.1 RG148.2
XTALOUTBUFF: length 9.4
  BOTTOM w0.102: UG6.BP5 254.04,128.81 254.24,128.81 254.35,128.71 254.35,127.99 254.21,127.85 254.21,127.5 254.35,127.36 254.35,127.15 254.84,126.65 254.84,126.51 254.65,126.31 254.65,126.17 255.3,125.51 255.57,125.51 255.96,125.9 256.11,125.9 256.34,125.66 256.34,125.52 255.89,125.07 255.89,124.93 256.08,124.74 256.23,124.74 256.81,125.32 256.96,125.32 257.99,124.29 RG141.1
XTALSSIN: length 9.5
  BOTTOM w0.102: UG6.BK8 251.51,131.18 251.51,127.82 251.31,127.62 251.31,124.83 252.53,123.61 252.53,122.75 RG146.1
N84238:
  vias: v1(256.54,62.32) v3(255.48,63.74) v3(256.26,63.74)
N87154: length 31.4
  TOP w0.203: PR280.1 153.55,62.07 153.55,61.31 v1(153.44,61.21)
  IN2 w0.254: v1(137.59,46.9) 137.59,47.27 135.83,49.02 135.83,50.96 136.25,51.38 136.25,52.89 136.96,53.59 136.96,55.5 139.4,57.95 v1(139.4,58.3)
  IN3 w0.254: v1(139.4,58.3) 139.65,58.05 148.85,58.05 152,61.21 v1(153.44,61.21)
  BOTTOM w0.203: PR629.2 137.26,47.23 v1(137.59,46.9)
N17127874: length 2.6
  TOP w0.14: RG68.1 244.12,119.35 RG69.2 243.93,118.94 244.72,118.15 UG1.4
N17127875: length 3.3
  TOP w0.14: CG396.2 241.63,118.16 241.62,118.18 RG75.1 ; CG396.2 v1(241.98,117.36) ; CG396.2 242.48,118.16 243.12,117.53 UG1.5
N19106637: length 4.5
  BOTTOM w0.14: PC342.1 v1(122.94,200.37)
  BOTTOM w0.178: PC342.1 122.58,199.36 122.2,198.98 122.2,198.97 121.81,198.58 ; 121.81,198.58 121.93,198.58 122.82,197.69 PU22.3 ; 121.81,198.58 PR439.1
N19106671: length 1.2
  BOTTOM w0.178: PU21.31 111,196.4 110.59,196.81 PR458.2
N19106721: length 8.3
  TOP w0.254: v1(114.43,191.48) 114.97,190.94 PR105.1
  BOTTOM w0.152: PL7.1 PR488.2
N19106779: length 2.6
  BOTTOM w0.178: PU22.2 122.32,197.57 122.2,197.7 121.13,197.7 120.78,198.05 PR448.2
N19106815: length 4.7
  BOTTOM w0.14: v1(132.59,200.37) PC343.1
  BOTTOM w0.178: PC343.1 132.23,199.36 131.85,198.98 131.85,198.97 131.46,198.58 PR440.1 131.45,198.4 131.63,198.22 132.04,198.22 132.48,197.78 PU23.3
N19106957: length 2.1
  BOTTOM w0.178: PU21.5 114.17,197.88 114.73,198.44 PR430.1
N19106959: length 2.3
  BOTTOM w0.178: PC335.2 115.17,197.95 PU21.7
N19106961: length 2.8
  BOTTOM w0.14: v1(117.35,199.61) 116.8,200.16 PC335.1 PR430.2
N19107009: length 8.5
  TOP w0.254: PR107.1 124.37,190.81 v1(123.7,191.48)
  BOTTOM w0.152: PL8.1 PR489.2
N19107047: length 3.7
  BOTTOM w0.14: PC336.2 126.5,199.24 v1(126.75,199.48)
  BOTTOM w0.178: PC336.2 125.71,198.92 124.82,198.04 PU22.7
N19107049: length 2.8
  BOTTOM w0.14: PC336.1 126.56,200.44 v1(126.88,200.75)
  BOTTOM w0.178: PC336.1 PR431.2
N19107109: length 1.5
  TOP w0.508: PC56.1 127.01,188.6 126.62,188.99 PR107.2
N19107173: length 2.3
  BOTTOM w0.178: PR431.1 124.18,198.23 v1(124.06,198.11) 123.82,197.87 PU22.5
N19107223: length 4.1
  BOTTOM w0.14: v1(151.9,200.24) PC345.1
  BOTTOM w0.178: PU25.3 151.78,197.55 151.46,197.87 151.46,198.07 150.96,198.57 PR443.1 151.11,198.76 151.3,198.76 151.9,199.35 PC345.1
N19107283: length 2.2
  BOTTOM w0.178: PR456.2 150.81,198.05 151.28,197.57 PU25.2
N19107293: length 8.7
  TOP w0.254: v1(152.53,191.48) 153.2,190.81 PR109.1
  BOTTOM w0.152: PL11.1 PR492.2
N19107323: length 3.5
  BOTTOM w0.14: PC340.2 155.11,198.88 155.45,199.23 v1(155.83,199.23)
  BOTTOM w0.178: PU25.7 153.78,198 PC340.2
N19107325: length 2.9
  BOTTOM w0.14: v1(155.83,200.5) 155.42,200.08 PC340.1
  BOTTOM w0.178: PC340.1 PR436.2
N19107371: length 1.5
  TOP w0.508: PR109.2 155.71,188.91 156.09,188.52 PC58.1
N19107403: length 2
  BOTTOM w0.178: PU25.5 152.78,197.87 153.14,198.23 PR436.1
N19107405: length 1.4
  BOTTOM w0.178: PU25.31 149.61,196.4 149.2,196.81 PR462.2
N19107409: length 2.5
  BOTTOM w0.178: PU25.1 150.78,197.53 150.6,197.71 149.41,197.71 149.07,198.05 PR455.2
N19107568: length 1.4
  BOTTOM w0.178: PR459.2 120.24,196.81 120.65,196.4 PU22.31
N19107627: length 2.4
  BOTTOM w0.178: PR450.2 130.8,198.37 131.28,197.88 131.67,197.88 131.98,197.57 PU23.2
N19107637: length 8.4
  TOP w0.254: PR106.1 134.02,190.94 v1(133.48,191.48)
  BOTTOM w0.152: PL9.1 PR490.2
N19107667: length 3.7
  BOTTOM w0.14: PC338.2 135.98,199.06 136.27,199.35 v1(136.53,199.35)
  BOTTOM w0.178: PC338.2 134.48,198.2 PU23.7
N19107669: length 2.9
  BOTTOM w0.14: v1(136.53,200.62) 136.16,200.26 PC338.1
  BOTTOM w0.178: PC338.1 PR433.2
N19107785: length 1.6
  TOP w0.508: PR106.2 136.4,189.22 136.79,188.83 PC57.1
N19107833: length 2.1
  BOTTOM w0.178: PR433.1 133.81,198.21 133.48,197.88 PU23.5
N19107835: length 1.5
  BOTTOM w0.178: PU23.31 129.79,196.4 129.64,196.55 PR460.2
N19107839: length 2.7
  BOTTOM w0.178: PR449.2 129.78,198.37 130.12,198.03 130.6,198.03 131.06,197.56 131.3,197.56 131.48,197.39 PU23.1
N19108009: length 5.2
  BOTTOM w0.14: v1(113.03,200.37) 112.78,200.11 112.78,199.1 113.29,198.59 PC341.1 112.79,198.58 112.75,198.62 112.19,198.62 112.15,198.58
  BOTTOM w0.178: PR438.1 112.15,198.58 112.15,198.5 113.17,197.49 PU21.3
N19108304: length 5.5
  BOTTOM w0.14: v1(161.67,201) 161.93,200.75 161.93,199.73 161.56,199.36 PC346.1
  BOTTOM w0.178: PU26.3 161.43,197.55 160.92,198.07 160.7,198.07 160.4,198.37 PR442.1 160.57,198.75 160.74,198.75 161.36,199.36 PC346.1
N19108364: length 2.8
  BOTTOM w0.178: PR445.2 110.24,197.96 110.49,197.7 v1(110.87,197.7) 111.7,197.7 112.17,197.23 PU21.1
N19108398: length 2.4
  BOTTOM w0.178: PR454.2 159.76,198.37 160.42,197.7 160.8,197.7 160.93,197.57 PU26.2
N19108408: length 8.7
  TOP w0.254: v1(162.11,191.53) 162.83,190.81 PR110.1
  BOTTOM w0.152: PL12.1 PR493.2
N19108454: length 3.7
  BOTTOM w0.14: v1(165.48,199.48) 164.99,198.98 PC337.2
  BOTTOM w0.178: PC337.2 164.32,198.57 163.43,197.68 PU26.7
N19108456: length 2.7
  BOTTOM w0.14: v1(164.47,201.26) 164.32,201.11 PC337.1
  BOTTOM w0.178: PC337.1 PR432.2
N19108516: length 1.5
  TOP w0.508: PC59.1 165.62,188.57 165.23,188.96 PR110.2
N19108570: length 2.1
  BOTTOM w0.178: PU26.5 162.43,197.9 162.79,198.26 PR432.1
N19108572: length 1.5
  BOTTOM w0.178: PU26.31 158.82,196.4 158.6,196.63 PR463.2
N19108576: length 2.5
  BOTTOM w0.178: PR453.2 158.5,198.34 v1(159.15,197.69) 159.79,197.05 PU26.1
N19108632: length 2.6
  BOTTOM w0.178: PU22.1 120.92,197.05 v1(120.34,197.64) 119.89,198.08 PR447.2
N19109090: length 2.3
  BOTTOM w0.178: PU21.2 112.67,197.4 111.96,198.11 111.73,198.11 111.48,198.37 PR446.2
N19109132: length 1.5
  TOP w0.508: PC55.1 117.36,188.81 117.22,188.94 PR105.2
N19109186: length 4.8
  BOTTOM w0.14: PC344.1 142.24,200.24 v1(141.99,200.5)
  BOTTOM w0.178: PC344.1 141.46,198.58 PR441.1 141.05,198.53 141.05,198.23 141.23,198.05 141.44,198.05 142.13,197.37 PU24.3
N19109234: length 2.5
  BOTTOM w0.178: PR452.2 140.08,198.05 140.5,197.63 141.38,197.63 141.63,197.38 PU24.2
N19109248: length 8.4
  TOP w0.254: v1(143.13,191.48) 143.8,190.81 PR108.1
  BOTTOM w0.152: PL10.1 PR491.2
N19109278: length 4.4
  BOTTOM w0.14: PC339.2 145.76,199.06 146.05,199.35 v1(147.07,199.35)
  BOTTOM w0.178: PU24.7 144.13,197.68 145.21,198.77 PC339.2
N19109280: length 2.8
  BOTTOM w0.14: PC339.1 146.2,200.26 v1(146.43,200.5)
  BOTTOM w0.178: PC339.1 PR434.2
N19109324: length 1.6
  TOP w0.508: PR108.2 145.93,188.94 146.32,188.55 PC60.1
N19109356: length 2.2
  BOTTOM w0.178: PR434.1 143.69,198.38 v1(143.36,198.05) 143.13,197.82 PU24.5
N19109358: length 1.4
  BOTTOM w0.178: PR461.2 139.55,196.81 139.96,196.4 PU24.31
N19109362: length 2.7
  BOTTOM w0.178: PU24.1 140.14,197.05 v1(139.6,197.59) 139.2,198 PR451.2
N19174209:
  vias: v1(167.74,215.54) v1(167.92,216.18) v1(168.37,215.71)
N19174211:
  vias: v1(167.66,214.15) v1(169.3,214.99)
N19201693: length 1.4
  TOP w0.14: PR12.2 PR2.2 126.4,216.55 v1(125.99,216.96)
N19241257: length 2.8
  TOP w0.14: PR23.2 v1(161.52,215.58)
  TOP w0.178: PR27.2 PR22.2 162.34,214.77 162.16,214.94 162.02,214.94 161.81,214.73 PR23.2
N19647217: length 70.7
  TOP w0.14: PR116.1 166.52,150.33 166.98,150.78 166.98,154.85 167.54,155.41 167.96,155.41 169.59,157.04 169.59,160.48 170.04,160.93 170.04,162.48 170.55,162.99 170.55,165.72 170.82,165.99 171.05,165.99 v1(171.28,166.23)
  TOP w0.178: v1(170.84,204.59) 170.97,204.72 170.97,205.98 170.64,206.31 PR88.1 170.18,206.49 170.36,206.67 170.68,206.67 170.92,206.9 PR81.1 171.55,207.73 171.55,209.42 170.83,210.14 PC10.1
  IN3 w0.089: v1(170.84,204.59) 171.08,204.35 171.08,203.4 172.14,202.34 172.14,201.08 173.25,199.97 173.25,193.11 175.07,191.29 175.07,187.44 176.29,186.22 176.29,181.18 176.52,180.95 176.52,177.69 175.99,177.16 175.99,176.47 176.43,176.03 176.43,174.87 176.04,174.48 175.68,174.48 175.36,174.16 175.36,172.48 172.34,169.46 171.24,169.46 170.14,168.36 170.14,167.37 v1(171.28,166.23)
N19940934: length 2.5
  TOP w0.254: PR296.2 149.35,58.09 v1(148.75,58.7) 149.45,59.4 PC213.2
N19940963:
  vias: v1(180.72,47.33)
N19940984: length 2.6
  TOP w0.14: v1(150.8,51.73) PC222.1
  TOP w0.508: PC222.1 PR307.2
N19940986: length 1.1
  TOP w0.381: PC223.1 171.24,51.69 v1(170.73,52.19)
N19941004: length 24.5
  TOP w0.178: v1(154.33,56.02) 154.2,56.15 PU15.14 ; v1(164.04,55.71) 164.3,55.71 164.61,56.02 165.27,56.02 165.45,55.85 165.45,51.88 170.16,47.17 v1(170.53,47.17)
  BOTTOM w0.178: v1(154.33,56.02) 156.12,56.02 156.37,56.27 161.24,56.27 161.79,55.71 v1(164.04,55.71) ; PR634.1 170.81,46.85 170.53,47.13 v1(170.53,47.17)
N19941046: length 4.7
  TOP w0.203: PR282.2 PR289.1 150.19,60.89 PR293.1 150.68,60.89 150.93,60.65 150.93,59.71 151.6,59.04 PU15.7
N19941069: length 4.1
  TOP w0.508: PR300.2 149.77,55.21 149.08,54.52 149.08,53.54 v1(147.58,52.03)
N19941188: length 2.5
  TOP w0.14: v1(161.49,52.73) PC224.1
  TOP w0.508: PC224.1 PR308.2
N19941230: length 2.7
  TOP w0.14: PR295.1 158.03,58.22 v1(158.63,57.62)
  TOP w0.254: PR295.1 157.48,58.94 157.57,59.03 PC212.2
N20974301: length 12.1
  BOTTOM w0.254: 203.15,92.06 203.57,91.65 203.57,86 202.88,85.31 201.84,85.31 201.84,85.31 201.41,85.31 201.05,84.95 199.94,84.95 198.98,85.91 PR610.2
  vias: v1(203.45,93.9)
N20974309: length 1.1
  BOTTOM w0.254: PR610.1 198.39,86.47 PR568.1
N20974323: length 1.6
  BOTTOM w0.254: PR549.1 PR540.2 PR539.2
N20974337: length 2.8
  BOTTOM w0.254: PR611.1 197.21,86.94 PR568.2 197.61,87.97 197.49,88.09 PU37.6
N20974353: length 2.8
  BOTTOM w0.254: PU37.1 197.49,92.39 197.02,92.86 PC424.2 197.02,94.39 PR549.2
N20974362: length 2
  BOTTOM w0.254: PU37.5 198.44,88.16 199.01,87.59 199.01,87.37 PR571.2
N21715576:
  vias: v1(127.38,71.84)
N21715582:
  vias: v1(134.42,71.82)
N21715612:
  vias: v1(135.59,74.69)
N21715630: length 4.2
  TOP w0.203: PU11.4 131.21,71.38 PC201.1 130.9,70.98 131.29,70.59 131.29,69.82 131.58,69.53 v1(131.58,69.41) 131.7,69.3 PR261.1
N21715632: length 1.2
  TOP w0.203: PU11.12 130.81,74.87 PC166.1
N21715634: length 1.2
  TOP w0.203: PC167.1 131.61,74.83 PU11.10
N21715657: length 1.5
  TOP w0.14: PR214.2 v1(129.28,77.55)
N21715675: length 2.1
  TOP w0.203: PC202.1 132.4,71.11 PR253.2 131.61,71.25 PU11.5
N21715683: length 2.7
  TOP w0.203: PU11.3 130.81,71.77 130.03,71 PC200.1 129.53,71 129.33,71.19 PR252.1
N21716526:
  vias: v1(138.81,71.21)
N21716532:
  vias: v1(149.99,70.96)
N21716562: length 1.6
  TOP w0.14: PR215.1 v1(150.11,74.9)
N21716580: length 2.4
  TOP w0.14: PR257.2 145.06,70.16 144.88,69.98 PC203.1 144.58,70.32 144.93,70.67 PU12.4
N21716582: length 1.2
  TOP w0.14: PC170.1 144.53,74.01 PU12.12
N21716584: length 1.2
  TOP w0.14: PC171.1 145.33,73.97 PU12.10
N21716605:
  vias: v1(140.34,73.62)
N21716627: length 2.6
  TOP w0.14: PC205.1 146.84,70.16 PR258.1 146.01,70.16 145.33,70.84 PU12.5
N21716633: length 2.8
  TOP w0.14: PR256.2 143.08,70.16 143.28,69.97 PC204.1 143.84,69.97 144.53,70.66 PU12.3
N23334321: length 2.7
  BOTTOM w0.203: PR652.2 115.15,42.58 115.36,42.36 PC512.1 115.85,43.23 115.83,43.24 PU38.4
N23334329: length 1.1
  BOTTOM w0.14: PC500.2 v1(120.31,49.33)
N23334507: length 1.7
  BOTTOM w0.203: PR653.1 116.69,42.72 116.23,43.18 PU38.3
N24995566:
  vias: v1(107.62,128.77)
N24995570: length 1.1
  BOTTOM w0.14: PR511.1 107.94,136.23 v1(108.21,136.49)
N24995581:
  vias: v1(110.39,134.6)
N25272034: length 2.4
  BOTTOM w0.14: v1(260.48,61.68) 260.66,61.51 PR618.1
  BOTTOM w0.203: PR618.1 PR619.1 261.53,60.86 PR617.2
N25272043:
  vias: v1(262.64,68.67)
N25272083:
  vias: v1(265.84,66.44) v3(265.26,66.89) v3(265.23,66.05)
N25431520: length 4.3
  TOP w0.508: PQ22.3 249.98,66.13 v1(250.68,66.13) 251.38,66.13 v1(252.03,65.48)
  BOTTOM w0.508: PR614.2 v1(252.03,65.48)
N25506978: length 1.3
  TOP w0.14: v1(61.98,47.08) 61.73,47.08 61.09,47.71 60.96,47.71
N25507004: length 1.8
  TOP w0.14: v1(65.92,49.37) 65.28,50 64.39,50
N27093787: length 2.8
  TOP w0.079: v2(38.56,91.38) U9.J6
  BOTTOM w0.14: R837.2 38.73,93.15 v1(38.73,92.83) 38.56,92.66 v2(38.56,91.38)
N31779326: length 0.9
  TOP w0.203: C315.2 159.77,81.13 158.94,81.13 R277.2
N31996495: length 1
  BOTTOM w0.14: R985.2 304.91,65.52 v1(304.68,65.75)
N32113508: length 1.7
  BOTTOM w0.14: TP128.1 100.41,88.98 CN6.56
N32113521: length 2
  BOTTOM w0.14: CN6.58 101.18,89.48 TP127.1
N36119360: length 4.7
  TOP w0.14: PD1.2 203.16,105.55 203.4,105.31 PR127.1 204.82,105.31 v1(205.1,105.59) 206.2,105.59 PQ13.3
N36119368: length 15.7
  TOP w0.203: v1(208.1,104.23) 208.38,103.95 PQ13.2
  BOTTOM w0.203: PR526.2 203.32,106.18 PR518.1 203.32,106.37 203.08,106.62 202.14,106.62 PQ63.3 201.73,107.53 201.73,108.02 203.08,109.37 205.91,109.37 207.94,107.35 v1(207.94,107.04) PQ64.2 207.94,104.39 v1(208.1,104.23)
N36119381: length 2.1
  BOTTOM w0.14: PU28.3 v1(202.36,101.36)
  BOTTOM w0.203: PR534.2 203.2,102.38 203.02,102.2 PU28.3
N36119386: length 3.3
  TOP w0.203: v1(208.81,102.68) 208.19,102.68 207.83,102.32 PR133.2
  BOTTOM w0.203: PQ64.3 208.89,102.76 v1(208.81,102.68)
N36119389: length 12
  TOP w0.203: PR135.2 198.53,100.9 197.92,101.51 v1(197.92,102.38) 197.92,102.53 PC120.1 199.25,102.09 PR132.1
  BOTTOM w0.203: v1(197.92,102.38) 198.05,102.24 199.32,102.24 PU28.4 200.31,102.2 200.86,102.75 200.86,105.48 200.1,106.24 PQ63.2
N36119404:
  vias: v1(200.95,99.61) v3(200.06,100.62) v3(200.09,99.86) v3(200.08,99.08)
N36119409: length 2.4
  BOTTOM w0.14: PC398.1 199.33,106.96 v1(199.14,107.15)
  BOTTOM w0.203: PC398.1 200,105.71 PR530.2
N36392478: length 0.8
  TOP w0.14: v1(307.02,60.51) 307.02,60.76 307.38,61.13 R519.2
N45101115: length 1.5
  TOP w0.203: U21.28 304.94,65.03 305.22,64.75 C455.2
N45105751: length 2.8
  TOP w0.14: C413.2 298,69.36 297.45,68.81 297.45,67.99 297.62,67.83 U21.2
N45109965: length 2.4
  TOP w0.203: U21.19 301.42,62.33 301.21,62.12 301.21,61.66 301.48,61.38 301.57,61.38 301.85,61.1 C489.2
N45110431: length 3.3
  TOP w0.203: U21.18 301.02,62.36 300.9,62.24 300.9,61.26 300.86,61.22 C488.2 300.86,59.87 C501.1
N45113988: length 18.1
  TOP w0.14: U21.11 297.58,64.23 293.64,68.16 v1(293.37,68.16) 293.25,68.29 291.69,68.29 291.01,68.97 D37.2 290.67,69.34 289.7,70.31 289.7,71.09 R418.2 288.94,72.09 288.77,72.25 R404.2 289.82,72.73 290.19,73.11 D31.2 290.56,74.3 R373.1 290.88,74.31 291.11,74.54 R372.2
N46786228: length 2.6
  TOP w0.508: PC46.2 176.04,193.42 v1(176.51,193.89)
  BOTTOM w0.508: v1(176.51,193.89) 175.43,193.89 PR477.1
N46786420: length 1.2
  TOP w0.508: PC29.2 164.43,202.93 164.51,203 PR99.2
N46787062: length 20.7
  TOP w0.203: PR92.2 167.74,204.79 v1(167.36,204.41)
  IN3 w0.203: v1(171.33,189.83) 171.48,189.68 171.88,189.68 172.32,190.11 172.32,192.01 168.84,195.48 168.84,200.6 169.35,201.11 169.35,204.11 168.74,204.71 167.67,204.71 v1(167.36,204.41)
  BOTTOM w0.203: PR483.2 171.28,189.87 v1(171.33,189.83)
N46788466: length 1.1
  TOP w0.178: PR57.2 169.27,209.93 169.53,209.67 169.62,209.67 169.81,209.48 PC12.2
N46789361: length 2.5
  TOP w0.178: PC10.2 170.05,210.14 170.97,209.22 v1(170.97,209.14) 171.08,209.03 171.08,208.76 170.92,208.59 PR71.2
N46789649: length 0.9
  TOP w0.178: PR53.2 163.1,211.38 163.05,211.42 163.05,211.44 PC7.2
N46792326: length 1.9
  TOP w0.178: PR59.1 160.35,209.84 160.2,209.69 v1(160.2,209.51) PR68.2
N47371767: length 3.4
  BOTTOM w0.14: CN13.58 100.02,64.43 TP151.1
N47371769: length 3.1
  BOTTOM w0.14: CN13.56 99.23,63.93 TP152.1
N47375149: length 2.8
  BOTTOM w0.14: CN6.10 100.86,77.48 100.82,77.43 R930.1 v1(100.3,76.45)
N48158653: length 4.2
  BOTTOM w0.14: PR360.2 PR359.1 PR358.1 PR357.1
  BOTTOM w0.152: PR350.1 PC278.2 117.61,216.25 117.87,216 PR357.1
N48158687: length 36.3
  IN4 w0.086: v1(111.17,191.22) 110.91,191.48 110.52,191.48 110.09,191.91 110.09,195.23 110.89,196.03 110.89,198.12 114.35,201.59 127.51,201.59 129.4,203.48 129.4,207.64 129.18,207.86 v1(128.8,207.86)
  BOTTOM w0.14: PR481.2 111,191.06 v1(111.17,191.22) ; PR397.2 127.28,208.64 PR398.1 128.07,207.86 128.79,207.86 v1(128.8,207.86)
N48158704: length 1.3
  BOTTOM w0.254: PC301.2 126.34,211.65 PR387.2
N48158713: length 2
  BOTTOM w0.14: v1(128.27,209.77) PC311.1
  BOTTOM w0.254: PC311.1 PR390.1
N48158820: length 22.3
  BOTTOM w0.14: PR393.1 115.6,209.17 115.3,208.87 115.03,208.87 114.91,208.75 114.91,208.48 PR396.1 v1(113.8,208.39) 112.53,207.11 112.53,205.41 109,201.89 109,197.93 108.61,197.54 108.61,194.18 108.92,193.87 108.92,191.62 PR482.1
