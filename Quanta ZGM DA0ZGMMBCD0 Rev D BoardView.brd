# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ3: length 62.9
  IN4 w0.102: v2(130.46,142.74) 130.08,142.36 128.6,142.36 128.05,142.91 123.86,142.91
  IN4 w0.127: v1(121.08,98.08) 122.14,99.14 122.14,103.15 114.93,110.36 114.93,127.16 115.88,128.1 115.88,135.74 116.51,136.38 116.51,137.38 122.02,142.89 123.85,142.89 123.86,142.91
  BOTTOM w0.102: U42.CM22 130.78,142.42 v2(130.46,142.74)
  BOTTOM w0.216: JDIM1.4 122.08,97.19 121.4,97.87 121.19,98.08 v1(121.08,98.08)
M_B_DQ4: length 63.7
  IN4 w0.102: v2(131.16,141.9) 127.95,141.9 127.75,142.11
  IN4 w0.127: 127.75,142.11 122.32,142.11 117.27,137.06 117.27,135.68 117.15,135.55 116.77,135.55 116.64,135.43 116.64,135.17 116.77,135.04 117.15,135.04 117.27,134.92 117.27,134.66 117.15,134.54 116.79,134.54 116.67,134.41 116.67,134.16 116.79,134.03 117.15,134.03 117.27,133.9 117.27,133.65 117.15,133.52 116.81,133.52 116.69,133.39 116.69,133.14 116.81,133.01 117.15,133.01 117.27,132.89 117.27,132.63 117.15,132.5 116.79,132.5 116.66,132.38 116.66,132.12 116.79,132 117.15,132 117.27,131.87 117.27,131.62 117.15,131.49 116.82,131.49 116.69,131.36 116.69,131.11 116.82,130.98 117.15,130.98 117.27,130.85 117.27,130.6 117.15,130.47 116.81,130.47 116.68,130.35 116.68,130.09 116.81,129.96 117.15,129.96 117.27,129.84 117.27,129.58 117.15,129.46 116.84,129.46 116.71,129.33 116.71,129.08 116.84,128.95 117.15,128.95 117.27,128.82 117.27,128.42 115.69,126.84 115.69,110.67 122.91,103.46 122.91,102.53 123.03,102.4 v1(123.27,102.4)
  BOTTOM w0.102: U42.CM21 130.78,141.52 v2(131.16,141.9)
  BOTTOM w0.216: JDIM1.7 122.83,102.85 v1(123.27,102.4)
M_B_DQ5: length 63.8
  IN4 w0.102: 122.81,140.02 124.8,140.02 125.21,140.42 130.17,140.42 130.3,140.55 130.76,140.55 130.87,140.44 131.23,140.44 v2(131.73,140.93)
  IN4 w0.127: v1(125.58,98.94) 125.58,98.69 125.45,98.57 125.09,98.57 124.94,98.72 124.94,99.36 125.07,99.49 125.81,99.49 125.94,99.61 125.94,99.85 125.79,99.99 125.07,99.99 124.94,100.12 124.94,100.38 125.07,100.5 125.5,100.5 125.63,100.63 125.63,100.88 125.5,101.01 125.07,101.01 124.94,101.14 124.94,103.53 117.18,111.29 117.18,125.24 118.76,126.82 118.76,136.44 122.33,140.02 122.81,140.02
  BOTTOM w0.102: U42.CK20 132.08,140.58 v2(131.73,140.93)
  BOTTOM w0.216: JDIM1.20 126.08,98.44 v1(125.58,98.94)
M_B_DQ6: length 63.9
  IN4 w0.102: 122.81,140.4 123.61,140.4 124.35,141.13 127.33,141.13 127.83,140.63 129.9,140.63 130.29,141.01 v2(130.48,141.01)
  IN4 w0.127: v1(124.59,98.1) 124.59,98 124.47,97.87 124.2,97.87 124.07,98 124.07,98.65 124.2,98.77 124.43,98.77 124.56,98.9 124.56,99.4 124.43,99.52 123.75,99.52 123.62,99.65 123.62,99.91 123.75,100.03 124.43,100.03 124.56,100.16 124.56,103.37 116.8,111.13 116.8,125.39 117.19,125.78 117.19,125.96 116.87,126.28 116.87,126.46 117.05,126.63 117.23,126.63 117.55,126.32 117.72,126.32 118.01,126.6 118.01,126.77 117.86,126.91 117.86,126.91 117.72,127.05 117.72,127.23 117.86,127.37 118.26,127.37 118.38,127.49 118.38,136.6 122.18,140.4 122.81,140.4
  BOTTOM w0.102: U42.CM20 130.48,140.84 v2(130.48,141.01)
  BOTTOM w0.216: v1(124.59,98.1) 124.86,98.1 125.08,97.88 JDIM1.16
M_B_DQ7: length 64.8
  IN4 w0.115: 124.81,139.64 125.34,140.17 v2(130.46,140.17)
  IN4 w0.127: v1(126.29,101.66) 125.57,101.66 125.38,101.85 125.32,101.91 125.32,102.56 125.45,102.69 125.68,102.69 125.81,102.82 125.81,103.07 125.68,103.2 125.45,103.2 125.32,103.32 125.32,103.69 117.56,111.45 117.56,125.08 119.35,126.86 119.35,127.04 119.14,127.25 119.14,127.53 119.27,127.66 119.56,127.66 119.68,127.79 119.68,128.25 119.55,128.38 119.27,128.38 119.14,128.51 119.14,128.76 119.27,128.89 119.59,128.89 119.72,129.01 119.72,129.26 119.59,129.39 119.27,129.39 119.14,129.52 119.14,129.78 119.27,129.9 119.59,129.9 119.72,130.03 119.72,130.28 119.58,130.41 119.27,130.41 119.14,130.54 119.14,130.79 119.27,130.92 119.59,130.92 119.72,131.05 119.72,131.29 119.58,131.43 119.27,131.43 119.14,131.55 119.14,131.81 119.27,131.93 119.59,131.93 119.72,132.06 119.72,132.31 119.58,132.44 119.27,132.44 119.14,132.57 119.14,132.82 119.27,132.95 119.59,132.95 119.72,133.08 119.72,133.33 119.59,133.46 119.27,133.46 119.14,133.59 119.14,133.84 119.27,133.97 119.59,133.97 119.72,134.09 119.72,134.34 119.58,134.47 119.27,134.47 119.14,134.6 119.14,134.86 119.27,134.98 119.59,134.98 119.72,135.11 119.72,135.36 119.59,135.49 119.27,135.49 119.14,135.62 119.14,135.87 119.27,136 119.55,136 119.68,136.13 119.68,136.51 120.05,136.87 120.05,137.19 120.25,137.39 120.57,137.39 120.77,137.59 120.77,137.91 120.97,138.11 121.28,138.11 121.48,138.31 121.48,138.63 121.68,138.83 122,138.83 122.27,139.1 122.27,139.42 122.49,139.64 124.81,139.64
  BOTTOM w0.102: v2(130.46,140.17) 130.9,140.17 U42.CL18
  BOTTOM w0.216: JDIM1.17 125.33,102.63 v1(126.29,101.66)
M_B_DQ8: length 58.6
  IN4 w0.102: v2(132.41,139.26) 130.98,139.26 130.6,138.88 126.79,138.88 126.56,138.65 123.51,138.65
  IN4 w0.127: 123.51,138.65 121.13,136.26 121.13,123.01 120.79,122.67 120.61,122.67 119.91,123.38 119.73,123.38 119.56,123.21 119.56,123.01 120.25,122.31 120.25,122.13 120.07,121.96 119.89,121.96 119.21,122.63 119.03,122.63 118.85,122.45 118.85,122.27 119.53,121.6 119.53,121.42 118.75,120.64 118.75,112.39 126.41,104.74 126.41,104.73 127.22,103.92 127.22,102.35 127.37,102.2 127.58,102.2 v1(127.79,102.4)
  BOTTOM w0.102: v2(132.41,139.26) 132.08,138.94 U42.CK17
  BOTTOM w0.216: v1(127.79,102.4) 127.33,102.87 JDIM1.25
M_B_DQ9: length 59
  IN4 w0.102: 124.08,138.35 126.77,138.35 127.09,138.67 130.31,138.67 130.31,138.67 130.8,138.67 131,138.88 132.67,138.88 v2(133.06,139.26)
  IN4 w0.127: 124.08,138.35 123.76,138.35 121.59,136.19 121.59,122.94 121.17,122.52 121.17,122.34 121.55,121.96 121.55,121.78 121.37,121.6 121.19,121.6 120.81,121.98 120.63,121.98 119.9,121.24 119.52,120.87 119.14,120.48 119.14,112.54 128.25,103.43 128.25,100.89 128.12,100.76 127.85,100.76 v1(127.73,100.88)
  BOTTOM w0.102: v2(133.06,139.26) 132.73,138.94 U42.CJ17
  BOTTOM w0.216: v1(127.73,100.88) 128.33,101.47 JDIM1.29
M_B_DQ10: length 60.5
  IN4 w0.102: 129.17,135.15 130.03,136.02 130.33,136.31 132.22,136.31 132.41,136.51 v2(132.41,136.69)
  IN4 w0.127: 129.17,135.15 128.75,135.15 128.62,135.02 128.62,134.93 128.49,134.8 128.24,134.8 128.11,134.93 128.11,135.11 127.99,135.24 127.73,135.24 127.61,135.11 127.61,134.93 127.48,134.8 127.23,134.8 127.1,134.93 127.1,135.12 126.97,135.25 126.69,135.25 125.98,134.53 125.98,134 125.85,133.87 124.87,133.87 124.74,133.74 124.74,133.38 124.92,133.21 125.49,133.21 125.62,133.08 125.62,132.83 125.49,132.7 124.96,132.7 124.74,132.48 124.74,132.02 124.87,131.9 125.25,131.9 125.38,131.77 125.38,131.29 125.22,131.13 125.22,127.12 125.35,126.99 125.81,126.99 125.95,126.85 125.95,126.61 125.82,126.48 125.29,126.48 125.16,126.35 125.16,126.1 125.29,125.97 125.78,125.97 125.92,125.84 125.92,125.59 125.79,125.47 125.29,125.47 125.16,125.34 125.16,125.08 125.29,124.96 125.79,124.96 125.92,124.83 125.92,124.58 125.79,124.45 125.29,124.45 125.09,124.25 125.09,124.03 125.29,123.83 125.79,123.83 125.92,123.7 125.92,123.19 128.53,120.58 128.53,106.87 131.74,103.66 131.74,101.32 131.62,101.19 131.28,101.19 131.12,101.04 131.12,100.79 131.25,100.66 131.62,100.66 131.74,100.54 131.74,100.27 131.62,100.14 131.39,100.14 131.26,100.02 131.26,99.77 131.39,99.64 131.89,99.64 132.02,99.51 132.02,99.05 131.89,98.93 131.57,98.93 v1(131.36,99.14)
  BOTTOM w0.102: v2(132.41,136.69) 132.73,137.01 U42.CJ14
  BOTTOM w0.216: v1(131.36,99.14) 130.98,99.14 130.58,98.74 130.58,97.48 JDIM1.38
M_B_DQ11: length 58.4
  IN4 w0.102: 124.28,138.98 125.05,138.98 125.74,139.67 130.04,139.67 v2(130.45,139.27)
  IN4 w0.127: 124.28,138.98 123.31,138.98 120.74,136.42 120.74,124.94 118.74,122.94 118.37,122.57 118.37,112.23 126.84,103.76 126.84,100.96 126.5,100.62 126.5,100.24 126.63,100.12 127.18,100.12 127.32,99.98 127.32,99.73 127.19,99.61 126.63,99.61 126.5,99.48 126.5,97.81 126.83,97.48 v1(127.11,97.48)
  BOTTOM w0.102: v2(130.45,139.27) 130.78,138.93 U42.CM17
  BOTTOM w0.216: v1(127.11,97.48) 127.08,97.45 JDIM1.24
M_B_DQ12: length 58.3
  IN4 w0.102: v2(131.17,138.47) 131.17,138.47 129.44,138.47 129.34,138.37 128.65,138.37 128.55,138.47 127.62,138.47 126.82,137.67 126.82,137.67 126.6,137.45 125.7,137.45 125.55,137.3 123.69,137.3 122.81,136.42
  IN4 w0.127: v1(129.16,101.01) 129.09,100.94 128.83,100.94 128.63,101.14 128.63,103.59 119.52,112.7 119.52,118.84 120.11,119.44 120.11,119.62 119.58,120.15 119.58,120.38 119.72,120.53 119.92,120.53 120.46,119.98 120.66,119.98 120.82,120.15 120.82,120.34 120.3,120.86 120.3,121.08 120.46,121.24 120.64,121.24 121.15,120.73 121.41,120.73 121.97,121.3 121.97,135.58 122.81,136.42
  BOTTOM w0.102: v2(131.17,138.47) 130.78,138.08 U42.CM16
  BOTTOM w0.216: JDIM1.37 130.33,102.17 v1(129.16,101.01)
M_B_DQ13: length 58.3
  IN4 w0.102: 128.61,135.48 129.21,135.48 129.66,135.93 129.66,135.93 130.42,136.69 v2(131.79,136.69)
  IN4 w0.127: v1(131.33,103.04) 131.33,103.54 128.15,106.71 128.15,120.42 125.35,123.22 125.17,123.22 124.83,122.88 124.65,122.88 124.47,123.06 124.47,123.24 124.81,123.58 124.81,123.76 124.66,123.9 124.06,123.9 123.93,124.03 123.93,124.22 124.08,124.37 124.68,124.37 124.78,124.47 124.78,124.8 124.66,124.93 124.34,124.93 124.21,125.05 124.21,125.31 124.34,125.43 124.66,125.43 124.78,125.56 124.78,125.94 124.66,126.07 123.97,126.07 123.84,126.2 123.84,126.45 123.97,126.58 124.66,126.58 124.78,126.7 124.78,126.95 124.65,127.08 123.97,127.08 123.84,127.21 123.84,127.47 123.97,127.59 124.68,127.59 124.81,127.72 124.81,127.97 124.68,128.1 123.97,128.1 123.84,128.23 123.84,128.48 123.97,128.61 124.7,128.61 124.82,128.74 124.82,128.99 124.7,129.12 123.97,129.12 123.84,129.24 123.84,129.5 123.97,129.62 124.66,129.62 124.83,129.79 124.83,129.97 124.66,130.13 123.97,130.13 123.84,130.26 123.84,130.65 123.97,130.78 124.63,130.78 124.83,130.97 124.83,131.21 124.63,131.4 124.01,131.4 123.81,131.6 123.81,134.05 124.29,134.53 124.29,134.89 124.43,135.03 124.75,135.03 124.88,134.9 124.88,134.46 125.01,134.32 125.26,134.32 125.38,134.45 125.38,134.96 125.51,135.08 126.05,135.08 126.44,135.48 128.61,135.48
  BOTTOM w0.102: U42.CK14 132.08,136.99 v2(131.79,136.69)
  BOTTOM w0.216: JDIM1.41 v1(131.33,103.04)
M_B_DQ14: length 58.2
  IN4 w0.102: 123.09,131.26 123.09,134.73 124.76,136.4 126.05,136.4 126.26,136.61 129.52,136.61 130.35,137.45 v2(130.48,137.45)
  IN4 w0.127: 123.09,131.26 123.08,131.25 123.08,123.38 124.34,122.12 125.37,122.12 125.64,121.85 125.64,121.67 125.44,121.47 125.44,121.29 125.62,121.11 125.8,121.11 126,121.31 126.18,121.31 126.36,121.13 126.36,120.95 126.15,120.75 126.15,120.57 126.33,120.39 126.51,120.39 126.72,120.59 126.9,120.59 127.39,120.1 127.39,106.4 130.36,103.42 130.36,100.28 130.5,100.14 130.5,97.43 130.25,97.18 129.26,97.18 129.06,97.38 129.06,98.27 128.5,98.83 128.32,98.83 128.08,98.59 128.08,98.41 v1(128.33,98.16)
  BOTTOM w0.102: v2(130.48,137.45) 130.78,137.14 U42.CM14
  BOTTOM w0.216: v1(128.33,98.16) 127.93,97.76 127.93,97.29 128.08,97.14 JDIM1.28
M_B_DQ15: length 58.8
  IN4 w0.102: 123.46,130.89 123.46,134.6 124.28,135.42 125.92,135.42 126.19,135.69 126.19,136.13 126.38,136.32 129.6,136.32 130.26,136.98 130.92,136.98 131.08,137.14 v2(131.08,137.46)
  IN4 w0.127: 123.46,130.89 123.46,125.71 123.58,125.59 123.7,125.59 123.83,125.46 123.83,125.2 123.7,125.08 123.58,125.08 123.46,124.95 123.46,123.54 124.49,122.5 125.53,122.5 127.77,120.26 127.77,106.55 130.22,104.1 130.74,103.58 130.74,100.44 130.88,100.3 130.88,96.46 131,96.33 131.5,96.33 131.65,96.48 131.65,96.97 132.57,97.89 132.57,98.07 132.32,98.32 132.14,98.32 v1(131.41,97.59)
  BOTTOM w0.102: v2(131.08,137.46) 131.08,137.45 131.11,137.42 131.11,136.63 U42.CL13
  BOTTOM w0.216: JDIM1.42 131.58,97.42 v1(131.41,97.59)
M_B_DQ16: length 47.9
  IN4 w0.102: v2(131.77,135.93) 131.42,135.58 131.27,135.58 129.39,133.7
  IN4 w0.127: 129.39,133.7 127.42,133.7 126,132.28 126,128.02 126.73,127.29 126.73,123.52 129.34,120.91 129.34,107.21 132.56,103.99 132.56,100.74 v1(134.54,98.76)
  BOTTOM w0.102: v2(131.77,135.93) 131.77,135.85 U42.CK12
  BOTTOM w0.216: v1(134.54,98.76) 134.51,98.76 133.58,97.83 JDIM1.50
M_B_DQ17: length 47.9
  IN4 w0.127: v2(133.06,135.92) 133.32,135.66 133.32,135.38 133.19,135.25 132.62,135.25 132.33,135.54 132,135.54 131.8,135.34 131.34,135.34 131.24,135.24 131,135.01 131,135 130.94,134.94 130.94,134.86 129.43,133.35 127.57,133.35 126.89,132.67 126.89,131.03 127.44,130.48 127.44,130.06 127.26,129.88 126.93,129.88 126.38,129.33 126.38,128.39 126.56,128.21 126.99,128.21 127.11,128.08 127.11,124.44 127.33,124.23 127.33,124.07 127.11,123.85 127.11,123.68 129.72,121.07 129.72,107.37 132.94,104.15 132.94,101.56 133.07,101.43 133.28,101.43 133.41,101.56 v1(133.41,101.7)
  BOTTOM w0.102: v2(133.06,135.92) 132.73,135.6 U42.CJ12
  BOTTOM w0.216: v1(133.41,101.7) 132.33,102.78 JDIM1.45
M_B_DQ18: length 45.4
  IN4 w0.102: 129.25,131.52 129.6,131.88 129.6,133.12 130.86,134.38 131.18,134.38 v2(131.36,134.19)
  IN4 w0.127: v1(133.42,103) 133.42,103.34 133.76,103.69 133.76,103.86 130.1,107.52 130.1,121.23 129.2,122.13 129.2,122.29 128.74,122.75 128.58,122.75 127.71,123.63 127.71,123.81 127.83,123.93 127.96,123.93 128.08,124.06 128.08,124.35 127.96,124.47 127.62,124.47 127.49,124.6 127.49,124.87 127.62,124.99 128.04,124.99 128.16,125.12 128.16,125.37 128.03,125.5 127.61,125.5 127.48,125.63 127.48,125.88 127.6,126.01 128.08,126.01 128.21,126.14 128.21,126.38 128.07,126.52 127.58,126.52 127.46,126.65 127.46,126.87 127.59,127.01 128.04,127.01 128.17,127.14 128.17,127.82 127.93,128.06 127.93,128.31 128.17,128.54 128.17,128.95 128.02,129.1 127.46,129.1 127.33,129.23 127.33,129.47 127.47,129.61 128.14,129.61 128.28,129.76 128.28,130.09 128.14,130.23 127.9,130.23 127.78,130.36 127.78,130.76 127.37,131.17 127.37,131.35 127.61,131.59 127.79,131.59 128.37,131.02 128.55,131.02 128.69,131.16 128.69,131.4 128.81,131.52 129.25,131.52
  BOTTOM w0.102: U42.CM9 130.98,134.09 131.08,134.19 v2(131.36,134.19)
  BOTTOM w0.216: v1(133.42,103) 133.33,103.09 JDIM1.49
M_B_DQ19: length 46.8
  IN4 w0.102: v2(130.47,135.91) 130.47,135.14 129.31,133.98
  IN4 w0.127: 129.31,133.98 127.24,133.98 125.61,132.34 125.61,127.76 126.35,127.01 126.35,123.37 128.96,120.75 128.96,107.05 132.18,103.83 132.18,100.55 132.46,100.27 132.46,98.79 v1(132.94,98.31)
  BOTTOM w0.102: v2(130.47,135.91) 130.78,135.6 U42.CM12
  BOTTOM w0.216: JDIM1.46 132.58,97.26 132.48,97.36 132.48,97.86 132.93,98.31 v1(132.94,98.31)
M_B_DQ20: length 44.6
  IN4 w0.127: v2(130.59,131.61) 130.47,131.61 129.9,131.03 129.9,130.56 129.78,130.44 129.36,130.44 129.23,130.31 129.23,130.02 129.35,129.91 129.93,129.91 130.05,129.79 130.05,129.52 129.92,129.39 129.43,129.39 129.3,129.26 129.3,129.08 129.51,128.87 129.93,128.87 130.06,128.74 130.06,125.01 129.93,124.89 129.66,124.89 129.5,124.73 129.5,124.46 129.62,124.33 130.05,124.33 130.82,123.57 130.82,123.01 130.94,122.88 131.5,122.88 132.3,122.08 132.3,121.7 131.99,121.39 131.99,121.1 131.21,120.32 131.21,107.98 134.25,104.94 135.4,103.79 135.4,100.53 135.06,100.2 135.06,97.83 135.28,97.61 136.1,97.61 v1(136.2,97.71)
  BOTTOM w0.127: U42.CN6 130.21,131.71 130.31,131.61 v2(130.59,131.61)
  BOTTOM w0.216: JDIM1.62 136.58,97.33 v1(136.2,97.71)
M_B_DQ21: length 44.6
  IN4 w0.102: v2(131.36,133.54) 131.61,133.54 131.75,133.4 131.75,129.27
  IN4 w0.127: 131.75,129.27 131.84,129.17 131.84,128.21 132,128.04 132,127.43 131.91,127.33 131.91,126.77 132.05,126.63 132.05,126.05 132.57,125.53 132.57,124.93 132.36,124.71 132.36,124.41 132.57,124.19 132.57,124.12 133.45,123.24 133.45,121.05 133.13,120.73 133.13,119.98 133,119.85 132.61,119.85 132.49,119.72 132.49,119.47 132.61,119.34 133,119.34 133.13,119.22 133.13,118.96 133,118.83 132.61,118.83 132.49,118.71 132.49,118.45 132.61,118.33 133,118.33 133.13,118.2 133.13,117.95 133,117.82 132.61,117.82 132.49,117.69 132.49,117.44 132.61,117.31 133,117.31 133.13,117.18 133.13,116.93 133,116.8 132.61,116.8 132.49,116.68 132.49,116.42 132.61,116.29 133,116.29 133.13,116.17 133.13,115.91 133,115.79 132.61,115.79 132.49,115.66 132.49,115.41 132.61,115.28 133,115.28 133.13,115.15 133.13,114.9 133,114.77 132.61,114.77 132.49,114.64 132.49,114.39 132.61,114.26 133,114.26 133.13,114.14 133.13,113.88 133,113.75 132.61,113.75 132.49,113.63 132.49,113.37 132.61,113.25 133,113.25 133.13,113.12 133.13,112.87 133,112.74 132.61,112.74 132.49,112.61 132.49,112.36 132.61,112.23 133,112.23 133.13,112.1 133.13,111.85 133,111.72 132.61,111.72 132.49,111.6 132.49,111.34 132.61,111.21 133,111.21 133.13,111.09 133.13,107.68 136.54,104.27 136.54,102.9 v1(136.59,102.86)
  BOTTOM w0.102: U42.CM8 130.98,133.44 131.08,133.54 v2(131.36,133.54)
  BOTTOM w0.216: v1(136.59,102.86) 136.83,103.09 JDIM1.63
M_B_DQ22: length 45.5
  IN4 w0.102: 130.98,130.48 130.98,131 131.36,131.37 v2(131.36,131.56)
  IN4 w0.127: 130.98,130.48 130.86,130.36 130.86,126.69 131.03,126.52 131.56,126.52 131.68,126.39 131.68,126.12 131.55,125.99 131.02,125.99 130.77,125.74 130.77,124.98 130.96,124.79 131.15,124.79 131.92,125.56 132.1,125.56 132.28,125.38 132.28,125.2 131.36,124.29 131.36,124.11 131.54,123.93 131.72,123.93 131.88,124.09 132.08,124.09 132.24,123.93 132.24,123.73 132.08,123.57 132.08,123.39 132.26,123.21 132.44,123.21 132.6,123.37 132.78,123.37 133.07,123.09 133.07,121.21 132.75,120.89 132.75,120.89 132.75,120.78 132.11,120.14 132.11,111.08 132.41,110.78 132.51,110.78 132.75,110.54 132.75,110.16 132.62,110.03 132.1,110.03 131.97,109.91 131.97,109.66 132.1,109.53 132.62,109.53 132.75,109.4 132.75,109.15 132.62,109.02 132.1,109.02 131.97,108.89 131.97,108.64 132.1,108.51 132.62,108.51 132.75,108.38 132.75,108.16 132.52,107.93 132.52,107.75 136.16,104.11 136.16,101.64 136.29,101.52 136.53,101.52 v1(136.58,101.56)
  BOTTOM w0.102: U42.CM6 131.33,131.56 v2(131.36,131.56)
  BOTTOM w0.216: v1(136.58,101.56) 136.14,101.56 135.66,102.04 135.66,103.2 135.83,103.37 JDIM1.59
M_B_DQ23: length 46.2
  IN4 w0.102: 130.18,130.5 130.18,130.96 130.43,131.2 130.83,131.2 130.98,131.35 130.98,132.14 131.08,132.24 v2(131.36,132.24)
  IN4 w0.127: 130.18,130.5 130.45,130.22 130.45,126.58 130.57,126.46 130.57,126.11 130.45,125.99 130.45,124.47 131.2,123.73 131.2,123.39 131.33,123.27 131.66,123.27 132.68,122.24 132.68,121.36 132.37,121.05 132.37,121.05 132.37,120.94 131.59,120.16 131.59,108.14 135.78,103.95 135.78,101.26 135.9,101.13 136.46,101.13 136.59,101.01 136.59,100.74 136.46,100.61 135.92,100.61 135.78,100.47 135.78,100.21 135.9,100.08 136.46,100.08 136.59,99.95 136.59,99.68 136.46,99.55 135.57,99.55 135.44,99.42 135.44,98.73 135.57,98.6 135.79,98.6 136.2,99.01 v1(136.2,99.07)
  BOTTOM w0.102: U42.CK7 131.75,132.34 131.64,132.24 v2(131.36,132.24)
  BOTTOM w0.216: v1(136.2,99.07) 135.85,99.07 135.36,98.59 135.36,97.27 135.58,97.05 JDIM1.58
M_B_DQ24: length 43.9
  IN4 w0.102: 133.81,126.41 133.8,126.41 133.8,132.59 v2(132.92,133.48)
  IN4 w0.114: 133.81,126.41 133.81,125.11 134.56,124.36
  IN4 w0.127: 134.56,124.36 135.02,123.9 135.02,108.91 138.69,105.24 138.69,98.48 140.01,97.15 140.49,97.15 v1(141.46,98.12)
  BOTTOM w0.102: U42.CJ9 132.53,133.86 v2(132.92,133.48)
  BOTTOM w0.216: v1(141.46,98.12) 142.08,97.5 JDIM1.84
M_B_DQ25: length 45.7
  IN4 w0.102: v2(134.7,134.19) 135.64,133.25 135.64,132.92 137.57,130.99
  IN4 w0.127: v1(141.49,101) 141.84,100.65 142.22,100.65 142.35,100.52 142.35,99.78 142.48,99.66 142.73,99.66 142.86,99.78 142.86,100.52 142.99,100.65 143.42,100.65 143.69,100.92 143.69,103.58 137.27,110.01 137.27,125.34 137.81,125.88 137.81,127.04 137.57,127.29 137.57,130.99
  BOTTOM w0.102: v2(134.7,134.19) 134.37,133.86 U42.CF9
  BOTTOM w0.216: JDIM1.83 141.83,103.38 141.99,103.21 141.99,101.51 v1(141.49,101)
M_B_DQ26: length 45.6
  IN4 w0.102: v2(134.72,132.24) 135.34,132.24 135.85,131.73 135.85,129.91
  IN4 w0.127: v1(141.47,99.5) 141.47,99.39 141.2,99.12 140.73,99.12 140.6,99.25 140.6,99.86 141.01,100.27 141.01,102.3 140.66,102.65 140.66,103.31 140.78,103.44 141.28,103.44 141.4,103.56 141.4,103.82 141.28,103.94 140.78,103.94 140.66,104.07 140.66,104.33 140.78,104.45 141.24,104.45 141.36,104.58 141.36,104.83 141.24,104.96 140.78,104.96 140.66,105.09 140.66,105.54 136.51,109.69 136.51,126.12 136.63,126.24 137.02,126.24 137.15,126.37 137.15,126.58 137.01,126.72 136.6,126.72 136.48,126.85 136.48,127.13 136.79,127.45 136.79,127.63 136.59,127.83 135.86,127.83 135.73,127.96 135.73,129.79 135.85,129.91
  BOTTOM w0.102: U42.CE7 135.05,132.56 v2(134.72,132.24)
  BOTTOM w0.216: v1(141.47,99.5) 141.47,99.5 141.42,99.45 141.29,99.45 140.9,99.06 140.9,97.34 141.08,97.17 JDIM1.80
M_B_DQ27: length 44.8
  IN4 w0.102: v2(134.71,133.56) 135.18,133.09 135.18,132.89 137.17,130.91
  IN4 w0.127: v1(141.49,102.36) 141.58,102.46 141.8,102.46 141.92,102.33 141.92,101.21 142.05,101.09 142.55,101.09 142.67,101.21 142.67,103.04 142.55,103.17 142.02,103.17 141.89,103.29 141.89,103.55 142.02,103.67 142.73,103.67 142.83,103.77 142.83,103.91 136.89,109.85 136.89,125.56 137.43,126.1 137.43,126.79 137.17,127.05 137.17,127.9 137.04,128.02 136.86,128.02 136.74,128.15 136.74,128.4 136.86,128.53 137.11,128.53 137.24,128.66 137.24,128.91 137.11,129.04 136.84,129.04 136.72,129.17 136.72,129.41 136.85,129.55 137.08,129.55 137.21,129.68 137.21,129.93 137.08,130.05 136.9,130.05 136.77,130.18 136.77,130.44 136.9,130.56 137.04,130.56 137.17,130.69 137.17,130.91
  BOTTOM w0.102: v2(134.71,133.56) 134.69,133.56 134.35,133.21 U42.CF8
  BOTTOM w0.216: JDIM1.79 140.83,103.02 v1(141.49,102.36)
M_B_DQ28: length 45
  IN4 w0.102: v2(134.7,131.59) 134.89,131.59 135.09,131.39 135.09,129.72
  IN4 w0.127: 135.09,129.72 135.09,129.71 135.09,129.41 135.22,129.28 135.38,129.28 135.51,129.15 135.51,128.9 135.38,128.77 135.3,128.77 135.17,128.64 135.17,127.54 135.3,127.41 136,127.41 136.13,127.28 136.13,127.03 136.01,126.9 135.36,126.9 135.24,126.78 135.24,126.52 135.36,126.39 136.06,126.39 136.2,126.26 136.2,126.01 136.07,125.89 135.35,125.89 135.23,125.76 135.23,125.4 135.4,125.23 136,125.23 136.13,125.1 136.13,109.53 140.28,105.38 140.28,105.25 140.15,105.13 139.92,105.13 139.79,105 139.79,104.74 139.92,104.62 140.15,104.62 140.28,104.49 140.28,104.24 140.15,104.11 139.92,104.11 139.79,103.98 139.79,103.6 139.91,103.48 140.13,103.48 140.26,103.35 140.26,102.41 140.63,102.04 140.63,100.42 140.38,100.18 140.01,100.18 139.8,100.39 v1(139.8,101.69)
  BOTTOM w0.102: U42.CF6 134.37,131.91 v2(134.7,131.59)
  BOTTOM w0.216: v1(139.8,101.69) 139.8,101.69 139.6,101.69 138.83,102.46 JDIM1.71
M_B_DQ29: length 43.3
  IN4 w0.102: 134.21,124.17 133.6,124.78 133.6,132.51 133.27,132.84 v2(132.91,132.84)
  IN4 w0.127: 134.21,124.17 134.64,123.74 134.64,120.24 134.51,120.11 134.45,120.11 134.32,119.98 134.32,119.73 134.45,119.6 134.51,119.6 134.64,119.47 134.64,119.22 134.51,119.09 134.45,119.09 134.32,118.97 134.32,118.71 134.45,118.58 134.51,118.58 134.64,118.46 134.64,118.2 134.51,118.08 134.45,118.08 134.32,117.95 134.32,117.7 134.45,117.57 134.51,117.57 134.64,117.44 134.64,117.19 134.51,117.06 134.45,117.06 134.32,116.93 134.32,116.68 134.45,116.55 134.51,116.55 134.64,116.43 134.64,116.17 134.51,116.04 134.45,116.04 134.32,115.92 134.32,115.66 134.45,115.54 134.51,115.54 134.64,115.41 134.64,115.16 134.51,115.03 134.45,115.03 134.32,114.9 134.32,114.65 134.45,114.52 134.51,114.52 134.64,114.39 134.64,114.14 134.51,114.01 134.45,114.01 134.32,113.89 134.32,113.63 134.45,113.5 134.51,113.5 134.64,113.38 134.64,113.12 134.51,113 134.45,113 134.32,112.87 134.32,112.62 134.45,112.49 134.51,112.49 134.64,112.36 134.64,112.11 134.51,111.98 134.45,111.98 134.32,111.85 134.32,111.6 134.45,111.47 134.51,111.47 134.64,111.35 134.64,111.09 134.51,110.96 134.45,110.96 134.32,110.84 134.32,110.58 134.45,110.46 134.51,110.46 134.64,110.33 134.64,109.95 134.51,109.82 134.45,109.82 134.32,109.69 134.32,109.44 134.45,109.31 134.51,109.31 134.64,109.19 134.64,108.57 134.5,108.43 134.5,108.25 134.68,108.07 134.86,108.07 135,108.21 135.18,108.21 135.36,108.03 135.36,107.85 135.22,107.71 135.22,107.53 135.4,107.35 135.58,107.35 135.72,107.49 135.9,107.49 136.08,107.31 136.08,107.13 135.86,106.91 135.86,106.73 136.04,106.55 136.22,106.55 136.44,106.77 136.62,106.77 136.83,106.56 136.83,106.38 136.62,106.17 136.62,105.97 136.82,105.78 137,105.78 137.21,105.99 137.39,105.99 138.23,105.15 138.23,104.83 138.11,104.7 137.88,104.7 137.78,104.61 137.78,104.25 137.91,104.12 138.18,104.12 138.31,104 138.31,103.74 138.18,103.62 137.91,103.62 137.78,103.49 137.78,102.81 v1(138.17,102.42)
  BOTTOM w0.102: v2(132.91,132.84) 132.89,132.84 U42.CJ8
  BOTTOM w0.216: JDIM1.67 137.83,103.39 137.79,103.35 137.74,103.3 137.74,102.85 v1(138.17,102.42)
M_B_DQ30: length 42.9
  IN4 w0.102: 132.51,129.13 132.51,131.15 v2(132.13,131.53)
  IN4 w0.114: 132.51,129.13 132.4,129.03 132.4,126.16 132.94,125.62 132.94,124.36
  IN4 w0.127: 132.94,124.36 133.88,123.42 133.88,120.87 133.56,120.55 133.56,107.86 137.02,104.4 137.02,99.06 136.89,98.94 136.73,98.94 136.6,98.81 136.6,98.56 136.73,98.43 136.89,98.43 137.02,98.3 137.02,96.93 137.15,96.81 137.49,96.81 137.62,96.93 137.62,98.16 137.74,98.29 137.95,98.29 138.11,98.14 v1(138.11,98.08)
  BOTTOM w0.102: U42.CJ6 132.13,131.53 v2(132.13,131.53)
  BOTTOM w0.216: JDIM1.66 137.58,97.63 138.03,98.08 v1(138.11,98.08)
M_B_DQ31: length 44.1
  IN4 w0.102: v2(132.94,131.51) 133.22,131.51 133.33,131.41 133.33,124.51 133.67,124.17
  IN4 w0.127: v1(138.11,99.37) 137.75,99.01 137.57,99.01 137.4,99.18 137.4,99.67 137.53,99.8 138.18,99.8 138.31,99.92 138.31,100.19 138.18,100.32 137.53,100.32 137.4,100.45 137.4,100.71 137.53,100.84 138.18,100.84 138.31,100.97 138.31,101.22 138.17,101.35 137.61,101.35 137.4,101.56 137.4,101.95 137.66,102.21 137.66,102.39 137.4,102.65 137.4,104.56 137.32,104.64 137.32,104.82 137.59,105.08 137.59,105.26 137.42,105.43 137.19,105.43 136.95,105.19 136.77,105.19 133.94,108.02 133.94,108.35 134.14,108.55 134.14,108.92 133.94,109.12 133.94,120.39 134.26,120.71 134.26,123.58 133.67,124.17
  BOTTOM w0.127: v2(132.94,131.51) 133.29,131.51 133.41,131.64 U42.CH6
  BOTTOM w0.216: JDIM1.70 138.57,96.15 138.57,98.92 138.3,99.19 138.29,99.19 v1(138.11,99.37)
M_B_DQ32: length 42
  IN4 w0.102: 157.84,127.01 157.96,127.12 157.96,128.95 158.79,129.78 158.79,131.67 159.37,132.25 v2(159.97,132.25)
  IN4 w0.127: 157.84,127.01 157.84,125.96 158.88,124.92 158.88,121.22 161.78,118.32 161.78,111.13 165.98,106.93 165.98,99 v1(166.82,98.15)
  BOTTOM w0.102: v2(159.97,132.25) 160.16,132.25 U42.AF6
  BOTTOM w0.216: JDIM1.174 166.58,97.05 166.41,97.22 166.41,97.77 166.77,98.13 166.8,98.13 v1(166.82,98.15)
M_B_DQ33: length 42
  IN4 w0.102: v2(159.97,131.59) 159.8,131.59 159.59,131.37 159.59,129.26 159.42,129.1
  IN4 w0.127: v1(166.84,102.36) 166.73,102.26 166.51,102.26 166.36,102.4 166.36,103.7 166.49,103.83 166.77,103.83 166.9,103.95 166.9,104.21 166.77,104.33 166.49,104.33 166.36,104.46 166.36,104.72 166.49,104.84 166.77,104.84 166.9,104.97 166.9,105.22 166.77,105.35 166.49,105.35 166.36,105.48 166.36,105.86 166.49,105.99 166.77,105.99 166.9,106.11 166.9,106.36 166.76,106.49 166.49,106.49 166.36,106.62 166.36,107.09 162.16,111.29 162.16,114.04 162.29,114.16 162.54,114.16 162.66,114.29 162.66,114.54 162.54,114.67 162.29,114.67 162.16,114.8 162.16,115.18 162.29,115.31 162.54,115.31 162.66,115.43 162.66,115.69 162.54,115.81 162.29,115.81 162.16,115.94 162.16,116.2 162.29,116.32 162.54,116.32 162.66,116.45 162.66,116.7 162.54,116.83 162.29,116.83 162.16,116.96 162.16,117.21 162.29,117.34 162.54,117.34 162.66,117.47 162.66,117.72 162.54,117.85 162.29,117.85 162.16,117.97 162.16,118.48 159.27,121.38 159.27,125.14 158.41,125.99 158.41,126.32 158.78,126.68 158.78,128.45 158.91,128.59 158.91,128.97 159.04,129.1 159.42,129.1
  BOTTOM w0.102: v2(159.97,131.59) 159.87,131.59 159.59,131.87 U42.AG6
  BOTTOM w0.216: JDIM1.173 166.33,102.88 v1(166.84,102.36)
M_B_DQ34: length 42.3
  IN4 w0.102: v2(159.97,133.54) 159.97,133.43 159.59,133.05 159.59,132.89 158.47,131.77 158.47,131.46 157.94,130.94 157.94,129.36
  IN4 w0.127: 157.94,129.36 157.66,129.07 157.36,129.07 157.24,128.95 157.24,128.62 157.36,128.49 157.55,128.49 157.67,128.37 157.67,127.64 157.55,127.51 157.35,127.51 157.23,127.39 157.23,127.12 157.51,126.83 157.51,126.55 157.23,126.27 157.23,126 158.5,124.73 158.5,121.06 160.89,118.67 160.89,118.16 161.02,118.04 161.27,118.04 161.4,117.91 161.4,117.66 161.27,117.53 161.02,117.53 160.89,117.4 160.89,117.15 161.02,117.02 161.27,117.02 161.4,116.89 161.4,116.64 161.27,116.51 161.02,116.51 160.89,116.39 160.89,116.13 161.02,116.01 161.27,116.01 161.4,115.88 161.4,115.62 161.27,115.5 161.02,115.5 160.89,115.37 160.89,115.12 161.02,114.99 161.27,114.99 161.4,114.86 161.4,114.61 161.27,114.48 161.02,114.48 160.89,114.35 160.89,114.1 161.02,113.97 161.27,113.97 161.4,113.85 161.4,113.59 161.27,113.47 161.02,113.47 160.89,113.34 160.89,113.08 161.02,112.96 161.24,112.96 161.37,112.83 161.37,112.58 161.24,112.45 161.02,112.45 160.89,112.32 160.89,111.48 165.5,106.87 v1(165.5,103.01)
  BOTTOM w0.102: v2(159.97,133.54) 159.65,133.21 U42.AG8
  BOTTOM w0.216: v1(165.5,103.01) 165.33,103.19 JDIM1.169
M_B_DQ35: length 40.7
  IN4 w0.102: v2(160.96,131.6) 160.96,128.18 160.37,127.6
  IN4 w0.114: 160.37,124.38 160.37,125.65
  IN4 w0.127: 160.37,125.65 160.37,127.6 ; v1(168.28,97.77) 167.63,98.43 167.63,99.38 168.89,100.65 168.89,102.79 168,103.68 168,107.01 163.77,111.24 163.77,118.43 160.37,121.83 160.37,124.38
  BOTTOM w0.102: U42.AD6 161.27,131.91 v2(160.96,131.6)
  BOTTOM w0.216: JDIM1.182 168.58,97.48 v1(168.28,97.77)
M_B_DQ36: length 41.3
  IN4 w0.102: 161.13,127.56 161.37,127.8 161.37,130.98 161.61,131.22 161.95,131.22 162.27,131.53 162.27,132.97 161.77,133.47 v2(161.77,133.54)
  IN4 w0.127: 161.13,127.56 161.13,122.15 164.53,118.75 164.53,111.56 168.77,107.32 168.77,106.85 168.89,106.72 169.37,106.72 169.52,106.57 169.52,106.34 169.39,106.21 168.89,106.21 168.77,106.08 168.77,105.83 168.89,105.7 169.55,105.7 169.68,105.58 169.68,105.35 169.53,105.2 168.89,105.2 168.77,105.07 168.77,104.76 168.89,104.63 169.55,104.63 169.68,104.51 169.68,104.25 169.54,104.11 169.11,104.11 168.99,103.98 168.99,103.78 169.18,103.59 169.79,103.59 169.92,103.45 v1(169.92,103.03)
  BOTTOM w0.102: U42.AD8 161.39,133.44 161.49,133.54 v2(161.77,133.54)
  BOTTOM w0.216: JDIM1.187 169.83,103.12 v1(169.92,103.03)
M_B_DQ37: length 43.5
  IN4 w0.102: v2(159.97,134.19) 159.59,133.81 159.59,133.38 159.21,133.01
  IN4 w0.127: 159.21,133.01 158.07,131.87 158.07,131.5 156.89,130.31 156.89,125.73 158.12,124.5 158.12,120.9 160.51,118.52 160.51,111.32 165.06,106.77 165.06,97.96 165.44,97.58 v1(165.56,97.58)
  BOTTOM w0.102: U42.AG9 159.65,133.86 v2(159.97,134.19)
  BOTTOM w0.216: v1(165.56,97.58) 165.58,97.56 JDIM1.170
M_B_DQ38: length 42
  IN4 w0.102: v2(161.77,134.19) 161.97,134.19 162.16,134 162.16,133.38 162.47,133.07 162.47,131.44 162.15,131.12 162.15,127.39 161.51,126.75
  IN4 w0.127: v1(169.9,101.62) 169.9,101.32 170.06,101.16 170.26,101.16 170.45,101.35 170.45,103.6 170.06,103.99 170.06,106.57 164.91,111.72 164.91,118.91 161.51,122.31 161.51,126.75
  BOTTOM w0.102: U42.AD9 161.45,133.86 v2(161.77,134.19)
  BOTTOM w0.216: v1(169.9,101.62) 168.83,102.69 JDIM1.183
M_B_DQ39: length 41.1
  IN4 w0.102: 160.75,127.6 161.17,128.02 161.17,131.28 161.34,131.44 161.34,131.8 v2(161.77,132.24)
  IN4 w0.127: 160.75,127.6 160.75,121.99 164.15,118.59 164.15,111.4 168.38,107.17 168.38,103.84 169.28,102.95 169.28,98.67 169.35,98.6 169.84,98.11 v1(169.95,98.11)
  BOTTOM w0.102: U42.AC7 162.1,132.56 v2(161.77,132.24)
  BOTTOM w0.216: v1(169.95,98.11) 169.58,97.73 JDIM1.186
M_B_DQ40: length 43.1
  IN4 w0.102: 161.95,126.67 161.95,126.88 162.38,127.32 162.38,131.02 162.68,131.31 162.68,131.94 162.97,132.24 v2(163.31,132.24)
  IN4 w0.127: v1(171.39,97.47) 171.39,97.47 170.87,97.47 170.58,97.76 170.58,98.86 170.44,99 170.1,99.34 169.71,99.73 169.71,100.5 169.93,100.72 170.44,100.72 170.88,101.17 170.88,103.78 170.49,104.17 170.49,106.75 165.34,111.9 165.34,119.09 161.95,122.49 161.95,126.67
  BOTTOM w0.102: U42.Y6 163.5,132.24 v2(163.31,132.24)
  BOTTOM w0.216: JDIM1.194 171.58,97.09 171.39,97.27 v1(171.39,97.47)
M_B_DQ41: length 44
  IN4 w0.102: 162.33,126.7 162.33,126.89 162.64,127.2 162.64,130.92 162.88,131.16 162.88,131.35 163.12,131.59 v2(163.31,131.59)
  IN4 w0.127: 162.33,126.7 162.33,122.65 165.73,119.25 165.73,112.05 166,111.78 166.18,111.78 166.25,111.85 166.43,111.85 166.61,111.67 166.61,111.49 166.54,111.42 166.54,111.24 166.72,111.06 166.9,111.06 166.97,111.13 167.15,111.13 167.33,110.96 167.33,110.77 167.26,110.7 167.26,110.52 167.44,110.34 167.61,110.34 167.68,110.41 167.87,110.41 168.05,110.24 168.05,110.06 167.97,109.98 167.97,109.8 168.15,109.62 168.33,109.62 168.41,109.7 168.59,109.7 168.76,109.52 168.76,109.33 168.69,109.27 168.69,109.09 168.87,108.91 169.05,108.91 169.12,108.98 169.3,108.98 169.48,108.8 169.48,108.62 169.41,108.55 169.41,108.37 169.47,108.31 169.59,108.19 169.77,108.19 169.84,108.26 170.02,108.26 170.19,108.09 170.19,107.89 170.13,107.83 170.13,107.65 170.31,107.47 170.49,107.47 170.56,107.54 170.74,107.54 170.92,107.37 170.92,107.18 170.87,107.13 170.87,106.32 171,106.2 171.62,106.2 171.74,106.07 171.74,105.85 171.61,105.72 171,105.72 170.87,105.59 170.87,105.36 171,105.23 171.61,105.23 171.74,105.09 171.74,104.85 171.62,104.73 171,104.73 170.87,104.6 170.87,104.33 171,104.21 171.61,104.21 171.74,104.08 171.74,103.85 171.57,103.68 171.57,103.5 171.74,103.33 171.74,102.79 171.81,102.73 172.02,102.51 172.02,102.11 171.9,101.98 171.65,101.98 171.3,102.33 v1(171.3,102.4)
  BOTTOM w0.102: v2(163.31,131.59) 162.98,131.91 U42.AB6
  BOTTOM w0.216: JDIM1.191 170.83,102.71 171.14,102.4 v1(171.3,102.4)
M_B_DQ42: length 44.6
  IN4 w0.102: 162.71,126.87 162.71,126.92 162.9,127.11 162.9,130.85 163.24,131.19 163.45,131.19 163.69,131.43 163.69,132.43 163.37,132.75 163.37,132.91 v2(163.38,132.92)
  IN4 w0.127: v1(171.33,98.95) 170.6,99.67 170.6,100.2 171.25,100.85 171.43,100.85 171.72,100.55 171.95,100.55 172.08,100.68 172.08,100.91 171.9,101.1 171.9,101.28 172.41,101.78 172.41,102.67 172.13,102.95 172.13,106.63 171.96,106.79 171.48,106.79 171.32,106.95 171.32,107.5 166.11,112.71 166.11,119.4 162.71,122.8 162.71,126.87
  BOTTOM w0.102: U42.AB8 163.22,132.92 v2(163.38,132.92)
  BOTTOM w0.216: v1(171.33,98.95) 170.58,98.2 JDIM1.190
M_B_DQ43: length 43.1
  IN4 w0.102: v2(165.09,131.48) 165.49,131.08 165.49,127.86 165.07,127.44 165.07,124.93 165.01,124.86
  IN4 w0.127: 165.01,124.86 165.01,123.57 167.42,121.16 167.42,121.16 167.97,120.61 167.97,113.49 175.71,105.76 175.71,105.34 175.83,105.21 176.03,105.21 176.16,105.09 176.16,104.83 176.03,104.71 175.87,104.71 175.75,104.58 175.75,104.12 175.36,103.74 175.36,100.54 175.11,100.29 174.63,100.29 174.48,100.44 174.48,101.09 v1(174.93,101.54)
  BOTTOM w0.102: v2(165.09,131.48) 164.73,131.84 U42.W6
  BOTTOM w0.216: v1(174.93,101.54) 174.22,101.54 173.83,101.94 JDIM1.203
M_B_DQ44: length 44.2
  IN4 w0.102: v2(165.11,133.54) 165.11,132.76 165.49,132.38 165.73,132.14 165.73,127.42 165.39,127.08 165.39,124.17
  IN4 w0.127: 165.39,124.17 165.39,123.73 168.35,120.77 168.35,113.65 176.54,105.47 176.54,104.38 175.74,103.58 175.74,100.38 175.09,99.73 v1(174.58,99.73)
  BOTTOM w0.102: v2(165.11,133.54) 164.78,133.21 U42.W8
  BOTTOM w0.216: JDIM1.208 175.08,99.24 v1(174.58,99.73)
M_B_DQ45: length 45.8
  IN4 w0.102: 163.09,126.72 163.09,126.82 163.69,127.43 163.69,130.08 163.96,130.35 163.96,132.45 163.82,132.59 163.82,134.18 163.71,134.3 163.42,134.3 v2(163.31,134.19)
  IN4 w0.127: v1(172.82,101.69) 172.74,101.61 172.74,101.41 172.8,101.36 172.92,101.23 173.18,101.23 173.34,101.39 173.34,102.17 173.24,102.27 173.24,103.48 173.12,103.61 172.63,103.61 172.51,103.73 172.51,103.99 172.63,104.12 173.1,104.12 173.23,104.24 173.23,104.49 173.1,104.62 172.63,104.62 172.51,104.75 172.51,105 172.64,105.13 173.1,105.13 173.23,105.26 173.23,105.56 173.1,105.69 172.7,105.69 172.57,105.82 172.57,106.07 172.86,106.36 172.86,106.5 166.49,112.87 166.49,119.56 163.09,122.96 163.09,124.32 163.21,124.44 163.21,124.87 163.09,125 163.09,125.41 163.19,125.51 163.19,125.93 163.09,126.03 163.09,126.72
  BOTTOM w0.102: U42.AB9 162.92,134.09 163.03,134.19 v2(163.31,134.19)
  BOTTOM w0.216: v1(172.82,101.69) 171.83,102.69 JDIM1.195
M_B_DQ46: length 44.8
  IN4 w0.102: v2(165.11,134.19) 165.51,133.79 165.51,132.7 165.97,132.24 165.97,127.03 165.77,126.83 165.77,124.17
  IN4 w0.127: 165.77,124.17 165.77,123.89 168.74,120.92 168.74,113.81 176.92,105.63 176.92,104.22 176.12,103.42 176.12,100.22 175.8,99.9 175.58,99.68 175.15,99.25 175.15,98.76 v1(174.55,98.15)
  BOTTOM w0.102: U42.W9 164.78,133.86 v2(165.11,134.19)
  BOTTOM w0.216: JDIM1.204 174.08,97.68 v1(174.55,98.15)
M_B_DQ47: length 43
  IN4 w0.102: 164.19,126.64 164.19,127.03 164.33,127.17 164.33,127.85 164.61,128.12 164.61,128.26 164.33,128.54 164.33,128.78 164.43,128.88 164.63,128.88 164.73,128.98 164.73,129.19 164.63,129.29 164.43,129.29 164.33,129.39 164.33,129.62 164.71,130 164.71,131.87 165.05,132.22 v2(165.11,132.22)
  IN4 w0.127: 164.19,126.64 164.07,126.51 164.07,126.33 164.26,126.14 164.26,125.95 164,125.69 164,125.51 164.19,125.31 164.19,124.61 164.32,124.48 164.5,124.48 164.63,124.35 164.63,124.1 164.5,123.97 164.32,123.97 164.19,123.85 164.19,123.57 164.32,123.44 164.5,123.44 164.63,123.32 164.63,122.99 164.9,122.72 165.08,122.72 165.11,122.75 165.29,122.75 165.47,122.57 165.47,122.39 165.44,122.36 165.44,122.18 165.62,122 165.8,122 165.83,122.03 166.01,122.03 166.19,121.85 166.19,121.67 166.16,121.64 166.16,121.46 166.33,121.28 166.51,121.28 166.55,121.31 166.73,121.31 166.91,121.13 166.91,120.95 166.87,120.92 166.87,120.74 167.09,120.52 167.5,120.52 167.59,120.43 167.59,113.34 174.35,106.58 174.35,105.98 174.48,105.85 175.08,105.85 175.2,105.73 175.2,105.48 175.07,105.35 174.48,105.35 174.35,105.22 174.35,104.96 174.48,104.84 175.22,104.84 175.35,104.71 175.35,104.48 175.2,104.33 174.48,104.33 174.35,104.2 174.35,102.81 174.48,102.68 174.77,102.68 174.93,102.84 v1(174.93,102.98)
  BOTTOM w0.102: v2(165.11,132.22) 165.11,132.46 165.21,132.56 U42.V7
  BOTTOM w0.216: JDIM1.207 174.83,103.08 v1(174.93,102.98)
M_B_DQ48: length 43.2
  IN4 w0.127: v1(176.65,103.06) 176.65,103.34 177.35,104.04 177.35,104.43 177.48,104.56 177.7,104.56 177.83,104.69 177.83,104.94 177.7,105.07 177.48,105.07 177.35,105.2 177.35,105.45 177.48,105.58 177.7,105.58 177.83,105.7 177.83,105.95 177.69,106.08 177.48,106.08 177.35,106.21 177.35,106.42 177.26,106.51 177.2,106.56 177.04,106.56 176.94,106.46 176.73,106.46 176.55,106.63 176.55,106.81 176.79,107.04 176.79,107.22 176.61,107.4 176.43,107.4 176.2,107.17 176.02,107.17 175.84,107.35 175.84,107.53 176.07,107.76 176.07,107.94 175.89,108.12 175.71,108.12 175.48,107.89 175.3,107.89 175.12,108.07 175.12,108.25 175.35,108.48 175.35,108.66 175.17,108.84 174.99,108.84 174.76,108.61 174.58,108.61 174.4,108.79 174.4,108.97 174.63,109.2 174.63,109.38 174.45,109.56 174.27,109.56 174.04,109.33 173.83,109.33 169.17,113.99 169.17,121.1 166.28,123.99 166.28,124.21 166.04,124.45 166.04,124.71 166.2,124.87 166.28,124.87 166.38,124.97 166.38,125.17 166.28,125.27 166.17,125.27 166.05,125.39 166.05,125.58 166.15,125.68 166.29,125.68 166.4,125.79 166.4,125.99 166.29,126.09 166.15,126.09 166.05,126.19 166.05,126.4 166.2,126.55 166.2,126.76 166.46,127.02 166.46,127.24 166.2,127.5 166.2,130.94 166.32,131.07 166.32,131.32 166.2,131.44 166.2,132.18 166.33,132.31 166.57,132.31 v2(166.63,132.25)
  BOTTOM w0.127: v2(166.63,132.25) 166.63,132.1 166.81,131.91 U42.R6
  BOTTOM w0.216: JDIM1.215 176.83,103.45 176.65,103.27 v1(176.65,103.06)
M_B_DQ49: length 44.3
  IN4 w0.127: v1(176.58,101.74) 176.58,100.27 176.77,100.08 177.03,100.08 177.21,100.26 177.21,102.07 177.01,102.27 177.01,102.71 177.21,102.91 177.21,103.36 178.21,104.36 178.21,106.34 177.73,106.82 177.48,106.82 177.19,107.12 177.19,107.36 174.61,109.94 173.75,109.94 169.55,114.15 169.55,121.26 166.69,124.12 166.69,126.63 167.11,127.05 167.11,131.72 166.98,131.84 166.78,131.84 166.65,131.72 166.65,131.54 v2(166.65,131.53)
  BOTTOM w0.127: v2(166.65,131.53) 166.39,131.53 166.26,131.66 U42.U6
  BOTTOM w0.216: v1(176.58,101.74) 176.54,101.74 175.83,102.46 JDIM1.211
M_B_DQ50: length 45.1
  IN4 w0.102: v2(166.68,133.57) 166.68,133.39 167.35,132.72 167.35,126.85 166.98,126.48 166.98,124.37 167.18,124.17
  IN4 w0.127: 167.18,124.17 169.93,121.42 169.93,114.31 173.91,110.32 174.77,110.32 178.59,106.5 178.59,104.2 177.59,103.2 177.59,100.1 176.4,98.92 v1(176.25,98.92)
  BOTTOM w0.102: U42.U8 166.33,133.21 v2(166.68,133.57)
  BOTTOM w0.216: JDIM1.216 177.08,98.1 v1(176.25,98.92)
M_B_DQ51: length 42.8
  IN4 w0.127: v2(168.45,131.59) 168.71,131.59 168.84,131.46 168.84,126.68 168.96,126.55 169.2,126.55 169.43,126.33 169.43,126.15 169.3,126.02 168.92,126.02 168.8,125.89 168.8,125.66 168.97,125.49 169.7,125.49 169.83,125.36 169.83,125.13 169.68,124.98 168.94,124.98 168.8,124.84 168.8,124.6 168.94,124.46 169.78,124.46 170.39,123.85 170.39,123.67 170.35,123.63 170.35,123.35 170.48,123.22 170.77,123.22 170.82,123.26 170.97,123.26 171.24,123 171.24,123 171.42,122.82 171.42,114.92 174.53,111.81 174.79,111.81 174.89,111.9 175.29,111.9 180.08,107.11 180.08,103.59 179.99,103.5 179.99,103.28 180.08,103.19 180.08,102.33 179.95,102.2 179.77,102.2 179.68,102.29 179.68,102.3 v1(179.66,102.32)
  BOTTOM w0.127: U42.P6 167.94,131.8 167.94,131.62 168.07,131.49 168.35,131.49 v2(168.45,131.59)
  BOTTOM w0.216: v1(179.66,102.32) 179.52,102.19 179.18,102.19 178.96,102.4 178.96,102.98 179.33,103.34 JDIM1.225
M_B_DQ52: length 43.7
  IN4 w0.102: v2(168.46,132.88) 169.34,131.99 169.34,127.26
  IN4 w0.127: v1(179.97,98.88) 180.12,98.88 180.48,99.24 180.48,100.52 180.84,100.88 180.84,107.43 175.61,112.67 174.75,112.67 172.18,115.24 172.18,123.14 171.96,123.35 171.02,124.29 170.42,124.9 170.42,126.19 169.34,127.26
  BOTTOM w0.102: U42.P8 168.4,132.88 v2(168.46,132.88)
  BOTTOM w0.216: v1(179.97,98.88) 179.08,97.98 JDIM1.224
M_B_DQ53: length 45.9
  IN4 w0.102: v2(166.64,134.19) 167.08,133.75 167.08,133.36 167.58,132.86 167.58,126.69 167.25,126.37
  IN4 w0.127: v1(176.19,97.54) 176.57,97.54 177.18,98.15 177.18,99.04 177.97,99.83 177.97,103.04 178.97,104.05 178.97,106.66 174.93,110.7 174.07,110.7 170.31,114.46 170.31,121.58 167.25,124.63 167.25,126.37
  BOTTOM w0.102: U42.U9 166.32,133.86 v2(166.64,134.19)
  BOTTOM w0.216: v1(176.19,97.54) 176.08,97.42 JDIM1.212
M_B_DQ54: length 44.8
  IN4 w0.102: v2(168.47,134.19) 169.59,133.07 169.59,127.44 169.98,127.05
  IN4 w0.127: 169.98,127.05 170.74,126.29 170.74,125.11 172.56,123.3 172.56,115.4 174.91,113.05 175.76,113.05 181.22,107.59 181.22,100.72 180.86,100.37 180.86,98.36 v1(180.08,97.57)
  BOTTOM w0.102: v2(168.47,134.19) 168.15,133.86 U42.P9
  BOTTOM w0.216: v1(180.08,97.57) JDIM1.228
M_B_DQ55: length 43.3
  IN4 w0.102: v2(168.45,132.24) 169.12,131.57 169.12,127.15
  IN4 w0.127: 169.12,127.15 169.12,127.05 170.1,126.07 170.1,124.67 171.8,122.98 171.8,115.08 174.59,112.28 175.45,112.28 180.46,107.27 180.46,102.02 180.21,101.77 180.21,100.79 179.64,100.22 179.4,100.22 179.24,100.38 179.24,100.61 v1(179.66,101.03)
  BOTTOM w0.102: U42.N7 168.77,132.56 v2(168.45,132.24)
  BOTTOM w0.216: v1(179.66,101.03) 179.78,101.16 179.96,101.16 180.33,101.52 JDIM1.229
M_B_DQ56: length 47.8
  IN4 w0.102: v2(169.98,132.24) 169.98,132.04 170.57,131.46 170.57,127.51 171.35,126.73 171.35,125.65 171.86,125.14 172.83,124.17
  IN4 w0.127: 172.83,124.17 173.56,123.44 173.56,123.12 175.92,120.76 178,120.76 180.19,118.56 180.19,115.34 179.64,114.79 179.64,114.15 179.51,114.03 179.37,114.03 179.24,113.9 179.24,113.64 179.37,113.52 179.51,113.52 179.64,113.39 179.64,113.14 179.51,113.01 179.37,113.01 179.25,112.88 179.25,112.63 179.37,112.5 179.51,112.5 179.64,112.37 179.64,112.12 179.51,111.99 179.34,111.99 179.21,111.86 179.21,111.61 179.34,111.49 179.51,111.49 179.64,111.36 179.64,110.32 182.63,107.34 182.63,107.13 182.45,106.95 182.45,106.76 182.63,106.58 182.63,102.29 182.29,101.96 182.29,101.71 182.65,101.34 182.65,101.16 182.47,100.98 182.29,100.98 182.16,101.11 181.97,101.11 181.78,100.92 181.78,100.74 182.01,100.51 182.01,99.36 181.88,99.23 181.67,99.23 v1(181.38,99.52)
  BOTTOM w0.102: U42.K6 170.31,131.91 v2(169.98,132.24)
  BOTTOM w0.216: v1(181.38,99.52) 181.57,99.33 181.58,99.33 182.04,98.87 182.04,98.19 182.08,98.16 JDIM1.236
M_B_DQ57: length 48.6
  IN4 w0.102: 170.36,127.22 170.36,131.02 169.98,131.4 v2(169.98,131.48)
  IN4 w0.127: 170.36,127.22 171.07,126.51 171.07,125.39 171.59,124.87 173.01,123.46 173.01,122.82 173.14,122.69 173.45,122.69 173.58,122.56 173.58,122.31 173.45,122.18 173.14,122.18 173.01,122.06 173.01,121.8 173.14,121.67 174.19,121.67 174.37,121.5 174.37,121.32 174.21,121.17 173.14,121.17 173.01,121.04 173.01,120.79 173.14,120.66 174.37,120.66 174.52,120.51 174.52,120.28 174.39,120.15 173.14,120.15 173.01,120.02 173.01,119.77 173.14,119.64 173.61,119.64 173.74,119.51 173.74,119.26 173.61,119.13 173.14,119.13 173.01,119.01 173.01,118.66 173.19,118.48 173.19,118.24 172.99,118.04 172.99,115.58 175.02,113.54 175.88,113.54 182.05,107.37 182.05,107.19 181.92,107.07 181.78,107.07 181.65,106.94 181.65,106.68 181.78,106.55 182.12,106.55 182.24,106.42 182.24,106.16 182.12,106.03 181.78,106.03 181.65,105.91 181.65,105.65 181.78,105.53 182.12,105.53 182.24,105.4 182.24,105.15 182.12,105.02 181.78,105.02 181.65,104.89 181.65,104.64 181.78,104.51 182.12,104.51 182.24,104.38 182.24,104.13 182.12,104 181.78,104 181.65,103.88 181.65,103.62 181.78,103.49 182.12,103.49 182.24,103.37 182.24,102.46 182,102.21 v1(181.8,102.21)
  BOTTOM w0.102: U42.L6 169.6,131.87 v2(169.98,131.48)
  BOTTOM w0.216: JDIM1.233 181.33,102.68 v1(181.8,102.21)
M_B_DQ58: length 48.6
  IN4 w0.102: v2(169.97,133.53) 169.97,133.45 170.39,133.03 170.39,131.97 170.77,131.58 170.77,127.78 171.64,126.92 171.64,125.73 172.05,125.32 172.09,125.28 172.48,124.89 172.66,124.89 173.37,124.17
  IN4 w0.127: 173.37,124.17 174.1,123.44 174.1,123.12 174.3,122.92 174.62,122.92 174.82,122.72 174.82,122.4 175.02,122.2 175.34,122.2 175.54,122 175.54,121.68 175.74,121.48 176.06,121.48 176.4,121.14 178.15,121.14 180.57,118.72 180.57,114.71 180.43,114.56 180.19,114.56 180.05,114.42 180.05,114.18 180.17,114.06 180.43,114.06 180.55,113.93 180.55,113.68 180.43,113.55 180.19,113.55 180.05,113.41 180.05,113.17 180.18,113.04 180.43,113.04 180.55,112.91 180.55,112.66 180.43,112.53 180.19,112.53 180.05,112.39 180.05,112.15 180.18,112.02 180.43,112.02 180.55,111.9 180.55,111.64 180.43,111.52 180.19,111.52 180.02,111.35 180.02,111.17 180.18,111.01 180.43,111.01 180.55,110.88 180.55,109.95 183.01,107.49 183.01,106.72 183.13,106.59 183.46,106.59 183.59,106.47 183.59,106.18 183.46,106.05 183.13,106.05 183.01,105.93 183.01,105.67 183.13,105.55 183.46,105.55 183.59,105.42 183.59,105.16 183.46,105.04 183.13,105.04 183.01,104.91 183.01,104.66 183.13,104.53 183.46,104.53 183.59,104.4 183.59,104.15 183.46,104.02 183.13,104.02 183.01,103.89 183.01,103.64 183.13,103.51 183.46,103.51 183.59,103.39 183.59,102.1 183.11,101.62 v1(183.02,101.62)
  BOTTOM w0.102: v2(169.97,133.53) 169.65,133.21 U42.L8
  BOTTOM w0.216: v1(183.02,101.62) 182.33,102.32 JDIM1.237
M_B_DQ59: length 47
  IN4 w0.102: 172.17,128.98 172.17,130.64 172.05,130.75 171.73,130.75 171.63,130.85 171.63,131.43 v2(171.78,131.59)
  IN4 w0.127: v1(185.28,103.06) 185.46,103.06 185.61,103.22 185.61,103.78 185.46,103.94 185.24,103.94 185.12,104.07 185.12,104.32 185.24,104.45 185.53,104.45 185.65,104.58 185.65,104.83 185.52,104.96 185.24,104.96 185.12,105.08 185.12,105.34 185.24,105.46 185.53,105.46 185.65,105.59 185.65,105.85 185.53,105.97 185.24,105.97 185.12,106.1 185.12,106.35 185.24,106.48 185.53,106.48 185.65,106.61 185.65,106.92 185.53,107.05 185.34,107.05 185.12,107.27 185.12,107.48 182.48,110.12 182.48,110.59 182.38,110.69 182.18,110.69 182.06,110.82 182.06,111.07 182.18,111.2 182.34,111.2 182.48,111.33 182.48,111.57 182.34,111.71 182.18,111.71 182.06,111.83 182.06,112.09 182.18,112.21 182.35,112.21 182.48,112.34 182.48,112.6 182.35,112.72 182.18,112.72 182.06,112.85 182.06,113.1 182.18,113.23 182.35,113.23 182.48,113.36 182.48,113.61 182.35,113.74 182.18,113.74 182.06,113.87 182.06,114.12 182.18,114.25 182.35,114.25 182.48,114.37 182.48,114.63 182.35,114.75 182.18,114.75 182.06,114.88 182.06,115.13 182.19,115.26 182.35,115.26 182.48,115.39 182.48,115.64 182.35,115.77 182.18,115.77 182.06,115.9 182.06,116.15 182.18,116.28 182.35,116.28 182.48,116.41 182.48,116.66 182.35,116.79 182.19,116.79 182.06,116.92 182.06,117.17 182.18,117.29 182.35,117.29 182.48,117.42 182.48,117.68 182.35,117.8 182.19,117.8 182.06,117.93 182.06,118.18 182.18,118.31 182.35,118.31 182.48,118.44 182.48,118.78 182.35,118.9 182.22,118.9 182.1,119.03 182.1,119.3 178.76,122.64 177.44,122.64 175.62,124.46 175.62,124.64 175.78,124.8 175.78,124.98 175.6,125.16 175.42,125.16 175.26,125 175.08,125 174.9,125.18 174.9,125.36 175.06,125.52 175.06,125.72 174.89,125.89 174.71,125.89 174.54,125.72 174.36,125.72 174.18,125.9 174.18,126.08 174.37,126.27 174.37,126.45 174.19,126.63 174.01,126.63 173.78,126.39 173.6,126.39 173.33,126.66 173.33,126.89 173.58,127.14 173.58,127.39 173.27,127.7 173.27,128.38 173.02,128.63 172.52,128.63 172.17,128.98
  BOTTOM w0.102: U42.H6 171.4,131.69 171.5,131.59 v2(171.78,131.59)
  BOTTOM w0.216: v1(185.28,103.06) 185.33,103.1 JDIM1.249
M_B_DQ60: length 47.3
  IN4 w0.102: 175.24,126.83 173.9,128.17 173.9,128.81 173.18,129.53 173.18,130.65 172.51,131.32 172.4,131.43 172.4,131.93 172.19,132.14 172.19,132.68 171.99,132.88 v2(171.78,132.88)
  IN4 w0.127: 175.24,126.83 176.75,125.31 176.75,124.4 177.7,123.46 179.01,123.46 183.24,119.24 183.24,110.44 186.42,107.26 186.42,103.42 186.38,103.38 186.38,102.9 186.14,102.66 186.14,100.63 185.72,100.21 185.72,99.79 185.59,99.66 185.24,99.66 185.11,99.53 185.11,99.29 185.24,99.15 185.54,99.15 185.72,98.97 185.72,98.37 185.91,98.18 185.91,97.94 185.75,97.78 185.57,97.78 185.02,98.33 v1(184.9,98.33)
  BOTTOM w0.102: U42.H8 171.73,132.88 v2(171.78,132.88)
  BOTTOM w0.216: v1(184.9,98.33) 184.58,98 184.58,97.95 184.56,97.93 184.56,96.17 JDIM1.246
