# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
RG86  2K_1%_2  [R0201]  262.51 116.52 90 top
RG87  10K_1%_2  [R0201]  239.82 116.08 180 top
RG88  10K_1%_2  [R0201]  241.79 115.12 270 top
RG89  *12.1K_1%_2  [R0201]  250.38 114.7 90 top
RG90  *10K_1%_2  [R0201]  232.57 114.69 90 top
RG91  *0_5%_2  [R0201]  267.79 114.53 90 top
RG92  *0_5%_2  [R0201]  268.55 114.51 90 top
RG93  10K_1%_2  [R0201]  251.23 113.96 90 top
RG94  *Short_0201  [S0201]  247.4 113.55 0 top
RG95  *0_5%_2  [R0201]  235.84 113.37 270 top
RG96  *Short_0201  [S0201]  234.3 113.35 270 top
RG97  *0_5%_2  [R0201]  240.02 113.02 180 top
RG98  *Short_0201  [S0201]  240.88 112.9 270 top
RG99  10K_1%_2  [R0201]  247.4 112.79 0 top
RG100  2K_1%_2  [R0201]  261.1 112.16 270 top
RG101  *Short_0201  [S0201]  261.86 112.16 270 top
RG102  2K_1%_2  [R0201]  258.32 112.15 270 top
RG103  *Short_0201  [S0201]  259.08 112.15 270 top
RG104  10K_1%_2  [R0201]  242.07 112.01 0 top
RG105  4.7K_1%_2  [R0201]  255.32 112 90 top
RG106  10K_1%_2  [R0201]  248.11 111.72 180 top
RG107  *Short_0402  [S0402]  226.95 131.87 90 top
RG108  10K_1%_2  [R0201]  259.56 176.33 0 bottom
RG109  10K_1%_2  [R0201]  266.82 168.42 90 bottom
RG110  1K_1%_2  [R0201]  267.6 168.42 90 bottom
RG111  121_1%_2  [R0201]  207.09 168.74 90 bottom
RG112  121_1%_2  [R0201]  207.82 168.74 90 bottom
RG113  100K_1%_2  [R0201]  150.16 163.38 90 bottom
RG114  100K_1%_2  [R0201]  151.31 163.38 90 bottom
RG115  10K_1%_2  [R0201]  267.49 138.59 270 bottom
RG116  10K_1%_2  [R0201]  270.16 136.61 270 bottom
RG117  *10K_1%_2  [R0201]  271.02 136.76 180 bottom
RG118  *10K_1%_2  [R0201]  272.04 136.75 180 bottom
RG119  100K_1%_2  [R0201]  262 136.49 90 bottom
RG120  1.1K_1%_2  [R0201]  262.77 136.49 90 bottom
RG121  33_1%_2  [R0201]  269.84 135.75 0 bottom
RG122  10K_1%_2  [R0201]  272.55 135.03 180 bottom
RG123  10K_1%_2  [R0201]  271.45 134.99 180 bottom
RG124  10K_1%_2  [R0201]  261.24 133.44 270 bottom
RG125  100K_1%_2  [R0201]  262.26 132.3 0 bottom
RG126  10K_1%_2  [R0201]  265.18 132.04 270 bottom
RG127  10K_1%_2  [R0201]  265.94 132.04 270 bottom
RG128  10K_1%_2  [R0201]  262.26 131.53 0 bottom
RG129  10K_1%_2  [R0201]  264.48 129.07 180 bottom
RG130  10K_1%_2  [R0201]  264.48 128.31 0 bottom
RG131  1K_1%_2  [R0201]  206.65 125.09 180 bottom
RG132  10K_1%_2  [R0201]  207.79 125.09 180 bottom
RG133  10K_1%_2  [R0201]  271.11 125.08 270 bottom
RG134  100K_1%_2  [R0201]  274.52 124.8 0 bottom
RG135  33_1%_2  [R0201]  272.44 124.65 90 bottom
RG136  33_1%_2  [R0201]  273.58 124.65 90 bottom
RG137  2.49K_1%_2  [R0201]  220.09 124.14 0 bottom
RG138  *100K_1%_2  [R0201]  274.52 124.06 180 bottom
RG139  *0_5%_2  [R0201]  221.11 124.04 270 bottom
RG140  *0_5%_2  [R0201]  222 124.04 90 bottom
RG141  100K_1%_2  [R0201]  257.99 124.03 270 bottom
RG142  100K_1%_2  [R0201]  272.03 123.64 90 bottom
RG143  *100K_1%_2  [R0201]  270.83 123.12 270 bottom
RG144  *10K_1%_2  [R0201]  268.35 123.03 270 bottom
RG145  *Short_0201  [S0201]  256.44 123.05 0 bottom
RG146  10K_1%_2  [R0201]  252.76 122.75 0 bottom
RG147  10K_1%_2  [R0201]  262.26 122.39 0 bottom
RG148  *Short_0201  [S0201]  256.91 122.34 180 bottom
RG149  100K_1%_2  [R0201]  266.58 122.14 270 bottom
RG150  10K_1%_2  [R0201]  241.68 122.01 90 bottom
RG151  N_DDS_GSYNC_N@100K_1%_2  [R0201]  260.4 121.28 90 bottom
RG152  100K_1%_2  [R0201]  261.26 121.44 90 bottom
RG153  *100K_1%_2  [R0201]  262 121.44 90 bottom
RG154  *100K_1%_2  [R0201]  248.18 120.92 270 bottom
RG155  *100K_1%_2  [R0201]  248.89 120.92 270 bottom
RG156  100K_1%_2  [R0201]  245.05 120.75 270 bottom
RG157  100K_1%_2  [R0201]  245.76 120.75 270 bottom
RG158  100K_1%_2  [R0201]  249.75 120.66 180 bottom
RG159  100K_1%_2  [R0201]  250.76 120.66 0 bottom
RG160  DDS_GSYNC@100K_1%_2  [R0201]  260.35 120.21 90 bottom
RG161  *100K_1%_2  [R0201]  261.06 120.21 90 bottom
RG162  100K_1%_2  [R0201]  261.9 119.89 90 bottom
RG163  100K_1%_2  [R0201]  251.1 119.81 180 bottom
RG164  100K_1%_2  [R0201]  252.11 119.81 0 bottom
RG165  10K_1%_2  [R0201]  268.99 119.44 90 bottom
RG166  10K_1%_2  [R0201]  266.2 119.22 180 bottom
RG167  100K_1%_2  [R0201]  260.32 118.76 180 bottom
RG168  *0_5%_2  [R0201]  263.05 118.73 180 bottom
RG169  *Short_0201  [S0201]  268.98 118.58 0 bottom
RG170  *Short_0201  [S0201]  267.49 118.35 270 bottom
RG171  10K_1%_2  [R0201]  231.3 118.07 270 bottom
RG172  *Short_0201  [S0201]  266.72 117.98 270 bottom
RG173  *Short_0201  [S0201]  269.95 117.98 270 bottom
RG174  10K_1%_2  [R0201]  261.52 117.73 90 bottom
RG175  100K_1%_2  [R0201]  265.78 117.73 270 bottom
RG176  10K_1%_2  [R0201]  260.05 117.58 0 bottom
RG177  100K_1%_2  [R0201]  247.21 116.91 180 bottom
RG178  *Short_0402  [S0402]  240.5 116.69 0 bottom
RG179  *12.1K_1%_2  [R0201]  246.07 115.57 90 bottom
RG180  10K_1%_2  [R0201]  232.84 115.46 270 bottom
RG181  10K_1%_2  [R0201]  255.78 115.37 90 bottom
RG182  10K_1%_2  [R0201]  259.07 115.35 180 bottom
RS1  51_1%_2  [R0201]  219.08 84.8 90 bottom
RS2  100K_1%_2  [R0201]  246.81 59.22 270 bottom
RV1  *TVM0G5R5M220R_22p  [R0402]  14.86 41.87 270 top
RV2  *TVM0G5R5M220R_22p  [R0402]  14.99 38.7 270 top
RV3  *TVM0G5R5M220R_22p  [R0402]  16.16 29.94 0 bottom
RV4  *TVM0G5R5M220R_22p  [R0402]  16.16 28.92 0 bottom
S1  -  [CLIP-39X35-100X18-3P]  217.75 188.97 180 bottom
S2  -  [CLIP-39X35-100X18-3P]  240.75 188.97 180 bottom
S3  -  [CLIP-39X35-100X18-3P]  265.75 188.97 180 bottom
S4  -  [CLIP-39X35-100X18-3P]  280.87 178.32 270 bottom
S5  -  [CLIP-39X35-100X18-3P]  123.25 171.94 180 bottom
S6  -  [CLIP-39X35-100X18-3P]  156.25 171.94 180 bottom
S7  -  [CLIP-39X35-100X18-3P]  189.25 171.94 180 bottom
S8  -  [CLIP-39X35-100X18-3P]  117.54 163.32 270 bottom
S9  -  [CLIP-39X35-100X18-3P]  280.87 153.32 270 bottom
S10  -  [CLIP-39X35-100X18-3P]  280.87 128.32 270 bottom
S11  -  [CLIP-39X35-100X18-3P]  117.54 127.32 270 bottom
S12  -  [CLIP-39X35-100X18-3P]  126.75 112.65 180 bottom
S13  -  [CLIP-39X35-100X18-3P]  174.75 112.65 180 bottom
S14  -  [CLIP-39X35-100X18-3P]  222.75 112.65 180 bottom
S15  -  [CLIP-39X35-100X18-3P]  270.75 112.65 180 bottom
SW1  Debug@T3AL-23S-Q-T/R  [SW-T3AL-23-Q-TR-4P]  193.47 57.6 270 bottom
SW2  TME-533B-Q-T/R  [SW-TME-533B-Q-TR-6P]  251.12 53.28 270 bottom
T1  *PAD  [TP2050]  238.49 64.76 0 top
T2  *PAD  [TP2050]  18.67 22.06 0 top
T3  *PAD  [TP2050]  19.75 20.95 0 top
T4  *PAD  [TP2050]  21.16 20.92 0 top
T5  *PAD  [TP2050]  26.67 20.66 180 bottom
T6  *PAD  [TP2050]  25.38 20.61 180 bottom
TP1  *TP  [TP2050]  226.24 209.68 0 top
TP2  *PAD  [TP2050]  149.44 208.55 0 top
TP3  *PAD  [TP2050]  279.33 200.95 90 top
TP4  *PAD  [TP2050]  283.72 191.81 90 top
TP5  *PAD  [TP2050]  283.72 181.84 90 top
TP6  *PAD  [TP2050]  285.39 181.83 90 top
TP7  *PAD  [TP2050]  169.44 153.29 0 top
TP8  *PAD  [TP2050]  170.84 152.78 0 top
TP9  *PAD  [TP2050]  168.78 152.16 0 top
TP10  *PAD  [TP2050]  184.03 151.85 0 top
TP11  *PAD  [TP2050]  184.03 150.58 0 top
TP12  *PAD  [TP2050]  184.03 149.31 0 top
TP13  *PAD  [TP2050]  184.94 146.22 0 top
TP14  *PAD  [TP2050]  184.03 147.79 0 top
TP15  *PAD  [TP2050]  167.44 143.86 0 top
TP16  *PAD  [TP2050]  268.66 131.97 90 top
TP17  *PAD  [TP2050]  269.75 131.28 90 top
TP18  *PAD  [TP2050]  252.5 131.94 90 top
TP19  *PAD  [TP2050]  280.85 122.04 90 top
TP20  *PAD  [TP2050]  269.34 113.2 90 top
TP21  *PAD  [TP2050]  270.84 113.04 90 top
TP22  *PAD  [TP2050]  280.75 120.56 90 top
TP23  *PAD  [TP2050]  265.48 116.57 90 top
TP24  *PAD  [TP2050]  165.54 100.95 0 top
TP25  *PAD  [TP2050]  18.93 97.32 90 top
TP26  *PAD  [TP2050]  163.5 96.79 0 top
TP27  *PAD  [TP2050]  20.83 96.69 90 top
TP28  *PAD  [TP2050]  35.03 93.5 0 top
TP29  *PAD  [TP2050]  66.68 93.31 0 top
TP30  *PAD  [TP2050]  61.29 92.14 90 top
TP31  *PAD  [TP2050]  70.11 91.02 0 top
TP32  *PAD  [TP2050]  164.6 88.94 0 top
TP33  *PAD  [TP2050]  66.55 87.08 0 top
TP34  *PAD  [TP2050]  213.77 86.55 0 top
TP35  *PAD  [TP2050]  40 86.13 0 top
TP36  *PAD  [TP2050]  42.17 86.07 0 top
TP37  *PAD  [TP2050]  44.07 86.07 0 top
TP38  *PAD  [TP2050]  66.97 85.81 0 top
TP39  *PAD  [TP2050]  61.22 85.13 90 top
TP40  *PAD  [TP2050]  213.53 84.8 0 top
TP41  *PAD  [TP2050]  64.65 82.64 0 top
TP42  *PAD  [TP2050]  162.84 82.59 0 top
TP43  *PAD  [TP2050]  63.18 81.07 0 top
TP44  *PAD  [TP2050]  18.19 80.64 90 top
TP45  *PAD  [TP2050]  19.12 79.78 90 top
TP46  *PAD  [TP2050]  208.09 77.2 0 top
TP48  *PAD  [TP2050]  301.88 76.8 90 top
TP49  *PAD  [TP2050]  30.36 76.24 0 top
TP50  *PAD  [TP2050]  209.67 74.46 0 top
TP51  *PAD  [TP2050]  212.63 74.96 0 top
TP52  *PAD  [TP2050]  211.95 73.71 0 top
TP53  *PAD  [TP2050]  215.98 72.53 0 top
TP54  *PAD  [TP2050]  222.25 72.23 0 top
TP55  *PAD  [TP2050]  217.4 70.85 0 top
TP56  *PAD  [TP2050]  35.44 68.92 0 top
TP57  *PAD  [TP2050]  37.34 68.75 0 top
TP58  *PAD  [TP2050]  39.24 68.83 0 top
TP59  *PAD  [TP2050]  21.12 68.47 90 top
TP60  *PAD  [TP2050]  18.1 68.07 90 top
TP61  *PAD  [TP2050]  221.49 67.27 0 top
TP62  *PAD  [TP2050]  220.16 67.23 0 top
TP63  *PAD  [TP2050]  220.07 65.79 0 top
TP64  *PAD  [TP2050]  220.09 64.49 0 top
TP65  *PAD  [TP2050]  214.86 63.97 0 top
TP66  *PAD  [TP2050]  210.49 63.91 0 top
TP67  *PAD  [TP2050]  213.61 63.73 0 top
TP68  *PAD  [TP2050]  305.53 63.52 0 top
TP69  *PAD  [TP2050]  37.75 62.6 0 top
TP70  *PAD  [TP2050]  304.98 62.35 0 top
TP71  *PAD  [TP2050]  206.29 61.9 0 top
TP72  *PAD  [TP2050]  220.6 61.63 0 top
TP73  *PAD  [TP2050]  222.87 61.56 0 top
TP74  *PAD  [TP2050]  205.11 61.43 0 top
TP75  *PAD  [TP2050]  227.59 60.97 0 top
TP76  *PAD  [TP2050]  184.33 56.33 0 top
TP77  *PAD  [TP2050]  181.87 55.72 0 top
TP78  *PAD  [TP2050]  211.2 54.47 0 top
TP79  *PAD  [TP2050]  38.23 54.09 0 top
TP80  *PAD  [TP2050]  210.22 51.81 90 top
TP81  *PAD  [TP2050]  207.9 51.52 0 top
TP82  *PAD  [TP2050]  210.56 42.88 0 top
TP83  *PAD  [TP2050]  273.86 217.58 90 bottom
TP84  *PAD  [TP2050]  265.15 216.62 270 bottom
TP85  *PAD  [TP2050]  266.74 216.27 270 bottom
TP86  *PAD  [TP2050]  265.43 214.77 270 bottom
TP87  *PAD  [TP2050]  171.8 160.5 180 bottom
TP88  *PAD  [TP2050]  178.97 160.53 180 bottom
TP89  *PAD  [TP2050]  152.86 160.33 180 bottom
TP90  *PAD  [TP2050]  173.76 160.15 180 bottom
TP91  *PAD  [TP2050]  154.07 159.94 180 bottom
TP92  *PAD  [TP2050]  147.47 159.64 180 bottom
TP93  *PAD  [TP2050]  148.74 159.64 180 bottom
TP94  *PAD  [TP2050]  175.41 159.64 180 bottom
TP95  *PAD  [TP2050]  172.49 159.26 180 bottom
TP96  *PAD  [TP2050]  153.12 159.09 180 bottom
TP97  *PAD  [TP2050]  169.69 158.88 180 bottom
TP98  *PAD  [TP2050]  170.96 158.88 180 bottom
TP99  *PAD  [TP2050]  173.76 158.88 180 bottom
TP100  *PAD  [TP2050]  147.47 158.37 180 bottom
TP101  *PAD  [TP2050]  148.74 158.37 180 bottom
TP102  *PAD  [TP2050]  175.76 157.84 180 bottom
TP103  *PAD  [TP2050]  178.58 157.73 180 bottom
TP104  *PAD  [TP2050]  179.85 157.73 180 bottom
TP105  *PAD  [TP2050]  142.5 157.7 180 bottom
TP106  *PAD  [TP2050]  169.69 157.61 180 bottom
TP107  *PAD  [TP2050]  170.96 157.61 180 bottom
TP108  *PAD  [TP2050]  173.67 157.58 180 bottom
TP109  *PAD  [TP2050]  177.01 157.56 180 bottom
TP110  *PAD  [TP2050]  123.83 130.9 180 bottom
TP111  *PAD  [TP2050]  123.84 129.54 180 bottom
TP112  *PAD  [TP2050]  123.83 128.27 180 bottom
TP113  *PAD  [TP2050]  179.2 124.93 180 bottom
TP114  *PAD  [TP2050]  128.52 124.67 180 bottom
TP115  *PAD  [TP2050]  179.2 123.66 180 bottom
TP116  *TP  [TP2050]  285.63 95.09 180 bottom
TP117  *TP  [TP2050]  275.85 94.96 180 bottom
TP118  *TP  [TP2050]  256.16 94.32 180 bottom
TP119  *TP  [TP2050]  236.6 94.2 180 bottom
TP120  *TP  [TP2050]  226.83 94.07 180 bottom
TP121  *TP  [TP2050]  246.26 94.07 180 bottom
TP122  *TP  [TP2050]  265.94 94.07 180 bottom
TP123  *TP  [TP2050]  217.06 93.71 180 bottom
TP124  *PAD  [TP2050]  111.64 92.29 180 bottom
TP125  *PAD  [TP2050]  66.51 91.21 180 bottom
TP126  *PAD  [TP2050]  310.65 90.64 270 bottom
TP127  *PAD  [TP2050]  100.35 90.31 180 bottom
TP128  *PAD  [TP2050]  100.37 89.03 180 bottom
TP129  *PAD  [TP2050]  64.09 88.25 180 bottom
TP130  *PAD  [TP2050]  40.52 87.97 180 bottom
TP131  *PAD  [TP2050]  310.77 87.85 270 bottom
TP132  *PAD  [TP2050]  214.06 87.71 180 bottom
TP133  *PAD  [TP2050]  215.16 87.02 180 bottom
TP134  *PAD  [TP2050]  64.14 86.96 180 bottom
TP135  *PAD  [TP2050]  60.31 87.24 270 bottom
TP136  *PAD  [TP2050]  221.39 85.94 180 bottom
TP137  *PAD  [TP2050]  207.42 85.48 180 bottom
TP138  *PAD  [TP2050]  214.05 84.77 180 bottom
TP139  *PAD  [TP2050]  218.32 84.37 180 bottom
TP140  *PAD  [TP2050]  221.39 84.16 180 bottom
TP141  *PAD  [TP2050]  205.01 83.94 180 bottom
TP142  *PAD  [TP2050]  211.03 82.41 180 bottom
TP143  *PAD  [TP2050]  299.22 79.74 90 bottom
TP144  *PAD  [TP2050]  298.73 78.47 90 bottom
TP145  *PAD  [TP2050]  297.82 77.43 90 bottom
TP146  *PAD  [TP2050]  273.78 76.67 180 bottom
TP147  *PAD  [TP2050]  273.54 71.34 180 bottom
TP148  *PAD  [TP2050]  271.58 71 180 bottom
TP149  *PAD  [TP2050]  36.05 70.8 180 bottom
TP150  *PAD  [TP2050]  272.55 70.01 180 bottom
TP151  *PAD  [TP2050]  99.05 65.4 180 bottom
TP152  *PAD  [TP2050]  99.06 64.1 180 bottom
TP153  *PAD  [TP2050]  272.68 62.58 180 bottom
TP154  *PAD  [TP2050]  195.84 61.56 180 bottom
TP155  *PAD  [TP2050]  195.84 60.29 180 bottom
TP156  *PAD  [TP2050]  278.39 53.91 180 bottom
TP157  *PAD  [TP2050]  284.42 53.67 180 bottom
TP158  *PAD  [TP2050]  227.97 53.01 180 bottom
TP159  *PAD  [TP2050]  214.01 52.74 180 bottom
TP160  *PAD  [TP2050]  216.62 52.73 180 bottom
TP161  *PAD  [TP2050]  215.3 52.61 180 bottom
TP162  *PAD  [TP2050]  197.37 52.46 180 bottom
TP163  *PAD  [TP2050]  225.02 51.93 180 bottom
TP164  *PAD  [TP2050]  200.31 51.92 180 bottom
TP165  *PAD  [TP2050]  208.31 51.9 180 bottom
TP166  *PAD  [TP2050]  198.96 51.89 180 bottom
TP167  *PAD  [TP2050]  216.54 51.2 180 bottom
TP168  *PAD  [TP2050]  197.69 51.2 180 bottom
TP169  *PAD  [TP2050]  223.31 50.86 180 bottom
TP170  *PAD  [TP2050]  225.3 50.61 180 bottom
TP171  *PAD  [TP2050]  201.37 49.93 180 bottom
TP172  *PAD  [TP2050]  208.52 49.86 180 bottom
TP173  *PAD  [TP2050]  209.89 49.68 180 bottom
TP174  *PAD  [TP2050]  212.09 49.58 180 bottom
TP175  *PAD  [TP2050]  198.71 49.55 180 bottom
TP176  *PAD  [TP2050]  214.81 49.49 180 bottom
TP177  *PAD  [TP2050]  223.65 73.23 0 top
TP178  *PAD  [TP2050]  198.72 79.28 0 top
TP179  *PAD  [TP2050]  198.76 77.94 0 top
TP180  *PAD  [TP2050]  198.76 76.54 0 top
TP181  *PAD  [TP2050]  198.76 75.27 90 top
TP182  *PAD  [TP2050]  198.73 82.35 0 top
TP183  *PAD  [TP2050]  198.71 80.59 0 top
TPG1  *PAD  [TP2050]  223.74 180.03 0 top
TPG2  *PAD  [TP2050]  237.45 179.01 0 top
TPG3  *PAD  [TP2050]  222.91 178.85 0 top
TPG4  *PAD  [TP2050]  252.97 178.67 0 top
TPG5  *PAD  [TP2050]  251.48 178.1 0 top
TPG6  *PAD  [TP2050]  236.44 177.85 0 top
TPG7  *PAD  [TP2050]  223.99 177.83 0 top
TPG8  *PAD  [TP2050]  254.03 177.76 0 top
TPG9  *PAD  [TP2050]  239.98 177.64 0 top
TPG10  *PAD  [TP2050]  250.4 176.06 0 top
TPG11  *PAD  [TP2050]  223.94 175.8 0 top
TPG12  *PAD  [TP2050]  252.65 175.47 0 top
TPG13  *PAD  [TP2050]  254 175.42 0 top
TPG14  *PAD  [TP2050]  237.35 174.98 0 top
TPG15  *PAD  [TP2050]  224.02 174.43 0 top
TPG16  *PAD  [TP2050]  237.41 173.66 0 top
TPG17  *PAD  [TP2050]  223.06 173.56 0 top
TPG18  *PAD  [TP2050]  240.07 173.12 0 top
TPG19  *PAD  [TP2050]  206.35 161.91 0 top
TPG20  *PAD  [TP2050]  203.74 162.15 0 top
TPG21  *PAD  [TP2050]  271.35 160.49 0 top
TPG22  *PAD  [TP2050]  267.24 160.52 0 top
TPG23  *PAD  [TP2050]  207.93 160.95 0 top
TPG24  *PAD  [TP2050]  209.53 159.42 0 top
TPG25  *PAD  [TP2050]  269.85 160.94 0 top
TPG26  *PAD  [TP2050]  205.53 160.92 0 top
TPG27  *PAD  [TP2050]  204.14 160.9 0 top
TPG28  *PAD  [TP2050]  268.58 160.78 0 top
TPG29  *PAD  [TP2050]  266.12 159.91 0 top
TPG30  *PAD  [TP2050]  270.13 159.6 0 top
TPG31  *PAD  [TP2050]  206.17 148.17 0 top
TPG32  *PAD  [TP2050]  263.98 148 0 top
TPG33  *PAD  [TP2050]  204.87 147.7 0 top
TPG34  *PAD  [TP2050]  209.97 147.61 0 top
TPG35  *PAD  [TP2050]  208.66 147.57 0 top
TPG36  *PAD  [TP2050]  268.6 147.52 0 top
TPG37  *PAD  [TP2050]  269.62 145.73 0 top
TPG38  *PAD  [TP2050]  265.78 145.57 0 top
TPG39  *PAD  [TP2050]  208.68 145.47 0 top
TPG40  *PAD  [TP2050]  267.05 145.41 0 top
TPG41  *PAD  [TP2050]  203.48 144.9 0 top
TPG42  *PAD  [TP2050]  270.77 143.98 0 top
TPG43  *PAD  [TP2050]  204.67 133.25 0 top
TPG44  *PAD  [TP2050]  209.25 133.11 0 top
TPG45  *PAD  [TP2050]  208.08 132.42 0 top
TPG46  *PAD  [TP2050]  203.73 131.95 0 top
TPG47  *PAD  [TP2050]  205 131.95 0 top
TPG48  *PAD  [TP2050]  206.78 131.89 0 top
TPG49  *PAD  [TP2050]  243.18 121.07 0 top
TPG50  *PAD  [TP2050]  271.24 136 270 bottom
TPG51  *PAD  [TP2050]  272.51 136 270 bottom
TPG52  *PAD  [TP2050]  270.35 134.86 270 bottom
TPG53  *PAD  [TP2050]  272.38 125.71 270 bottom
TPG54  *PAD  [TP2050]  273.69 125.69 270 bottom
TPG55  *PAD  [TP2050]  253.18 123.5 180 bottom
TPG56  *PAD  [TP2050]  240.85 122.39 180 bottom
TPG57  *PAD  [TP2050]  254.56 121.86 180 bottom
TPG58  *PAD  [TP2050]  241.3 120.94 180 bottom
TPG59  *PAD  [TP2050]  240.71 119.78 180 bottom
TPG60  *PAD  [TP2050]  240.57 118.33 180 bottom
TPS1  *PAD  [TP2050]  223.14 76.14 0 top
TPS2  *PAD  [TP2050]  219.62 75.63 0 top
TPS3  *PAD  [TP2050]  207.75 60.3 0 top
U1  6K5130UA0  [QFN32-4X4-4-33P-MT6605N]  147.2 205.19 180 top
U2  74AUP1G32SE-7  [SC70-2_1-65-5P]  201.17 185.76 90 top
U3  74AUP1G32SE-7  [SC70-2_1-65-5P]  204.73 185.76 90 top
U4  SN74LVC2G53DCUR  [VSSOP8-3_1-5-TS5A3359]  283.35 177.96 0 top
U5  TPS22924CYZPR  [BGA6-TEXAS-CD3271-6P]  53.6 98.39 90 top
U6  SLGC55544CVTR  [QFN16-3X3-5-17P-SLGC55544C]  311.92 95.97 270 top
U7  SLGC55544CVTR  [QFN16-3X3-5-17P-SLGC55544C]  318.27 95.97 270 top
U8  *TUSB212RWBR  [QFN12-1_6X1_6-4-TUSB320]  18.93 95.42 90 top
U9  JHL8040R QURW  [BGA105-INTEL-DELTABRIDGE-0_5S]  38.87 90.39 90 top
U10  W25Q80DVSNIG  [SOIC8-6-1_27-PM25LV010A]  50.55 88.61 0 top
U11  TPS65994ADYBGR  [BGA50-TEXAS-TPS65994-NHDI]  61.12 88.23 90 top
U12  *MC74VHC1G08DFT2G  [SOT353-1-2_125-65-5P]  99.32 85.56 270 top
U13  TPS22924CYZPR  [BGA6-TEXAS-CD3271-6P]  46.23 80.48 90 top
U14  CAT24C256WI-GT3  [SOIC8-6-1_27-PM25LV010A]  67.57 79.72 90 top
U15  *TUSB212RWBR  [QFN12-1_6X1_6-4-TUSB320]  17.28 78.73 90 top
U16  JHL8040R QURW  [BGA105-INTEL-DELTABRIDGE-0_5S]  34.29 73.11 90 top
U17  **74AVC1T45FZ4-7  [DFN6-1_4X1-5]  227.71 70.26 90 top
U18  TPM@NPCT750AADYX  [QFN32-5X5-5-33P-0_85H]  238.88 68.96 0 top
U19  *74AVC1T45FZ4-7  [DFN6-1_4X1-5]  226.01 66.99 90 top
U20  ALC289-CG  [QFN48-6X6-4-49P-ALC280]  312.35 66.43 270 top
U21  SUB@ALC1006-VB-P-CG  [QFN48-6X6-4-49P-ALC280]  301.22 66.03 270 top
U22  NL17SZ08DFT2G  [SOT353-1-2_125-65-5P]  271.28 65.88 180 top
U23  IT5571E-128/DX  [LQFP128-16X16-4-1_6H]  175.71 65.1 270 top
U24  PS8811QFN36GTR2-A3  [QFN36-4_2X4_2-4-37P]  19.21 64.3 180 top
U25  *MC74VHC1G08DFT2G  [SOT353-1-2_125-65-5P]  98.17 63.34 180 top
U26  NL17SZ08DFT2G  [SOT353-1-2_125-65-5P]  271.28 63.34 180 top
U27  PI3HDX12211ZHEX  [QFN42-9X3_5-5-43P-PI3EQX1004]  41.73 58.24 180 top
U28  *MC74VHC1G08DFT2G  [SOT353-1-2_125-65-5P]  224.55 57.73 180 top
U29  UP7553PMA5-15  [SOT23-5-2_8-95-5P-G708]  20.57 45.82 270 top
U30  *MC74VHC1G08DFT2G  [SOT353-1-2_125-65-5P]  212.35 45.68 180 top
U31  G5250Q1T73U  [SOT23-2_38-95-3P]  17.62 39.82 180 top
U32  *AZ1023-04F.R7G  [ESD10-2_5X1-5-9P-AZ1143]  17.02 36.28 90 top
U33  *AZ1023-04F.R7G  [ESD10-2_5X1-5-9P-AZ1143]  17.02 31.46 90 top
U34  MC74VHC1G08DFT2G  [SOT353-1-2_125-65-5P]  24.44 13.7 0 top
U35  G781P8  [MSOP8-4_9-65]  258.58 215.99 270 bottom
U36  PI3DPX8121ZLDEX  [QFN40-6X3-4-41P-0_75H]  274.2 212.69 0 bottom
U37  PI3CH480QEX  [SOP16-5_99-635]  264.34 211.29 270 bottom
U38  APL3512ABI-TRG  [SOT23-5-2_8-95-5P-G708]  283.85 203.04 180 bottom
U39  MC74VHC1G08DFT2G  [SOT353-1-2_125-65-5P]  275.99 200.87 270 bottom
U40  MC74VHC1G08DFT2G  [SOT353-1-2_125-65-5P]  273.5 200.87 270 bottom
U41  MC74VHC1G08DFT2G  [SOT353-1-2_125-65-5P]  114.05 141.82 270 bottom
U42  CPU_TGL_H_1787P  [BGA1787-INTEL-TGL-H]  151.9 141.25 180 bottom
U43  M74VHC1GT32DFT2G  [SOT353-2_1-65-5P]  261.88 124.17 270 bottom
U44  MC74VHC1G08DFT2G  [SOT353-1-2_125-65-5P]  264.31 124.17 90 bottom
U45  M74VHC1GT32DFT2G  [SOT353-2_1-65-5P]  266.74 124.17 270 bottom
U46  G781P8  [MSOP8-4_9-65]  212.47 102.58 0 bottom
U49  PCH_TGL_H_943P  [BGA943-INTEL-TGL-H-PCH]  212.9 67.5 0 bottom
U50  5G_S@SX9310ICSTRT  [BGA9-SEMTECH-SX9310-0_5S]  277.52 55.87 0 bottom
U51  5G_S@SX9310ICSTRT  [BGA9-SEMTECH-SX9310-0_5S]  284 55.61 0 bottom
U52  SLGC55544CVTR  [QFN16-3X3-5-17P-SLGC55544C]  22.45 53.35 270 bottom
U53  W25Q256JVEIQ  [SON8-8X6-1_27-9P]  243.61 51.72 180 bottom
U54  *TLV8801DBVR  [SOT23-2_8-95-5P-LP2985-50DBVT]  186.76 49.7 270 bottom
U55  PS8527BTQFN20GTR2-A2  [TQFN20-4X4-5-25P]  272.8 46.57 0 bottom
U56  TUSB546-DCIRNQR  [QFN40-6X4-4-49P-TUSB546]  21.42 23.08 90 bottom
UG1  NL17SZ08DFT2G  [SOT353-1-2_125-65-5P]  244.07 116.48 270 top
UG2  NL17SZ32DFT2G  [SOT353-2_1-65-5P]  234.98 115.63 90 top
UG3  NL17SZ32DFT2G  [SOT353-2_1-65-5P]  237.65 113.25 270 top
UG4  M74VHC1GT32DFT2G  [SOT353-2_1-65-5P]  173.76 162.27 90 bottom
UG5  M74VHC1GT32DFT2G  [SOT353-2_1-65-5P]  169.37 162.04 180 bottom
UG6  U_GPU_GB5_256  [BGA2714-NVIDIA-N20Y-ES-A1]  237.5 146.57 270 bottom
UG7  XXX@VBIOS  [SOP8-5_99-1_27]  271.75 130.03 0 bottom
UG8  NL17SZ08DFT2G  [SOT353-1-2_125-65-5P]  243.51 122.29 90 bottom
UG9  NL17SZ08DFT2G  [SOT353-1-2_125-65-5P]  242.8 118.54 270 bottom
UG10  M74VHC1GT32DFT2G  [SOT353-2_1-65-5P]  267.48 115.95 90 bottom
UG11  M74VHC1GT32DFT2G  [SOT353-2_1-65-5P]  269.9 115.95 90 bottom
VRAM1  MT61K256M32JE-16:A  [BGA180-MICRON-MT61K256M32]  223.5 176.82 270 bottom
VRAM2  MT61K256M32JE-16:A  [BGA180-MICRON-MT61K256M32]  238 176.82 90 bottom
VRAM3  MT61K256M32JE-16:A  [BGA180-MICRON-MT61K256M32]  252.5 176.82 270 bottom
VRAM4  MT61K256M32JE-16:A  [BGA180-MICRON-MT61K256M32]  207.25 161.57 180 bottom
VRAM5  MT61K256M32JE-16:A  [BGA180-MICRON-MT61K256M32]  267.75 160.57 0 bottom
VRAM6  MT61K256M32JE-16:A  [BGA180-MICRON-MT61K256M32]  207.25 147.07 0 bottom
VRAM7  MT61K256M32JE-16:A  [BGA180-MICRON-MT61K256M32]  267.75 146.07 180 bottom
VRAM8  MT61K256M32JE-16:A  [BGA180-MICRON-MT61K256M32]  207.25 132.57 180 bottom
Y1  25MHZ/10ppm  [XTL-3_2X2_5-2_2X1_7]  35.94 98.9 180 top
Y2  38.4MHZ/8ppm  [XTL-2X1_6-1_4X1_1-4P]  210.34 84.37 180 top
Y3  25MHZ/10ppm  [XTL-3_2X2_5-2_2X1_7]  31.37 81.62 180 top
Y4  32.768KHZ/20ppm  [XTL-3_2X1_5-2_5-SMT]  217.26 48.23 180 bottom
YG1  27MHZ/10ppm  [XTL-3_2X2_5-2_2X1_6-0_9H]  257.59 120.56 180 bottom

## Library data of the parts
C1-C34 C36-C38 C40-C43 C45-C84 C86-C88 C91-C94 C97 C101-C108 C113-C115 C118 C119 C122-C125 C129 C131-C152 C154-C156 C158 C160 C163-C166 C170-C173 C175 C177-C180 C182 C184 C187 C189-C193 C199 C203 C205-C207 C209-C217 C219-C223 C225 C227-C233 C235-C250 C252-C254 C258-C260 C262-C267 C269 C270 C272-C279 C281 C285 C286 C288 C289 C293-C296 C298-C303 C305 C307 C308 C310-C312 C314 C318-C323 C325-C333 C335 C336 C340-C343 C345-C347 C350-C378 C380-C384 C386-C407 C409-C456 C460-C468 C470-C615 C617-C620 C622-C631 C634-C643 C646 C647 C649-C652 C655-C659 C664-C699 C703 C705-C707 C709 C711 C713 C714 C716 C719-C721 C723 C725-C740 C745 C748 C749 C755 C757-C821 C823-C868 C871-C875 CG1-CG4 CG6-CG44 CG46-CG101 CG103 CG104 CG106-CG108 CG110-CG120 CG122-CG156 CG158-CG163 CG165 CG167 CG172-CG178 CG182-CG192 CG194 CG196-CG200 CG203-CG208 CG212 CG213 CG216-CG222 CG224 CG230-CG237 CG245-CG251 CG253 CG254 CG260-CG268 CG275-CG278 CG280-CG298 CG300-CG305 CG307-CG321 CG323-CG327 CG330-CG334 CG336-CG342 CG344-CG355 CG357-CG360 CG362-CG368 CG370-CG391 CG393 CG400 CG401 CG403 CG405 CG408-CG438 CG444-CG451 CG454-CG522 CG528 EC1 PC2 PC3 PC5-PC17 PC19 PC20 PC22-PC26 PC29 PC40-PC49 PC53-PC60 PC69-PC97 PC99-PC102 PC116 PC120-PC155 PC157-PC174 PC176 PC178-PC181 PC183 PC185 PC187 PC188 PC191-PC195 PC200-PC206 PC210 PC216 PC219 PC225-PC227 PC229 PC237 PC242 PC244 PC254 PC258 PC260 PC266 PC267 PC269 PC272-PC281 PC284 PC285 PC287-PC291 PC294 PC295 PC297-PC303 PC305 PC306 PC309 PC311-PC313 PC316-PC318 PC320 PC323-PC329 PC332-PC360 PC362-PC376 PC378-PC382 PC384-PC397 PC400-PC403 PC406 PC407 PC409-PC421 PC425-PC466 PC468-PC483 PC487 PC494 PC504 PC505 PC510 PC511 PC513 PC516-PC527 = CAP_NON-POL_BGM
C35 C39 C44 C85 C89 C90 C98-C100 C109-C112 C120 C121 C126-C128 C130 C153 C157 C159 C161 C162 C167-C169 C174 C176 C181 C183 C185 C186 C188 C194-C198 C200-C202 C204 C208 C224 C226 C251 C255-C257 C261 C268 C271 C280 C282-C284 C287 C290-C292 C297 C304 C306 C309 C313 C315-C317 C324 C334 C337-C339 C344 C348 C349 C379 C385 C457-C459 C469 C616 C621 C632 C633 C644 C645 C648 C653 C654 C660-C663 C700-C702 C704 C708 C710 C712 C715 C717 C718 C722 C724 C741-C744 C746 C747 C750-C754 C756 CG5 CG45 CG102 CG105 CG109 CG121 CG157 CG164 CG166 CG168 CG169 CG179-CG181 CG193 CG195 CG209-CG211 CG214 CG215 CG223 CG225-CG229 CG238-CG244 CG252 CG255-CG259 CG269-CG274 CG279 CG299 CG306 CG322 CG328 CG329 CG335 CG343 CG356 CG361 CG369 CG392 CG394-CG399 CG402 CG404 CG406 CG407 CG439-CG443 CG452 CG453 CG523-CG527 PC1 PC4 PC18 PC21 PC27 PC28 PC30-PC35 PC50-PC52 PC98 PC175 PC177 PC182 PC184 PC186 PC189 PC190 PC196-PC199 PC207-PC209 PC211-PC215 PC217 PC218 PC220-PC224 PC228 PC230-PC236 PC238 PC239 PC241 PC243 PC245-PC253 PC256 PC257 PC259 PC261-PC265 PC268 PC270 PC271 PC282 PC283 PC286 PC292 PC293 PC296 PC304 PC307 PC308 PC310 PC314 PC315 PC321 PC322 PC330 PC331 PC361 PC377 PC383 PC398 PC399 PC404 PC405 PC408 PC422-PC424 PC467 PC484-PC486 PC489 PC491-PC493 PC495-PC503 PC506 PC508 PC512 PC514 PC515 = CAP NON-POL_BGM
C95 C96 C116 C117 C218 C234 PC36-PC39 PC61-PC68 PC103-PC115 PC117-PC119 PC156 PC255 PC319 PC488 PC490 PC507 PC509 = CAP_POL_BGM
C408 = C
C822 = CAP_NON-POL_V1_BGM
CG170 CG171 CG201 CG202 PC240 = CAP POL_BGM
CN1 = FFCFPC_26P_BGM
CN2 = Housing_40P_6fixP_BGM
CN3 CN8 = HEADER_50273-00471-001_4P_BGM
CN4 = HEADER_10P_2F_BGM
CN5 CN9 = USB3_1_24P_8F_V3_BGM
CN6 CN13 = NGFF_79P_MKEY_NAME_BGM
CN7 = NGFF_79P_BKEY_NASB0_BGM
CN10 = FFCFPC_45P_R_V2_BGM
CN11 CN16 = Header_2P_V2_BGM
CN12 = NGFF_79P_EKEY_NAME_BGM
CN14 CN22 = FFCFPC_6P_BGM
CN15 = USB3_9P_4fix_V2_BGM
CN17 = FFCFPC_10P_2F_BGM
CN18 = Housing_20P_FIX6P_BGM
CN19 = FFCFPC_12P_V1_BGM
CN20 = HEADER_4P_2F_BGM
CN21 = Header_8P_2fix_BGM
CN23 = HDMI_19P_FD_4fix_D3_BGM
CN24 = mDP_20P_6fix_V2_BGM
D1-D5 D7-D9 D11-D14 D16 D17 D19 D23 D24 D27-D30 D32 D33 D35 D38 D46-D49 D53 D54 D61 D63-D69 D73-D80 = TVS_DIODE_BGM
D6 D10 D22 D57-D60 D72 = TVS_DIODE_DUAL_BGM
D15 D18 D20 D21 D25 D26 D31 D34 D36 D37 D39-D45 D50-D52 D56 D70 DG2-DG6 PD2 = Schottky_DIODE_BGM
D55 D62 PD4-PD7 = ZENER_DIODE_BGM
D71 = DIODE SCHOTTKY_1
DG1 = BAT54A_BGM
ESD1 = AZ1045-04F_BGM
HOLE1-HOLE13 HOLE15-HOLE22 HOLE24-HOLE50 = 3x2_1.1
J1 = SIMCARD_7P_4F_V3_BGM
J2 J3 = RF_4P_V2_BGM
J4 J5 = OPEN
JDIM1 JDIM2 = DDR4_DIMM_260P_BGM
L1 L4 L5 L7 L8 L11-L14 L19-L22 LG1 LG2 LG6-LG8 = BEAD_BGM
L2 L6 PL1-PL6 PL13 PL22 PL23 PL27 = INDUCTOR_BGM
L3 = BW_BGM
L9 L10 L17 L18 PJ5 PJ6 PJ12 PR1-PR122 PR124-PR140 PR143-PR301 PR303-PR436 PR438-PR473 PR475-PR480 PR485 PR500-PR518 PR526 PR528-PR532 PR534-PR620 PR622 PR623 PR625-PR630 PR632-PR671 PR6036-PR6041 R1-R139 R141-R156 R158-R279 R281-R291 R293-R366 R369-R378 R380-R489 R491-R530 R532-R809 R811-R831 R833-R920 R922-R955 R957-R992 R994 R996-R1010 R1012-R1234 RG1-RG182 RS1 RS2 = RES_BGM
L15 L16 = RFL11T2SA0BR_BGM
LED1-LED7 = LED_6P_BRG_BGM
PD1 = DIODE_BGM
PD3 = BAT54C_BGM
PJ1-PJ4 PJ7 PJ10 PJ11 PJ13-PJ18 PJ20 PR437 PR474 PR486 PR487 PR631 R531 R956 = R_Current_SEN_BGM
PJ8 PJ9 = DCJACK_4P_6F+2_BGM
PJ19 = Header_10P_2fix_BGM
PL7-PL12 PL14-PL21 = INDUCTOR_V01_BGM
PL24-PL26 = TEMPOBJ_0
PQ1-PQ4 PQ6-PQ10 PQ12 PQ13 PQ15 PQ17-PQ20 PQ22-PQ25 PQ28 PQ30 PQ33 PQ35 PQ38-PQ40 PQ51 PQ53-PQ57 PQ61-PQ64 PQ68 PQ73 Q4 Q6-Q9 Q13 Q14 Q17 Q21-Q28 Q30 Q32 Q36 Q38 Q43 Q45 Q46 Q48 Q50 Q52 Q55-Q57 Q59 Q63 Q64 Q66-Q70 Q76 Q80 Q82 Q86 Q95 Q98 Q100 Q102 Q105 Q107 Q109 Q112-Q115 Q121-Q124 Q127 QG9 QG13 QG16 QG18-QG20 QG22-QG25 = MOS-N_3P_ESD_BGM
PQ5 PQ11 Q11 Q15 Q19 Q33 Q35 Q42 Q54 Q99 Q101 Q116 Q118-Q120 QG3-QG7 QG17 = NPN_BGM
PQ14 PQ69 PQ71 = MOS-N_8P_V3_BGM
PQ16 PQ26 PQ27 PQ34 PQ72 Q12 Q84 Q93 Q111 Q128 = DTC144EU_BGM
PQ21 PQ29 Q94 = MOS-N_3P_ESD_V3_BGM
PQ36 PQ58 PQ59 = MOS-N_8P_ESD_BGM
PQ37 PQ70 Q5 Q18 Q41 Q58 Q60 Q61 Q77 Q85 Q125 = MOS-P_3P_BGM
PQ41-PQ44 PQ52 = MOS-N-Dual_10P_BGM
PQ45-PQ50 PQ60 = MOS-P_8P_V1_BGM
PQ65-PQ67 = MOS-N-Dual_9P_BGM
PR123 PR142 PR483 PR484 PR488-PR499 PR519-PR525 PR527 PR533 PR624 R832 R921 = SHORTPAD_V01_BGM
PR141 PR621 R993 R995 R1011 = SHORTPAD_BGM
PR481 PR482 = Thermistor_BGM
PU1 = AS393MTR-G1_BGM
PU2 = US5650_0
PU3 U12 U25 U28 U30 U34 U39-U41 U44 = MC74VHC1G08DFT2G_5P_BGM
PU4 = NCP81269MNTXG_20P_V2_BGM_0
PU5 PU6 = MAX8731EEI_4
PU7 PU8 = SY8386RHC_16P_BGM_0
PU9 = SY9329C_4
PU10 = UP9512PQGJ_40P_V2_BGM
PU11-PU13 PU17 = JW7110DFNCTRPBF_14P_BGM_4
PU14 = M5671RE1U_BGM
PU15 = TPS51225RUKR_BGM
PU16 = M74VHC1GT08DFT2G_5P_BGM
PU18 = BQ24780SRUYR_BGM_0
PU19 = RT8816AGQW_BGM
PU20 = NCP81305MNTXG_40P_V2_BGM
PU21-PU26 = NCP302045MNTWG_33P_BGM_0
PU27 = G708T1U_BGM
PU28 = G9336ADJTP1U_BGM
PU29-PU36 = QD9619AQR1_39P_V2_BGM
PU37 = G5719CTB1U_BGM
PU38 = RT8231BGQW_BGM
PU39 = AOZ2260QI-18_BGM_0
Q1 Q3 Q74 Q78 Q79 = MOS-P_Dual_6P_BGM
Q2 Q10 Q20 Q29 Q34 Q37 Q39 Q40 Q47 Q49 Q51 Q53 Q62 Q65 Q71-Q73 Q75 Q81 Q87 Q88 Q96 Q103 Q106 Q108 Q117 Q126 QG1 QG2 QG8 QG10-QG12 QG14 QG15 QG21 = MOS-N_Dual_6P_ESD_BGM
Q16 Q97 = NPN_0
Q31 Q83 = 2N7002
Q89 Q91 Q104 Q110 = MOS-N_3P_BGM
R367 R368 R379 R490 = RES_B_BGM
R810 = R_3
RV1-RV4 = Varistor_BGM
S1-S15 = HOLE 1_1
SW1 = SW_4P_BGM
SW2 = SW_6P_BGM
T1-T6 TP1-TP46 TP48-TP183 TPG1-TPG60 TPS1-TPS3 = TP_BGM
U1 = 6K5130UA0_32P_BGM
U2 U3 = 7SH08_0
U4 = SN74LVC2G53DCUR_8P_BGM
U5 U13 = TPS22924CYZPR_6P_BGM
U6 U7 U52 = SLGC55544CVTR_16P_BGM
U8 U15 = ESP32-D0WDQ6_12P_BGM
U9 U16 = Burnside_Bridge_105P_BGM
U10 = W25Q80DVSNIG_8P_BGM
U11 = TPS65994ACYBGR_50P_BGM
U14 = CAT24C256WI-GT3_8P_BGM
U17 U19 = G2129BAJ1U_8P_BGM_4
U18 = NPCT750AAAYX_32P_BGM
U20 = ALC289-CG_48P_BGM
U21 = ALC1006-VB-CGT_48P_BGM
U22 U26 = NL17SZ08DFT2G_5P_BGM
U23 = IT5571E-I-128/CX_128P_BGM: tolerance: AJ055710F01
U24 = PS8811QFN36GTR2-A2_36P_BGM
U27 = PI3HDX12211ZHEX_42P_BGM
U29 = UP7553PMA5-15_BGM
U31 = G5250Q1T73U_BGM
U32 U33 = TVS_AOZ8829DI-03_10P_BGM
U35 U46 = G781_BGM
U36 = PI3DPX8121ZLDEX_40P_BGM
U37 = PI3CH480QEX_16P_BGM
U38 = APL3512ABI-TRG_BGM
U42 = CPU_TGL_H_1787P_Rev1p2_V2_BGM
U43 U45 UG4 UG5 UG10 UG11 = M74VHC1GT32DFT2G_5P_BGM
U49 = PCH_TGL_H_943P_Rev1p3_BGM
U50 U51 = SX9310ICSTRT_9P_BGM
U53 = W25Q256JVEIQ_8P_BGM
U54 = TLV8801DBVR_5P_BGM
U55 = PS8527BTQFN20GTR2-A2_BGM
U56 = TUSB546I_BGM
UG1 UG8 UG9 = Logic_AND_BGM
UG2 UG3 = 74LVC1G32GW_5P_BGM
UG6 = U_GPU_GB5_256
UG7 = IC
VRAM1-VRAM8 = GDDR6_180P_BGM
Y1 Y3 = CRYSTAL2_4
Y2 YG1 = CRYSTAL_4P_BGM
Y4 = CRYSTAL_2P_BGM

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
2D-BARCODE-8X8-S
  round 0.991 smd: 1(7,-4)
50224-00801-001-8P-L
  rect 0.61x1.549 smd: 1(-3.5,3.875) 2(-2.5,3.875) 3(-1.5,3.875) 4(-0.5,3.875) 5(0.5,3.875) 6(1.5,3.875) 7(2.5,3.875) 8(3.5,3.875)
  rect 1.194x1.803 smd: 9(-4.8,0) 10(4.8,0)
50224-01001-001-10P-L
  rect 0.61x1.549 smd: 1(-4.5,3.875) 2(-3.5,3.875) 3(-2.5,3.875) 4(-1.5,3.875) 5(-0.5,3.875) 6(0.5,3.875) 7(1.5,3.875) 8(2.5,3.875) 9(3.5,3.875) 10(4.5,3.875)
  rect 1.194x1.803 smd: 11(-5.8,0) 12(5.8,0)
50271-0040N-V01-4P-L
  rect 0.787x1.6 smd: 1(-1.875,2.9) 2(-0.625,2.9) 3(0.625,2.9) 4(1.875,2.9)
  rect 2.108x2.997 smd: 5(-4.425,0) 6(4.425,0)
50273-0020N-V09-2P-L
  rect 0.787x1.6 smd: 1(-0.625,2.9) 2(0.625,2.9)
  rect 2.108x2.997 smd: 3(-3.175,0) 4(3.175,0)
50273-00604-V09-6P-L
  rect 0.787x1.6 smd: 1(-3.125,2.9) 2(-1.875,2.9) 3(-0.625,2.9) 4(0.625,2.9) 5(1.875,2.9) 6(3.125,2.9)
  rect 2.108x2.997 smd: 7(-5.675,0) 8(5.675,0)
51619-0260N-001-26P-L
  rect 0.305x1.295 smd: 1(-6.25,2.8) 2(-5.75,2.8) 3(-5.25,2.8) 4(-4.75,2.8) 5(-4.25,2.8) 6(-3.75,2.8) 7(-3.25,2.8) 8(-2.75,2.8) 9(-2.25,2.8) 10(-1.75,2.8) 11(-1.25,2.8) 12(-0.75,2.8) 13(-0.25,2.8) 14(0.25,2.8) 15(0.75,2.8) 16(1.25,2.8) 17(1.75,2.8) 18(2.25,2.8) 19(2.75,2.8) 20(3.25,2.8) 21(3.75,2.8) 22(4.25,2.8) 23(4.75,2.8) 24(5.25,2.8) 25(5.75,2.8) 26(6.25,2.8)
  rect 1.803x1.397 smd: 27(-7.9,0) 28(7.9,0)
51625-01201-001-12P-L
  rect 0.305x0.838 smd: 1(-2.75,3.555) 2(-2.25,3.555) 3(-1.75,3.555) 4(-1.25,3.555) 5(-0.75,3.555) 6(-0.25,3.555) 7(0.25,3.555) 8(0.75,3.555) 9(1.25,3.555) 10(1.75,3.555) 11(2.25,3.555) 12(2.75,3.555)
  rect 0.991x1.448 smd: 13(-4.54,0) 14(4.54,0)
51653-0100N-V01-10P-L
  rect 0.305x1.295 smd: 1(-4.5,2.65) 2(-3.5,2.65) 3(-2.5,2.65) 4(-1.5,2.65) 5(-0.5,2.65) 6(0.5,2.65) 7(1.5,2.65) 8(2.5,2.65) 9(3.5,2.65) 10(4.5,2.65)
  rect 1.803x1.397 smd: 11(-6.65,0) 12(6.65,0)
ANTENNA-20449-001E-4P
  rect 0.61x0.559 smd: 1(0,-0.975)
  custom 0.145x0.145 smd: 2(0.96,0) 3(-0.96,0)
  rect 0.508x0.508 smd: 4(0,1)
BGA6-TEXAS-CD3271-6P
  round 0.305 smd: A1(-0.5,-0.25) A2(-0.5,0.25) B1(0,-0.25) B2(0,0.25) C1(0.5,-0.25) C2(0.5,0.25)
BGA9-SEMTECH-SX9310-0_5S
  round 0.254 smd: A1(-0.4,-0.4) A2(-0.4,0) A3(-0.4,0.4) B1(0,-0.4) B2(0,0) B3(0,0.4) C1(0.4,-0.4) C2(0.4,0) C3(0.4,0.4)
BGA50-TEXAS-TPS65994-NHDI
  round 0.254 smd: A1(-1.4,-1.4) A2(-1.4,-1) A7(-1.4,1) A8(-1.4,1.4) B2(-1,-1) B3(-1,-0.6) B4(-1,-0.2) B5(-1,0.2) B6(-1,0.6) B7(-1,1) B8(-1,1.4) C2(-0.6,-1) C6(-0.6,0.6) C7(-0.6,1) C8(-0.6,1.4) D2(-0.2,-1) D7(-0.2,1) D8(-0.2,1.4) E2(0.2,-1) E7(0.2,1) E8(0.2,1.4) F2(0.6,-1) F6(0.6,0.6) F7(0.6,1) F8(0.6,1.4) G1(1,-1.4) G2(1,-1) G3(1,-0.6) G4(1,-0.2) G5(1,0.2) G6(1,0.6) G7(1,1) G8(1,1.4) H1(1.4,-1.4) H2(1.4,-1) H7(1.4,1) H8(1.4,1.4)
  oval 0.254x0.164 smd: A3(-1.4,-0.6) A4(-1.4,-0.2) A5(-1.4,0.2) A6(-1.4,0.6) H3(1.4,-0.6) H4(1.4,-0.2) H5(1.4,0.2) H6(1.4,0.6)
  oval 0.164x0.254 smd: B1(-1,-1.4) C1(-0.6,-1.4) D1(-0.2,-1.4) E1(0.2,-1.4) F1(0.6,-1.4)
BGA105-INTEL-DELTABRIDGE-0_5S
  oval 0.178x0.33 smd: A1(-2.53,-2.53) A12(-2.53,2.53) B1(-2.07,-2.53) B12(-2.07,2.53) C1(-1.61,-2.53) C12(-1.61,2.53) D1(-1.15,-2.53) D12(-1.15,2.53) E1(-0.69,-2.53) E12(-0.69,2.53) F1(-0.23,-2.53) F12(-0.23,2.53) G1(0.23,-2.53) G12(0.23,2.53) H1(0.69,-2.53) H12(0.69,2.53) J1(1.15,-2.53) J12(1.15,2.53) K1(1.61,-2.53) K12(1.61,2.53) L1(2.07,-2.53) L12(2.07,2.53) M1(2.53,-2.53) M12(2.53,2.53)
  oval 0.33x0.178 smd: A2(-2.53,-2.07) A3(-2.53,-1.61) A4(-2.53,-1.15) A5(-2.53,-0.69) A6(-2.53,-0.23) A7(-2.53,0.23) A8(-2.53,0.69) A9(-2.53,1.15) A10(-2.53,1.61) A11(-2.53,2.07) M2(2.53,-2.07) M3(2.53,-1.61) M4(2.53,-1.15) M5(2.53,-0.69) M6(2.53,-0.23) M7(2.53,0.23) M8(2.53,0.69) M9(2.53,1.15) M10(2.53,1.61) M11(2.53,2.07)
  round 0.229 smd: B2(-2.07,-2.07) B3(-2.07,-1.61) B4(-2.07,-1.15) B5(-2.07,-0.69) B6(-2.07,-0.23) B7(-2.07,0.23) B8(-2.07,0.69) B9(-2.07,1.15) B10(-2.07,1.61) B11(-2.07,2.07) C2(-1.61,-2.07) C3(-1.3,-1.3) C5(-1.3,-0.65) C6(-1.3,0) C7(-1.3,0.65) C9(-1.3,1.3) C11(-1.61,2.07) D2(-1.15,-2.07) D11(-1.15,2.07) E2(-0.69,-2.07) E3(-0.65,-1.3) E5(-0.65,-0.65) E6(-0.65,0) E7(-0.65,0.65) E9(-0.65,1.3) E11(-0.69,2.07) F2(-0.23,-2.07) F3(0,-1.3) F5(0,-0.65) F6(0,0) F7(0,0.65) F9(0,1.3) F11(-0.23,2.07) G2(0.23,-2.07) G3(0.65,-1.3) G5(0.65,-0.65) G6(0.65,0) G7(0.65,0.65) G9(0.65,1.3) G11(0.23,2.07) H2(0.69,-2.07) H11(0.69,2.07) J2(1.15,-2.07) J3(1.3,-1.3) J5(1.3,-0.65) J6(1.3,0) J7(1.3,0.65) J9(1.3,1.3) J11(1.15,2.07) K2(1.61,-2.07) K11(1.61,2.07) L2(2.07,-2.07) L3(2.07,-1.61) L4(2.07,-1.15) L5(2.07,-0.69) L6(2.07,-0.23) L7(2.07,0.23) L8(2.07,0.69) L9(2.07,1.15) L10(2.07,1.61) L11(2.07,2.07)
BGA180-MICRON-MT61K256M32
  round 0.356 smd: A1(-6.375,-4.875) A2(-6.375,-4.125) A3(-6.375,-3.375) A4(-6.375,-2.625) A5(-6.375,-1.875) A10(-6.375,1.875) A11(-6.375,2.625) A12(-6.375,3.375) A13(-6.375,4.125) A14(-6.375,4.875) B1(-5.625,-4.875) B2(-5.625,-4.125) B3(-5.625,-3.375) B4(-5.625,-2.625) B5(-5.625,-1.875) B10(-5.625,1.875) B11(-5.625,2.625) B12(-5.625,3.375) B13(-5.625,4.125) B14(-5.625,4.875) C1(-4.875,-4.875) C2(-4.875,-4.125) C3(-4.875,-3.375) C4(-4.875,-2.625) C5(-4.875,-1.875) C10(-4.875,1.875) C11(-4.875,2.625) C12(-4.875,3.375) C13(-4.875,4.125) C14(-4.875,4.875) D1(-4.125,-4.875) D2(-4.125,-4.125) D3(-4.125,-3.375) D4(-4.125,-2.625) D5(-4.125,-1.875) D10(-4.125,1.875) D11(-4.125,2.625) D12(-4.125,3.375) D13(-4.125,4.125) D14(-4.125,4.875) E1(-3.375,-4.875) E2(-3.375,-4.125) E3(-3.375,-3.375) E4(-3.375,-2.625) E5(-3.375,-1.875) E10(-3.375,1.875) E11(-3.375,2.625) E12(-3.375,3.375) E13(-3.375,4.125) E14(-3.375,4.875) F1(-2.625,-4.875) F2(-2.625,-4.125) F3(-2.625,-3.375) F4(-2.625,-2.625) F5(-2.625,-1.875) F10(-2.625,1.875) F11(-2.625,2.625) F12(-2.625,3.375) F13(-2.625,4.125) F14(-2.625,4.875) G1(-1.875,-4.875) G2(-1.875,-4.125) G3(-1.875,-3.375) G4(-1.875,-2.625) G5(-1.875,-1.875) G10(-1.875,1.875) G11(-1.875,2.625) G12(-1.875,3.375) G13(-1.875,4.125) G14(-1.875,4.875) H1(-1.125,-4.875) H2(-1.125,-4.125) H3(-1.125,-3.375) H4(-1.125,-2.625) H5(-1.125,-1.875) H10(-1.125,1.875) H11(-1.125,2.625) H12(-1.125,3.375) H13(-1.125,4.125) H14(-1.125,4.875) J1(-0.375,-4.875) J2(-0.375,-4.125) J3(-0.375,-3.375) J4(-0.375,-2.625) J5(-0.375,-1.875) J10(-0.375,1.875) J11(-0.375,2.625) J12(-0.375,3.375) J13(-0.375,4.125) J14(-0.375,4.875) K1(0.375,-4.875) K2(0.375,-4.125) K3(0.375,-3.375) K4(0.375,-2.625) K5(0.375,-1.875) K10(0.375,1.875) K11(0.375,2.625) K12(0.375,3.375) K13(0.375,4.125) K14(0.375,4.875) L1(1.125,-4.875) L2(1.125,-4.125) L3(1.125,-3.375) L4(1.125,-2.625) L5(1.125,-1.875) L10(1.125,1.875) L11(1.125,2.625) L12(1.125,3.375) L13(1.125,4.125) L14(1.125,4.875) M1(1.875,-4.875) M2(1.875,-4.125) M3(1.875,-3.375) M4(1.875,-2.625) M5(1.875,-1.875) M10(1.875,1.875) M11(1.875,2.625) M12(1.875,3.375) M13(1.875,4.125) M14(1.875,4.875) N1(2.625,-4.875) N2(2.625,-4.125) N3(2.625,-3.375) N4(2.625,-2.625) N5(2.625,-1.875) N10(2.625,1.875) N11(2.625,2.625) N12(2.625,3.375) N13(2.625,4.125) N14(2.625,4.875) P1(3.375,-4.875) P2(3.375,-4.125) P3(3.375,-3.375) P4(3.375,-2.625) P5(3.375,-1.875) P10(3.375,1.875) P11(3.375,2.625) P12(3.375,3.375) P13(3.375,4.125) P14(3.375,4.875) R1(4.125,-4.875) R2(4.125,-4.125) R3(4.125,-3.375) R4(4.125,-2.625) R5(4.125,-1.875) R10(4.125,1.875) R11(4.125,2.625) R12(4.125,3.375) R13(4.125,4.125) R14(4.125,4.875) T1(4.875,-4.875) T2(4.875,-4.125) T3(4.875,-3.375) T4(4.875,-2.625) T5(4.875,-1.875) T10(4.875,1.875) T11(4.875,2.625) T12(4.875,3.375) T13(4.875,4.125) T14(4.875,4.875) U1(5.625,-4.875) U2(5.625,-4.125) U3(5.625,-3.375) U4(5.625,-2.625) U5(5.625,-1.875) U10(5.625,1.875) U11(5.625,2.625) U12(5.625,3.375) U13(5.625,4.125) U14(5.625,4.875) V1(6.375,-4.875) V2(6.375,-4.125) V3(6.375,-3.375) V4(6.375,-2.625) V5(6.375,-1.875) V10(6.375,1.875) V11(6.375,2.625) V12(6.375,3.375) V13(6.375,4.125) V14(6.375,4.875)
BGA943-INTEL-TGL-H-PCH
  round 0.305 smd: A2(-11.314,-11.46) A3(-11.314,-10.959) A4(-11.314,-10.459) A46(-11.314,10.459) A47(-11.314,10.959) A48(-11.314,11.46) AA12(-1.354,-6.583) AA13(-1.354,-5.808) AA15(-1.354,-5.034) AA17(-1.354,-4.259) AA18(-1.354,-3.484) AA20(-1.549,-2.324) AA22(-1.549,-1.549) AA23(-1.549,-0.775) AA25(-1.549,0) AA27(-1.549,0.775) AA29(-1.354,1.935) AA30(-1.354,2.71) AA32(-1.354,3.484) AA33(-1.354,4.259) AA35(-1.354,5.034) AA37(-1.354,5.808) AA38(-1.354,6.583) AB20(-0.775,-2.324) AB22(-0.775,-1.549) AB23(-0.775,-0.775) AB25(-0.775,0) AB27(-0.775,0.775) AB28(-0.775,1.549) AC6(-0.579,-9.374) AC8(-0.579,-8.612) AC9(-0.579,-7.85) AC11(-0.579,-7.088) AC12(-0.579,-6.583) AC13(-0.579,-5.808) AC15(-0.579,-5.034) AC17(-0.579,-4.259) AC18(-0.579,-3.484) AC35(-0.579,5.034) AC37(-0.579,5.808) AC38(-0.579,6.583) AC39(-0.579,7.088) AC41(-0.579,7.85) AC42(-0.579,8.612) AC44(-0.579,9.374) AD6(0,-9.374) AD8(0,-8.612) AD9(0,-7.85) AD11(0,-7.088) AD12(0,-6.583) AD13(0,-5.808) AD15(0,-5.034) AD17(0,-4.259) AD18(0,-3.484) AD20(0,-2.324) AD22(0,-1.549) AD23(0,-0.775) AD25(0,0) AD27(0,0.775) AD28(0,1.549) AD35(0,5.034) AD37(0,5.808) AD38(0,6.583) AD39(0,7.088) AD41(0,7.85) AD42(0,8.612) AD44(0,9.374) AE6(0.579,-9.374) AE8(0.579,-8.612) AE9(0.579,-7.85) AE11(0.579,-7.088) AE12(0.579,-6.583) AE13(0.579,-5.808) AE15(0.579,-5.034) AE17(0.579,-4.259) AE18(0.579,-3.484) AE35(0.579,5.034) AE37(0.579,5.808) AE38(0.579,6.583) AE39(0.579,7.088) AE41(0.579,7.85) AE42(0.579,8.612) AE44(0.579,9.374) AF20(0.775,-2.324) AF22(0.775,-1.549) AF23(0.775,-0.775) AF25(0.775,0) AF27(0.775,0.775) AF28(0.775,1.549) AG12(1.354,-6.583) AG13(1.354,-5.808) AG15(1.354,-5.034) AG17(1.354,-4.259) AG18(1.354,-3.484) AG20(1.549,-2.324) AG22(1.549,-1.549) AG23(1.549,-0.775) AG25(1.549,0) AG27(1.549,0.775) AG28(1.549,1.549) AG35(1.354,5.034) AG37(1.354,5.808) AG38(1.354,6.583) AH9(2.205,-7.919) AH11(2.014,-7.18) AH12(2.218,-6.583) AH13(2.218,-5.808) AH15(2.218,-5.034) AH17(2.218,-4.259) AH18(2.218,-3.484) AH35(2.218,5.034) AH37(2.218,5.808) AH38(2.218,6.583) AH39(2.014,7.18) AH41(2.205,7.919) AJ6(2.586,-9.397) AJ8(2.395,-8.658) AJ20(2.324,-2.324) AJ22(2.324,-1.549) AJ23(2.324,-0.775) AJ25(2.324,0) AJ27(2.324,0.775) AJ28(2.324,1.549) AJ42(2.395,8.658) AJ44(2.586,9.397) AK11(3.259,-7.181) AK12(3.083,-6.583) AK13(3.083,-5.808) AK15(3.083,-5.034) AK17(3.083,-4.259) AK18(3.083,-3.484) AK21(2.904,-2.218) AK22(2.904,-1.354) AK24(2.904,-0.579) AK25(2.904,0) AK26(2.904,0.579) AK28(2.904,1.354) AK29(3.083,1.935) AK30(3.083,2.71) AK32(3.083,3.484) AK33(3.083,4.259) AK35(3.083,5.034) AK37(3.083,5.808) AK38(3.083,6.583) AK39(3.259,7.181) AL9(3.495,-7.914) AL19(3.679,-3.083) AL21(3.679,-2.218) AL22(3.679,-1.354) AL24(3.679,-0.579) AL25(3.679,0) AL26(3.679,0.579) AL28(3.679,1.354) AL29(3.679,2.218) AL31(3.679,3.083) AL41(3.495,7.914) AM7(4.224,-9.295) AM8(3.843,-8.635) AM12(3.998,-6.583) AM13(3.948,-5.808) AM15(3.948,-5.034) AM17(3.948,-4.259) AM33(3.948,4.259) AM35(3.948,5.034) AM37(3.948,5.808) AM38(3.998,6.583) AM42(3.843,8.635) AM43(4.224,9.295) AN11(4.656,-7.181) AN17(4.454,-3.948) AN19(4.454,-3.083) AN21(4.454,-2.218) AN22(4.454,-1.354) AN24(4.454,-0.579) AN25(4.454,0) AN26(4.454,0.579) AN28(4.454,1.354) AN29(4.454,2.218) AN31(4.454,3.083) AN33(4.454,3.948) AN39(4.656,7.181) AP9(4.968,-7.914) AP12(4.813,-6.583) AP13(4.813,-5.808) AP15(4.813,-5.034) AP17(5.228,-3.948) AP19(5.228,-3.083) AP21(5.228,-2.218) AP22(5.228,-1.354) AP24(5.228,-0.579) AP25(5.228,0) AP26(5.228,0.579) AP28(5.228,1.354) AP29(5.228,2.218) AP31(5.228,3.083) AP33(5.228,3.948) AP35(4.813,5.034) AP37(4.813,5.808) AP38(4.813,6.583) AP41(4.968,7.914) AR7(5.659,-9.295) AR8(5.469,-8.508) AR11(5.773,-7.181) AR39(5.773,7.181) AR42(5.469,8.508) AR43(5.659,9.295) AT12(5.867,-6.583) AT13(5.867,-5.808) AT15(5.867,-5.034) AT17(6.003,-3.948) AT19(6.003,-3.083) AT21(6.003,-2.218) AT22(6.003,-1.354) AT24(6.003,-0.579) AT25(6.003,0) AT26(6.003,0.579) AT28(6.003,1.354) AT29(6.003,2.218) AT31(6.003,3.083) AT33(6.003,3.948) AT35(5.867,5.034) AT37(5.867,5.808) AT38(5.867,6.583) AU8(6.764,-8.597) AU9(6.416,-7.914) AU14(6.757,-5.748) AU16(6.719,-4.656) AU19(6.68,-3.259) AU21(6.679,-2.014) AU24(6.588,-0.579) AU25(6.588,0) AU26(6.588,0.579) AU29(6.679,2.014) AU31(6.68,3.259) AU34(6.719,4.656) AU36(6.757,5.748) AU41(6.416,7.914) AU42(6.764,8.597) AV7(7.094,-9.295) AV11(6.975,-7.079) AV39(6.975,7.079) AV43(7.094,9.295) AW9(7.577,-7.824) AW11(7.509,-7.262) AW13(7.49,-6.01) AW15(7.452,-4.892) AW18(7.413,-3.495) AW21(7.419,-2.205) AW24(7.35,-0.579) AW25(7.35,0) AW26(7.35,0.579) AW29(7.419,2.205) AW32(7.413,3.495) AW35(7.452,4.892) AW37(7.49,6.01) AW39(7.509,7.262) AW41(7.577,7.824) AY7(8.203,-9.13) AY8(7.898,-8.533) AY12(8.135,-6.485) AY15(8.135,-5.24) AY17(8.135,-3.843) AY20(8.158,-2.395) AY24(8.112,-0.579) AY25(8.112,0) AY26(8.112,0.579) AY30(8.158,2.395) AY33(8.135,3.843) AY35(8.135,5.24) AY38(8.135,6.485) AY42(7.898,8.533) AY43(8.203,9.13) B1(-10.96,-11.814) B2(-10.83,-11.33) B4(-10.878,-10.709) B46(-10.878,10.709) B48(-10.83,11.33) B49(-10.96,11.814) BA7(8.706,-9.088) BA9(8.774,-8.024) BA11(8.795,-6.866) BA14(8.795,-5.621) BA17(8.795,-4.224) BA33(8.795,4.224) BA36(8.795,5.621) BA39(8.795,6.866) BA41(8.774,8.024) BA43(8.706,9.088) BB6(9.254,-9.634) BB8(9,-8.589) BB20(8.897,-2.586) BB24(8.874,-0.579) BB25(8.874,0) BB26(8.874,0.579) BB30(8.897,2.586) BB42(9,8.589) BB44(9.254,9.634) BD1(9.959,-11.814) BD2(10.196,-11.373) BD4(9.983,-10.474) BD5(10.212,-9.965) BD45(10.212,9.965) BD46(9.983,10.474) BD48(10.196,11.373) BD49(9.959,11.814) BE1(10.459,-11.814) BE3(10.311,-10.86) BE4(10.487,-10.391) BE46(10.487,10.391) BE47(10.311,10.86) BE49(10.459,11.814) BF1(10.96,-11.814) BF2(10.83,-11.33) BF4(10.878,-10.709) BF46(10.878,10.709) BF48(10.83,11.33) BF49(10.96,11.814) BG2(11.314,-11.46) BG3(11.314,-10.959) BG4(11.314,-10.459) BG46(11.314,10.459) BG47(11.314,10.959) BG48(11.314,11.46) C1(-10.459,-11.814) C3(-10.311,-10.86) C4(-10.487,-10.391) C46(-10.487,10.391) C47(-10.311,10.86) C49(-10.459,11.814) D1(-9.959,-11.814) D2(-10.196,-11.373) D4(-9.983,-10.474) D5(-10.212,-9.965) D45(-10.212,9.965) D46(-9.983,10.474) D48(-10.196,11.373) D49(-9.959,11.814) F6(-9.254,-9.634) F8(-9,-8.589) F20(-8.897,-2.586) F24(-8.874,-0.579) F25(-8.874,0) F26(-8.874,0.579) F30(-8.897,2.586) F42(-9,8.589) F44(-9.254,9.634) G7(-8.706,-9.088) G9(-8.774,-8.024) G11(-8.795,-6.866) G14(-8.795,-5.621) G17(-8.795,-4.224) G33(-8.795,4.224) G36(-8.795,5.621) G39(-8.795,6.866) G41(-8.774,8.024) G43(-8.706,9.088) H7(-8.203,-9.13) H8(-7.898,-8.533) H12(-8.135,-6.485) H15(-8.135,-5.24) H17(-8.135,-3.843) H20(-8.158,-2.395) H24(-8.112,-0.579) H25(-8.112,0) H26(-8.112,0.579) H30(-8.158,2.395) H33(-8.135,3.843) H35(-8.135,5.24) H38(-8.135,6.485) H42(-7.898,8.533) H43(-8.203,9.13) J9(-7.577,-7.824) J11(-7.509,-7.262) J13(-7.49,-6.01) J15(-7.452,-4.892) J18(-7.413,-3.495) J21(-7.419,-2.205) J24(-7.35,-0.579) J25(-7.35,0) J26(-7.35,0.579) J29(-7.419,2.205) J32(-7.413,3.495) J35(-7.452,4.892) J37(-7.49,6.01) J39(-7.509,7.262) J41(-7.577,7.824) K7(-7.094,-9.295) K11(-6.975,-7.079) K39(-6.975,7.079) K43(-7.094,9.295) L8(-6.764,-8.597) L9(-6.416,-7.914) L14(-6.757,-5.748) L16(-6.719,-4.656) L19(-6.68,-3.259) L21(-6.679,-2.014) L24(-6.588,-0.579) L25(-6.588,0) L26(-6.588,0.579) L29(-6.679,2.014) L31(-6.68,3.259) L34(-6.719,4.656) L36(-6.757,5.748) L41(-6.416,7.914) L42(-6.764,8.597) M12(-5.867,-6.583) M13(-5.867,-5.808) M15(-5.867,-5.034) M17(-6.003,-3.948) M19(-6.003,-3.083) M21(-6.003,-2.218) M22(-6.003,-1.354) M24(-6.003,-0.579) M25(-6.003,0) M26(-6.003,0.579) M28(-6.003,1.354) M29(-6.003,2.218) M31(-6.003,3.083) M33(-6.003,3.948) M35(-5.867,5.034) M37(-5.867,5.808) M38(-5.867,6.583) N7(-5.659,-9.295) N8(-5.469,-8.508) N11(-5.773,-7.181) N39(-5.773,7.181) N42(-5.469,8.508) N43(-5.659,9.295) P9(-4.968,-7.914) P12(-4.813,-6.583) P13(-4.813,-5.808) P15(-4.813,-5.034) P17(-5.228,-3.948) P19(-5.228,-3.083) P21(-5.228,-2.218) P22(-5.228,-1.354) P24(-5.228,-0.579) P25(-5.228,0) P26(-5.228,0.579) P28(-5.228,1.354) P29(-5.228,2.218) P31(-5.228,3.083) P33(-5.228,3.948) P35(-4.813,5.034) P37(-4.813,5.808) P38(-4.813,6.583) P41(-4.968,7.914) R11(-4.656,-7.181) R17(-4.454,-3.948) R19(-4.454,-3.083) R21(-4.454,-2.218) R22(-4.454,-1.354) R24(-4.454,-0.579) R25(-4.454,0) R26(-4.454,0.579) R28(-4.454,1.354) R29(-4.454,2.218) R31(-4.454,3.083) R33(-4.454,3.948) R39(-4.656,7.181) T7(-4.224,-9.295) T8(-3.843,-8.635) T12(-3.998,-6.583) T13(-3.948,-5.808) T15(-3.948,-5.034) T17(-3.948,-4.259) T33(-3.948,4.259) T35(-3.948,5.034) T37(-3.948,5.808) T38(-3.998,6.583) T42(-3.843,8.635) T43(-4.224,9.295) U9(-3.495,-7.914) U19(-3.679,-3.083) U21(-3.679,-2.218) U22(-3.679,-1.354) U24(-3.679,-0.579) U25(-3.679,0) U26(-3.679,0.579) U28(-3.679,1.354) U29(-3.679,2.218) U31(-3.679,3.083) U41(-3.495,7.914) V11(-3.259,-7.181) V12(-3.083,-6.583) V13(-3.083,-5.808) V15(-3.083,-5.034) V17(-3.083,-4.259) V18(-3.083,-3.484) V21(-2.904,-2.218) V22(-2.904,-1.354) V24(-2.904,-0.579) V25(-2.904,0) V26(-2.904,0.579) V28(-2.904,1.354) V29(-2.904,2.218) V32(-3.083,3.484) V33(-3.083,4.259) V35(-3.083,5.034) V37(-3.083,5.808) V38(-3.083,6.583) V39(-3.259,7.181) W6(-2.586,-9.397) W8(-2.395,-8.658) W20(-2.324,-2.324) W22(-2.324,-1.549) W23(-2.324,-0.775) W25(-2.324,0) W27(-2.324,0.775) W28(-2.324,1.549) W30(-2.324,2.324) W42(-2.395,8.658) W44(-2.586,9.397) Y9(-2.205,-7.919) Y11(-2.014,-7.18) Y12(-2.218,-6.583) Y13(-2.218,-5.808) Y15(-2.218,-5.034) Y17(-2.218,-4.259) Y18(-2.218,-3.484) Y32(-2.218,3.484) Y33(-2.218,4.259) Y35(-2.218,5.034) Y37(-2.218,5.808) Y38(-2.218,6.583) Y39(-2.014,7.18) Y41(-2.205,7.919)
  round 0.279 smd: A5(-11.314,-9.958) A45(-11.314,9.958) BC1(9.458,-11.814) BC49(9.458,11.814) BG5(11.314,-9.958) BG45(11.314,9.958) E1(-9.458,-11.814) E49(-9.458,11.814)
  oval 0.254x0.203 smd: A6(-11.314,-9.399) A44(-11.314,9.399) BG6(11.314,-9.399) BG44(11.314,9.399)
  oval 0.254x0.152 smd: A9(-11.314,-8.294) A13(-11.314,-6.072) A17(-11.314,-3.875) A22(-11.314,-1.678) A25(-11.314,0) A28(-11.314,1.678) A33(-11.314,3.875) A37(-11.314,6.072) A41(-11.314,8.294) B8(-10.816,-8.462) B13(-10.816,-6.265) B17(-10.816,-4.068) B21(-10.816,-1.871) B29(-10.816,1.871) B33(-10.816,4.068) B37(-10.816,6.265) B42(-10.816,8.462) BD8(9.813,-8.411) BD10(10.186,-7.784) BD11(10.059,-7.283) BD12(10.118,-6.76) BD13(9.813,-6.214) BD14(10.186,-5.587) BD15(10.059,-5.086) BD16(10.118,-4.563) BD17(9.813,-4.017) BD18(10.186,-3.39) BD19(10.059,-2.889) BD20(10.118,-2.366) BD21(9.813,-1.82) BD23(10.186,-1.193) BD24(10.059,-0.692) BD25(10.298,0) BD26(10.059,0.692) BD27(10.186,1.193) BD29(9.813,1.82) BD30(10.118,2.366) BD31(10.059,2.889) BD32(10.186,3.39) BD33(9.813,4.017) BD34(10.118,4.563) BD35(10.059,5.086) BD36(10.186,5.587) BD37(9.813,6.214) BD38(10.118,6.76) BD39(10.059,7.283) BD40(10.186,7.784) BD42(9.813,8.411) BE8(10.313,-8.492) BE10(10.687,-7.784) BE11(10.603,-7.123) BE12(10.313,-6.295) BE14(10.687,-5.587) BE15(10.603,-4.926) BE17(10.313,-4.098) BE18(10.687,-3.39) BE20(10.603,-2.729) BE21(10.313,-1.901) BE23(10.687,-1.193) BE24(10.603,-0.532) BE25(10.806,0) BE26(10.603,0.532) BE27(10.687,1.193) BE29(10.313,1.901) BE30(10.603,2.729) BE32(10.687,3.39) BE33(10.313,4.098) BE35(10.603,4.926) BE36(10.687,5.587) BE38(10.313,6.295) BE39(10.603,7.123) BE40(10.687,7.784) BE42(10.313,8.492) BF8(10.816,-8.462) BF13(10.816,-6.265) BF17(10.816,-4.068) BF21(10.816,-1.871) BF29(10.816,1.871) BF33(10.816,4.068) BF37(10.816,6.265) BF42(10.816,8.462) BG9(11.314,-8.294) BG13(11.314,-6.072) BG17(11.314,-3.875) BG22(11.314,-1.678) BG25(11.314,0) BG28(11.314,1.678) BG33(11.314,3.875) BG37(11.314,6.072) BG41(11.314,8.294) C8(-10.313,-8.492) C10(-10.687,-7.784) C11(-10.603,-7.123) C12(-10.313,-6.295) C14(-10.687,-5.587) C15(-10.603,-4.926) C17(-10.313,-4.098) C18(-10.687,-3.39) C20(-10.603,-2.729) C21(-10.313,-1.901) C23(-10.687,-1.193) C24(-10.603,-0.532) C25(-10.806,0) C26(-10.603,0.532) C27(-10.687,1.193) C29(-10.313,1.901) C30(-10.603,2.729) C32(-10.687,3.39) C33(-10.313,4.098) C35(-10.603,4.926) C36(-10.687,5.587) C38(-10.313,6.295) C39(-10.603,7.123) C40(-10.687,7.784) C42(-10.313,8.492) D8(-9.813,-8.411) D10(-10.186,-7.784) D11(-10.059,-7.283) D12(-10.118,-6.76) D13(-9.813,-6.214) D14(-10.186,-5.587) D15(-10.059,-5.086) D16(-10.118,-4.563) D17(-9.813,-4.017) D18(-10.186,-3.39) D19(-10.059,-2.889) D20(-10.118,-2.366) D21(-9.813,-1.82) D23(-10.186,-1.193) D24(-10.059,-0.692) D25(-10.298,0) D26(-10.059,0.692) D27(-10.186,1.193) D29(-9.813,1.82) D30(-10.118,2.366) D31(-10.059,2.889) D32(-10.186,3.39) D33(-9.813,4.017) D34(-10.118,4.563) D35(-10.059,5.086) D36(-10.186,5.587) D37(-9.813,6.214) D38(-10.118,6.76) D39(-10.059,7.283) D40(-10.186,7.784) D42(-9.813,8.411)
  oval 0.152x0.254 smd: AA1(-1.678,-11.814) AA49(-1.678,11.814) AB3(-1.193,-11.187) AB4(-1.193,-10.686) AB46(-1.193,10.686) AB47(-1.193,11.187) AC3(-0.532,-11.103) AC4(-0.692,-10.559) AC46(-0.692,10.559) AC47(-0.532,11.103) AD1(0,-11.814) AD3(0,-11.306) AD4(0,-10.798) AD46(0,10.798) AD47(0,11.306) AD49(0,11.814) AE3(0.532,-11.103) AE4(0.692,-10.559) AE46(0.692,10.559) AE47(0.532,11.103) AF3(1.193,-11.187) AF4(1.193,-10.686) AF46(1.193,10.686) AF47(1.193,11.187) AG1(1.678,-11.814) AG49(1.678,11.814) AH2(1.871,-11.316) AH3(1.901,-10.813) AH4(1.82,-10.313) AH46(1.82,10.313) AH47(1.901,10.813) AH48(1.871,11.316) AJ3(2.729,-11.103) AJ4(2.366,-10.618) AJ46(2.366,10.618) AJ47(2.729,11.103) AK4(2.883,-10.559) AK46(2.883,10.559) AL3(3.39,-11.187) AL4(3.39,-10.686) AL46(3.39,10.686) AL47(3.39,11.187) AM1(3.875,-11.814) AM2(4.068,-11.316) AM3(4.098,-10.813) AM4(4.017,-10.313) AM46(4.017,10.313) AM47(4.098,10.813) AM48(4.068,11.316) AM49(3.875,11.814) AN4(4.563,-10.618) AN46(4.563,10.618) AP3(4.926,-11.103) AP4(5.08,-10.559) AP46(5.08,10.559) AP47(4.926,11.103) AR3(5.587,-11.187) AR4(5.587,-10.686) AR46(5.587,10.686) AR47(5.587,11.187) AT1(6.097,-11.814) AT2(6.265,-11.316) AT4(6.214,-10.313) AT46(6.214,10.313) AT48(6.265,11.316) AT49(6.097,11.814) AU3(6.295,-10.813) AU4(6.76,-10.618) AU46(6.76,10.618) AU47(6.295,10.813) AV3(7.123,-11.103) AV4(7.277,-10.559) AV46(7.277,10.559) AV47(7.123,11.103) AW3(7.784,-11.187) AW4(7.784,-10.686) AW46(7.784,10.686) AW47(7.784,11.187) J3(-7.784,-11.187) J4(-7.784,-10.686) J46(-7.784,10.686) J47(-7.784,11.187) K3(-7.123,-11.103) K4(-7.277,-10.559) K46(-7.277,10.559) K47(-7.123,11.103) L3(-6.295,-10.813) L4(-6.76,-10.618) L46(-6.76,10.618) L47(-6.295,10.813) M1(-6.097,-11.814) M2(-6.265,-11.316) M4(-6.214,-10.313) M46(-6.214,10.313) M48(-6.265,11.316) M49(-6.097,11.814) N3(-5.587,-11.187) N4(-5.587,-10.686) N46(-5.587,10.686) N47(-5.587,11.187) P3(-4.926,-11.103) P4(-5.08,-10.559) P46(-5.08,10.559) P47(-4.926,11.103) R4(-4.563,-10.618) R46(-4.563,10.618) T1(-3.875,-11.814) T2(-4.068,-11.316) T3(-4.098,-10.813) T4(-4.017,-10.313) T46(-4.017,10.313) T47(-4.098,10.813) T48(-4.068,11.316) T49(-3.875,11.814) U3(-3.39,-11.187) U4(-3.39,-10.686) U46(-3.39,10.686) U47(-3.39,11.187) V4(-2.883,-10.559) V46(-2.883,10.559) W3(-2.729,-11.103) W4(-2.366,-10.618) W46(-2.366,10.618) W47(-2.729,11.103) Y2(-1.871,-11.316) Y3(-1.901,-10.813) Y4(-1.82,-10.313) Y46(-1.82,10.313) Y47(-1.901,10.813) Y48(-1.871,11.316)
  round 0.254 smd: AA5(-1.601,-9.856) AA45(-1.601,9.856) AC5(-0.579,-10.06) AC45(-0.579,10.06) AD5(0,-10.06) AD45(0,10.06) AE5(0.579,-10.06) AE45(0.579,10.06) AG5(1.601,-9.856) AG45(1.601,9.856) AJ5(2.274,-10.098) AJ45(2.274,10.098) AK5(2.776,-10.06) AK45(2.776,10.06) AM5(3.799,-9.856) AM45(3.799,9.856) AN5(4.471,-10.098) AN45(4.471,10.098) AP5(4.973,-10.06) AP45(4.973,10.06) AT5(5.996,-9.856) AT45(5.996,9.856) AU5(6.669,-10.098) AU45(6.669,10.098) AV5(7.17,-10.06) AV45(7.17,10.06) AY5(8.193,-9.856) AY45(8.193,9.856) B6(-10.811,-9.397) B44(-10.811,9.397) BA2(8.526,-11.316) BA3(8.594,-10.809) BA5(8.468,-10.304) BA45(8.468,10.304) BA47(8.594,10.809) BA48(8.526,11.316) BB3(9.126,-10.825) BB47(9.126,10.825) BC2(9.315,-11.318) BC9(9.356,-8.193) BC11(9.56,-7.17) BC12(9.598,-6.669) BC13(9.356,-5.996) BC15(9.56,-4.973) BC16(9.598,-4.471) BC17(9.356,-3.799) BC19(9.56,-2.776) BC20(9.598,-2.274) BC22(9.356,-1.601) BC24(9.56,-0.579) BC25(9.56,0) BC26(9.56,0.579) BC28(9.356,1.601) BC30(9.598,2.274) BC31(9.56,2.776) BC33(9.356,3.799) BC34(9.598,4.471) BC35(9.56,4.973) BC37(9.356,5.996) BC38(9.598,6.669) BC39(9.56,7.17) BC41(9.356,8.193) BC48(9.315,11.318) BD7(9.872,-8.914) BD43(9.872,8.914) BE7(10.357,-9.091) BE43(10.357,9.091) BF6(10.811,-9.397) BF44(10.811,9.397) C7(-10.357,-9.091) C43(-10.357,9.091) D7(-9.872,-8.914) D43(-9.872,8.914) E2(-9.315,-11.318) E9(-9.356,-8.193) E11(-9.56,-7.17) E12(-9.598,-6.669) E13(-9.356,-5.996) E15(-9.56,-4.973) E16(-9.598,-4.471) E17(-9.356,-3.799) E19(-9.56,-2.776) E20(-9.598,-2.274) E22(-9.356,-1.601) E24(-9.56,-0.579) E25(-9.56,0) E26(-9.56,0.579) E28(-9.356,1.601) E30(-9.598,2.274) E31(-9.56,2.776) E33(-9.356,3.799) E34(-9.598,4.471) E35(-9.56,4.973) E37(-9.356,5.996) E38(-9.598,6.669) E39(-9.56,7.17) E41(-9.356,8.193) E48(-9.315,11.318) F3(-9.126,-10.825) F47(-9.126,10.825) G2(-8.526,-11.316) G3(-8.594,-10.809) G5(-8.468,-10.304) G45(-8.468,10.304) G47(-8.594,10.809) G48(-8.526,11.316) H5(-8.193,-9.856) H45(-8.193,9.856) K5(-7.17,-10.06) K45(-7.17,10.06) L5(-6.669,-10.098) L45(-6.669,10.098) M5(-5.996,-9.856) M45(-5.996,9.856) P5(-4.973,-10.06) P45(-4.973,10.06) R5(-4.471,-10.098) R45(-4.471,10.098) T5(-3.799,-9.856) T45(-3.799,9.856) V5(-2.776,-10.06) V45(-2.776,10.06) W5(-2.274,-10.098) W45(-2.274,10.098)
  oval 0.203x0.254 smd: BA1(8.327,-11.814) BA49(8.327,11.814) G1(-8.327,-11.814) G49(-8.327,11.814)
