# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+VCCIN_AUX on BOTTOM (solid shape): 171.09,188.13 171.09,188.12 171.13,188.09 171.18,188.08 171.56,188.08 171.61,188.09 171.64,188.12 171.65,188.13 171.67,188.15 173.01,188.15 173.36,187.8 173.36,187.34 173.35,187.28 173.35,187.23 173.35,187.18 173.36,187.12 173.36,186.39 173.35,186.33 173.34,186.27 173.35,186.21 173.36,186.15 173.36,185.71 173.36,185.7 173.32,185.52 173.36,185.33 173.36,185.32 173.36,185.14 173.36,185.12 173.23,184.95 173.19,184.77 173.32,184.45 173.64,184.32 173.75,184.34 173.85,184.38 173.88,184.38 173.91,184.37 174.31,183.97 175.19,183.97 175.46,183.69 175.46,181.55 175.07,181.16 175.01,181.16 174.73,180.88 174.73,180.82 174.59,180.68 174.59,174.66 174.27,174.34 171.28,174.34 170.99,174.05 168.76,174.05 168.46,174.34 168.46,175.21 169.01,175.75 169.01,180.49 168.95,180.55 168.64,180.87 168.64,180.87 168.53,180.97 167.56,180.97 167.3,181.24 167.3,183.37 167.32,183.46 167.33,183.54 167.32,183.63 167.3,183.72 167.3,183.93 167.66,184.29 168.38,184.29 169.06,184.97 169.06,187.75 169.46,188.15 171.06,188.15
+VCCIN_AUX on BOTTOM (solid shape): 145.98,136.36 145.99,136.33 145.99,136.3 145.98,136.27 145.97,136.21 145.83,136.07 145.81,136.06 145.66,135.98 145.6,135.81 145.68,135.63 145.86,135.56 145.97,135.59 146.08,135.67 146.1,135.68 146.12,135.68 146.15,135.65 146.15,135.63 146.18,135.6 146.19,135.57 146.19,135.27 145.91,135 145.83,134.97 145.75,135.02 145.63,135.13 145.48,135.17 145.27,135.1 145.16,134.93 145.15,134.91 145.12,134.89 144.43,134.89 144.4,134.9 144.26,135.1 144.06,135.17 143.9,135.13 143.78,135.02 143.71,134.98 143.62,135 143.51,135.12 143.51,135.46 143.55,135.54 143.63,135.56 143.67,135.56 143.85,135.63 143.93,135.81 143.88,135.96 143.77,136.05 143.76,136.06 143.72,136.09 143.71,136.13 143.72,136.16 144.1,136.54 145.79,136.54
+VCCIN_AUX on BOTTOM (solid shape): outline of 716 points within 156.83,142.72 166.27,159.29
+VCCIN_AUX on IN2 (solid shape): 167.16,215.81 167.16,214.77 167.01,214.62 166.22,214.62 166.01,214.69 165.79,214.62 165.79,214.62 165.56,214.85 165.56,215.94 165.59,215.96 167.01,215.96
+VCCIN_AUX on SVCC (solid shape): outline of 1208 points within 156.86,143.2 179.71,182.59
+VCCIN_AUX on SVCC1 (solid shape): outline of 1216 points within 156.86,143.2 179.71,182.59
+VCCIN_AUX on IN3 (solid shape): outline of 4899 points within 143.27,135.07 174.63,188.46
+VCCIN_AUX on IN4 (solid shape): outline of 2475 points within 144.41,135.3 166.77,158.76
+VCCIO_OUT on TOP (solid shape): 184.84,153.06 184.92,153.05 185.01,153.06 185.09,153.07 186.38,153.07 187.22,152.23 187.22,149.69 185.89,148.36 184.28,148.36 184.26,148.37 184.26,148.74 184.34,148.82 184.45,148.82 184.74,149.1 184.74,149.63 185.26,150.15 185.26,151.25 185.3,151.3 185.5,151.3 185.76,151.04 186.57,151.04 186.64,151.11 186.64,151.98 186.37,152.25 184.45,152.25 184.26,152.44 184.26,152.83 184.51,153.07 184.75,153.07
+VCCIO_OUT on BOTTOM (solid shape): 181.51,160.39 181.51,159.72 181.51,159.72 181.51,157.59 180.45,156.53 179.65,156.53 179.27,156.15 179.2,156.07 179.16,155.98 179.16,155.97 178.99,155.8 178.99,153.93 177.95,152.9 177.95,151.03 177.65,150.73 177.43,150.73 177.26,150.9 177.26,153.22 178.43,154.39 178.43,155.92 179.46,156.96 180.11,156.96 180.75,157.59 180.75,159.35 180.47,159.63 180.47,159.64 180.39,159.75 180.27,159.83 180.25,159.85 180.16,159.87 180.11,159.87 180.06,159.87 180,159.85 179.63,159.85 179.32,159.54 179.32,158.93 179.26,158.88 178.91,158.88 178.89,158.9 178.89,159.65 179.42,160.19 180.07,160.19 180.46,160.58 181.31,160.58
+VCCPRIM_1P05_OUT on TOP (solid shape): 215.53,71.03 215.61,71.02 215.66,71.03 215.72,71.04 215.75,71.03 215.8,70.98 215.8,70.06 216.06,69.81 216.31,69.81 216.49,69.64 216.49,68.92 216.44,68.87 216.06,68.87 215.98,68.8 215.97,68.8 215.78,68.61 215.78,68.53 215.76,68.51 215.33,68.51 215.29,68.54 215.29,68.77 215.51,68.99 215.82,68.99 215.91,69.08 215.91,69.4 215.83,69.47 215.77,69.47 215.31,69.47 215.25,69.47 215.14,69.58 215.14,69.68 214.99,69.83 214.63,69.83 214.51,69.95 214.51,70.68 214.89,71.06 215.44,71.06
+VCCPRIM_1P05_OUT on BOTTOM (solid shape): 215.86,70.34 215.86,70.32 215.85,70.26 215.85,70.22 215.86,70.16 215.88,70.09 215.88,69.97 216.44,69.41 216.44,69.13 216.18,68.87 216.03,68.87 215.85,68.7 215.54,68.7 215.45,68.78 215.45,68.93 215.47,68.99 215.48,69.05 215.45,69.17 215.36,69.26 215.35,69.28 215.28,69.3 215.22,69.3 215.17,69.3 215.11,69.28 214.81,69.28 214.7,69.38 214.7,70.01 214.58,70.13 214.58,70.5 214.71,70.63 215.57,70.63
+VCCST on TOP (solid shape): 207.19,179.85 207.19,178.73 206.94,178.47 205.49,178.47 205.31,178.65 205.31,179.77 205.62,180.07 206.96,180.07
+VCCST on TOP (solid shape): 167.73,142.57 167.73,141.34 167.8,141.26 167.8,140.67 167.79,140.66 166.84,140.66 166.59,140.92 166.59,142.57 166.71,142.69 167.6,142.69
+VCCST on TOP (solid shape): 185.07,157.44 185.07,156.33 184.76,156.02 183.82,156.02 183.01,155.21 183.01,154.7 182.76,154.45 182.07,154.45 181.77,154.75 181.77,156.05 183.49,157.77 184.74,157.77
+VCCST on TOP (solid shape): 157.04,72.31 157.04,71.55 156.99,71.5 156.47,71.5 155.93,71.5 155.88,71.55 155.88,72.11 155.97,72.2 156.18,72.2 156.49,72.51 156.84,72.51
+VCCST on TOP (solid shape): 184.43,147.22 184.47,147.21 184.48,147.17 184.48,146.52 184.04,146.08 182.87,146.08 182.78,146.16 182.78,146.95 182.91,147.08 183.21,147.08 183.37,146.93 183.37,146.7 183.48,146.59 184,146.59 184.27,146.85 184.27,147.22 184.27,147.22
+VCCST on BOTTOM (solid shape): 183.11,156.2 183.11,154.45 182.76,154.09 182.02,154.09 181.97,154.14 181.97,156.27 182.1,156.4 182.91,156.4
+VCCST on BOTTOM (solid shape): 167.06,142.49 167.06,142.25 167.49,141.82 167.49,141.69 167.7,141.48 167.7,141.21 167.93,140.98 167.93,140.74 167.82,140.62 167.09,140.62 166.94,140.77 166.94,140.91 166.56,141.29 166.56,141.49 166.76,141.69 166.76,142.09 166.57,142.28 166.57,142.58 166.64,142.65 166.9,142.65
+VCCST on BOTTOM (solid shape): 207.18,179.91 207.18,179.61 207.1,179.53 207.1,179.02 206.66,178.58 205.94,178.58 205.29,177.94 205.29,176.56 205.28,176.55 204.5,176.55 204.46,176.56 204.45,176.6 204.45,179 204.96,179.51 206.17,179.51 206.72,180.07 207.03,180.07
+VCCST on BOTTOM (solid shape): 112.25,132.27 112.25,131.85 111.87,131.48 111.87,130.66 112.24,130.29 114.45,130.29 114.52,130.36 115.12,130.36 115.12,127.78 114.59,127.25 113.79,127.25 113.51,127.53 113.51,129.56 113.39,129.68 111.81,129.68 111.35,130.15 111.35,131.68 111.83,132.16 111.83,132.26 111.84,132.3 111.88,132.31 112.21,132.31
+VCCST on IN3 (solid shape): outline of 2347 points within 166.33,140.37 183.35,156.58
+VCCSTG on TOP (solid shape): 183.18,163.67 183.18,163.66 183.55,163.3 184.04,163.3 184.05,163.28 184.05,162.83 184.03,162.81 182.8,162.81 181.58,164.03 181.58,164.34 181.77,164.53 182.32,164.53
+VCCSTG on TOP (solid shape): 168.82,150 168.88,149.99 168.94,150 169,150.01 169.52,150.01 169.59,150 169.65,149.99 169.69,150 169.74,150.01 169.77,150 169.79,149.99 169.81,149.97 169.9,149.87 169.9,149.53 169.8,149.43 169.78,149.42 169.75,149.42 169.7,149.43 169.65,149.43 169.56,149.42 169.48,149.39 169.47,149.39 169.06,149.39 169.05,149.39 168.96,149.42 168.88,149.43 168.82,149.43 168.76,149.41 168.22,149.41 167.86,149.04 167.86,148.62 167.98,148.49 168.24,148.49 168.35,148.38 168.35,148.09 168.2,147.94 168.19,147.94 168.05,147.94 167.98,147.87 167.98,147.14 168.02,147.09 168.02,146.47 167.96,146.4 167.9,146.37 167.86,146.34 167.38,146.34 167.22,146.5 167.22,147.4 167.34,147.52 167.34,148.41 167.22,148.53 167.22,149.42 167.81,150.01 168.76,150.01
+VCCSTG on BOTTOM (solid shape): 198.24,186.71 198.24,183.34 198.14,183.24 197.95,183.24 197.78,183.07 197.78,182.74 197.6,182.56 197.25,182.56 197.19,182.63 197.19,182.64 197,182.83 197,183.11 197.15,183.26 197.15,186.56 197.39,186.81 198.15,186.81
+VCCSTG on BOTTOM (solid shape): 220.11,85.47 220.11,85.45 220.25,85.23 220.5,85.14 220.62,85.16 220.72,85.21 220.83,85.21 220.88,85.12 220.88,84.93 220.81,84.85 218.87,84.85 218.7,85.03 218.7,85.89 218.77,85.97 218.79,85.98 218.81,85.98 218.86,85.98 218.95,85.99 219.02,86.01 219.03,86.02 219.56,86.02
+VCCSTG on BOTTOM (solid shape): 183.31,164.25 183.31,161.22 183.1,161 177.65,161 177.62,160.98 177.62,160.59 177.92,160.29 178.3,160.29 178.33,160.26 178.33,159.97 178.27,159.91 177.95,159.91 177.74,159.7 177.74,159.4 177.53,159.18 177.53,159.02 177.37,158.86 176.98,158.86 176.96,158.89 176.96,159.08 176.97,159.08 177.1,159.08 177.34,159.33 177.34,159.81 177.5,159.98 177.5,160.35 177.48,160.37 177.35,160.51 175.85,160.51 175.8,160.55 175.65,160.73 175.43,160.8 175.27,160.76 175.13,160.66 174.96,160.48 174.42,160.48 174.41,160.49 174.41,160.85 174.49,160.93 174.62,160.93 174.66,160.93 174.7,160.93 174.82,161.05 174.82,161.41 176.17,162.76 179.07,162.76 181.17,164.86 182.7,164.86
+VCCSTG on IN3 (solid shape): outline of 2291 points within 166.33,147.49 183.17,164.9
+VCCSTG_12 on TOP (solid shape): 167.69,139.16 167.69,138.28 167.61,138.2 167.04,138.2 167.04,138.83 166.73,138.83 166.56,139 166.56,139.15 166.7,139.29 167.56,139.29
+VCCSTG_OUT_1 on TOP (solid shape): 166.4,139.24 166.4,138.94 166.71,138.63 166.71,138.25 166.65,138.19 166.27,138.19 166.25,138.21 165.83,138.21 165.77,138.14 165.26,138.14 165.25,138.14 165.25,138.57 165.31,138.63 165.7,138.63 165.91,138.85 165.91,139.14 166.07,139.29 166.35,139.29
+VCCSTG_OUT_23456 on TOP (solid shape): 166.21,138.05 166.22,138.05 166.3,137.97 166.6,137.97 166.68,138.04 166.92,138.04 167.09,137.87 167.09,137.81 167.2,137.55 167.46,137.44 167.54,137.45 167.62,137.48 167.63,137.49 167.86,137.49 168.11,137.23 168.11,136.72 168.24,136.6 168.24,136.09 167.86,136.09 167.73,136.22 167.73,136.47 167.6,136.6 166.55,136.6 166.38,136.42 166.38,136.1 166.33,136.05 166.13,136.05 166.12,136.07 166.12,136.81 165.85,137.08 165.84,137.09 165.71,137.23 165.52,137.29 165.41,137.27 165.32,137.23 165.32,137.23 165.2,137.35 165.2,137.68 165.22,137.72 165.23,137.78 165.27,137.82 165.92,137.82 165.92,137.96 166.01,138.06 166.2,138.06
+VCCSTG_OUT_23456 on BOTTOM (solid shape): 167.14,137.97 167.14,137.95 167.12,137.88 167.12,137.81 167.17,137.63 167.31,137.5 167.32,137.5 167.51,137.31 167.51,137.3 167.61,137.14 167.78,137.08 167.82,137.08 167.85,137.09 168.01,137.09 168.13,136.97 168.13,136.35 167.98,136.2 167.98,136.19 167.92,136.13 167.87,136.1 167.59,136.1 167.55,136.14 167.25,136.14 167.15,136.04 166.46,136.04 166.06,136.44 166.06,136.46 166.04,136.53 165.99,136.59 165.87,136.71 165.87,137.07 165.88,137.08 165.9,137.09 166.05,137.19 166.11,137.36 166.06,137.52 165.92,137.62 165.91,137.62 165.87,137.66 165.87,137.99 166.01,138.12 166.99,138.12
+VIN on TOP (solid shape): 65.43,62.02 65.43,60.22 65.3,60.08 63.18,60.08 62.97,60.29 62.97,62.24 63.1,62.37 65.08,62.37
+VIN on TOP (solid shape): 172.29,205.4 172.29,202.93 170.74,201.39 168.19,201.39 167.15,202.43 167.15,203.56 167.64,204.05 171.11,204.05 171.51,204.45 171.51,204.7 171.66,204.85 171.66,205.45 171.71,205.5 172.19,205.5
+VIN on TOP (solid shape): 120.02,57.77 120.26,57.69 120.51,57.77 120.53,57.77 120.88,57.42 120.88,55.79 120.75,55.67 119.51,55.67 119.43,55.74 119.43,56.27 119.08,56.63 119.08,56.64 118.98,56.79 118.82,56.89 118.8,56.91 118.8,57.24 119.33,57.77
+VIN on TOP (solid shape): 87.21,91.67 87.21,91.61 87.21,91.58 87.21,90.21 87.25,90.11 87.34,90.07 87.37,90.07 87.63,89.81 87.63,88.8 87.49,88.66 86.03,88.66 85.91,88.79 85.91,89.01 85.92,89.08 85.93,89.14 85.92,89.21 85.91,89.28 85.91,89.65 85.5,90.06 84.19,90.06 84.07,90.18 84.07,91.5 84.19,91.62 85.07,91.62 85.29,91.85 87.03,91.85
+VIN on TOP (solid shape): 54.37,52.07 54.37,51.79 54.38,51.79 54.38,51.32 54.59,51.11 56.28,51.11 56.49,50.9 56.49,50.18 57.03,49.64 57.03,47.46 57.15,47.33 58.04,47.33 58.17,47.21 58.17,46.7 58.04,46.57 57.15,46.57 56.77,46.19 56.77,44.16 56.52,43.9 51.69,43.9 51.18,44.41 51.18,45.43 50.93,45.68 47.76,45.68 47.75,45.68 46.68,45.68 46.55,45.55 44.28,45.55 43.9,45.93 43.9,49.32 44.96,50.38 51.77,50.38 52.12,50.74 52.12,51.87 52.49,52.24 54.21,52.24
+VIN on TOP (solid shape): outline of 249 points within 180.6,168.06 192.9,186.83
+VIN on BOTTOM (solid shape): 148.8,56.43 148.8,54.85 147.98,54.03 143.1,54.03 142.78,54.36 142.78,56.53 142.8,56.55 148.67,56.55
+VIN on BOTTOM (solid shape): 169.71,55.6 169.71,53.98 169.52,53.79 169.02,53.79 168.84,53.96 164.73,53.96 164.42,54.27 164.42,55.59 164.7,55.87 169.45,55.87
+VIN on BOTTOM (solid shape): 193.02,168.47 193.02,167.02 192.62,166.63 192.02,166.63 191.98,166.59 190.58,166.59 190.4,166.76 190.4,167.63 190.71,167.93 191.8,167.93 192.51,168.64 192.84,168.64
+VIN on BOTTOM (solid shape): 139.14,206.67 139.4,206.67 139.73,206.34 139.73,201.66 139.23,201.16 137.46,201.16 137.01,201.6 137.01,207.53 137.19,207.71 138.1,207.71
+VIN on BOTTOM (solid shape): 121.15,40.77 122.1,40.77 122.37,40.49 122.42,40.45 122.48,40.44 125.68,40.44 125.75,40.36 125.75,39.16 125.57,38.98 121.19,38.98 120.6,39.56 120.6,40.7 120.68,40.78 121.14,40.78
+VIN on BOTTOM (solid shape): 249.02,45.89 249.02,45.12 248.4,44.49 248.4,43.82 248.05,43.47 245.18,43.47 244.99,43.67 244.99,44.29 245.24,44.55 245.49,44.55 245.79,44.84 245.79,45.1 246.02,45.32 247.78,45.32 248.06,45.61 248.06,45.94 248.26,46.14 248.77,46.14
+VIN on BOTTOM (solid shape): 172.37,203.79 172.37,202.65 172.28,202.57 169.22,202.57 169.17,202.56 169.12,202.53 168.9,202.53 168.69,202.32 168.69,201.66 168.58,201.54 167.93,201.54 166.85,202.62 166.85,203.25 167.7,204.1 171.26,204.1 171.27,204.11 172.04,204.11
+VIN on BOTTOM (solid shape): 188.24,186.53 188.24,182.23 188.5,181.98 188.5,175.58 188.45,175.53 187.99,175.53 187.96,175.55 187.96,176.67 187.51,177.13 184.23,177.13 183.82,177.53 183.82,178.04 183.72,178.14 181.36,178.14 181.21,178.3 181.21,181.47 181.35,181.62 181.35,182.44 181.13,182.67 180.77,182.67 180.6,182.84 180.6,186.45 180.91,186.77 188,186.77
+VIN on BOTTOM (solid shape): 45.48,49.81 45.81,49.81 46.06,49.56 46.06,47.15 46.15,47.05 46.43,47.05 46.57,46.92 46.58,46.9 46.57,46.85 46.57,46.55 46.57,46.51 46.59,46.46 46.59,42.74 46.36,42.51 45.34,42.51 45.09,42.76 44.33,42.76 44.1,42.99 44.1,47.2 43.84,47.46 43.84,49.26 44.4,49.82 45.47,49.82
+VIN on BOTTOM (solid shape): 278.74,184.54 278.87,184.54 279.04,184.37 279.04,181.14 278.48,180.58 278.48,180.26 278.44,180.16 278.43,180.06 278.44,179.95 278.48,179.85 278.48,179.76 278.47,179.74 278.47,179.52 278.1,179.15 277.98,179.01 277.93,178.83 277.94,178.74 277.97,178.66 277.89,178.58 277.12,178.58 277,178.69 277,180.49 277,180.49 277,182.66 277.14,182.8 277.14,184.29 277.4,184.54 278.74,184.54
+VIN on IN1 (solid shape): outline of 1348 points within 166.93,178.39 183.8,204.13
+VIN on IN2 (solid shape): outline of 202 points within 274.04,182.01 279.22,191.28
+VIN on IN2 (solid shape): outline of 521 points within 99.75,116.02 120.07,175.5
+VIN on SVCC (solid shape): outline of 1800 points within 43.95,36.03 248.92,208.12
+VIN on SVCC (solid shape): outline of 1760 points within 180.72,178.19 286.87,219.8
+VIN on SVCC1 (solid shape): outline of 1612 points within 39.46,48.1 186.11,208.11
+VIN on IN3 (solid shape): outline of 1097 points within 100.13,116.19 118.07,174.28
+VIN on IN4 (solid shape): outline of 11610 points within 110.72,168.62 189.28,206.44
+VIN_GPU_TOTAL on TOP (solid shape): outline of 93 points within 226.86,199.63 263.19,209.26
+VIN_GPU_TOTAL on BOTTOM (solid shape): 231.87,201.27 231.87,199.94 231.71,199.77 231.69,199.77 231.62,199.74 231.59,199.67 231.59,199.66 231.24,199.31 227.08,199.31 226.85,199.54 226.85,201.52 227,201.67 227.2,201.67 227.2,201.67 231.47,201.67
+VIN_GPU_TOTAL on BOTTOM (solid shape): outline of 82 points within 236.55,204.64 264.98,209.16
+VIN_GPU_TOTAL on IN1 (solid shape): 262.96,208.35 262.96,207.62 262.67,207.33 256.62,207.33 255.84,208.1 255.84,208.87 256.26,209.28 262.03,209.28
+VIN_GPU_TOTAL on SVCC (solid shape): 252.16,208.98 252.48,208.78 252.8,208.98 263.98,208.98 265.18,207.78 265.18,201.34 261.67,197.83 232.53,197.83 231.54,198.82 225.75,198.82 225.13,199.44 225.13,200.33 232.29,207.5 232.38,207.45 232.48,207.44 232.73,207.54 232.84,207.8 232.82,207.9 232.78,207.99 233.77,208.98
+VIN_GPU_TOTAL on SVCC1 (solid shape): 252.15,209 252.48,208.78 252.81,209 263.95,209 265.18,207.78 265.18,201.34 261.67,197.83 232.37,197.83 231.5,198.7 231.34,198.81 231.14,198.85 225.38,198.85 225.17,199.06 225.17,204.98 226.3,206.11 226.41,206.27 226.44,206.46 226.44,208.37 226.44,208.44 226.5,208.47 226.55,208.52 227.04,209
+VIN_PANEL_R on TOP (solid shape): 272.93,185.13 273.56,185.13 273.69,185 273.69,183.73 273.56,183.6 272.66,183.6 272.59,183.67 272.51,183.73 272.41,183.78 272.31,183.82 271.85,183.81 271.48,183.54 271.44,183.52 269.5,183.52 269.39,183.63 269.39,183.98 270.54,183.98 270.54,184.22 269.39,184.22 269.39,184.47 270.54,184.47 270.54,184.72 269.39,184.72 269.39,184.98 270.54,184.98 270.54,185.22 269.39,185.22 269.39,185.46 269.4,185.47 272.58,185.47
+VIN_PANEL_R on BOTTOM (solid shape): 275.59,184.22 275.59,183.19 275.82,182.96 276.26,182.96 276.57,182.64 276.57,180.47 276.47,180.42 276.43,180.33 276.43,178.96 276.44,178.91 276.31,178.78 274.62,178.78 273.86,179.55 273.86,180.36 273.68,180.54 273.68,181.99 272.82,182.85 272.82,182.89 272.36,183.81 271.41,183.42 271.41,183.41 271.36,183.38 271.17,183.38 271.17,183.37 270.69,183.37 270.35,183.71 270.17,183.71 270.16,183.69 269.8,183.69 269.77,183.73 269.77,184.09 270.3,184.62 271.25,184.62 271.95,185.33 274.48,185.33
+VIN_SRC on TOP (solid shape): outline of 253 points within 186.08,186.73 199.24,202.43
+VIN_SRC on BOTTOM (solid shape): 195.96,202.43 196.1,202.22 196.35,202.13 196.59,202.22 196.73,202.43 199.09,202.43 199.24,202.27 199.24,195.9 198.49,195.15 194.69,195.15 194.12,194.58 193.22,194.58 192.97,194.32 192.97,192.19 192.76,191.99 192.76,191.17 192.59,191 192.59,188.76 192.36,188.53 188.26,188.53 188.02,188.3 188.02,187.62 187.97,187.57 186.49,187.57 186.44,187.62 186.44,188.02 186.52,188.1 186.87,188.1 186.97,188.2 186.97,188.86 186.57,189.27 186.57,193.64 187,194.07 187.56,194.07 188.88,195.39 188.88,202.38 188.93,202.43
+VIN_VCC_CORE on TOP (solid shape): outline of 1442 points within 114.51,195.06 167.36,209.34
+VIN_VCC_CORE on BOTTOM (solid shape): 136.5,208.6 136.5,203.26 136.38,203.14 129.9,203.14 129.54,203.49 129.54,207.66 129.67,207.79 129.67,208.98 129.99,209.29 135.81,209.29
+VIN_VCC_CORE on BOTTOM (solid shape): 117.99,198.46 117.99,196.81 118.88,195.92 118.88,195.03 118.75,194.91 117.61,194.91 117.31,195.2 113.98,195.2 113.88,195.29 113.88,196.43 113.93,196.48 115.38,196.48 115.52,196.62 115.52,197.55 115.58,197.6 115.85,197.6 116.97,198.72 117.73,198.72
+VIN_VCC_CORE on BOTTOM (solid shape): 156.59,198.46 156.59,196.81 157.48,195.92 157.48,195.03 157.36,194.91 156.21,194.91 155.9,195.22 152.59,195.22 152.54,195.28 152.54,196.38 152.59,196.43 153.96,196.43 154.13,196.6 154.13,197.45 154.33,197.65 154.51,197.65 155.58,198.72 156.34,198.72
+VIN_VCC_CORE on BOTTOM (solid shape): 166.25,198.46 166.25,196.81 167.14,195.92 167.14,195.03 167.01,194.91 165.87,194.91 165.59,195.18 162.28,195.18 162.2,195.26 162.2,196.4 162.24,196.43 163.63,196.43 163.78,196.59 163.78,197.46 164.21,197.89 164.4,197.89 165.23,198.72 165.99,198.72
+VIN_VCC_CORE on BOTTOM (solid shape): 127.64,198.46 127.64,196.38 128.04,195.98 128.47,195.98 128.53,195.92 128.53,195.03 128.4,194.91 127.26,194.91 126.97,195.19 123.64,195.19 123.56,195.26 123.56,196.45 123.61,196.49 125.03,196.49 125.17,196.63 125.17,197.59 125.36,197.78 125.68,197.78 126.62,198.72 127.38,198.72
+VIN_VCC_CORE on BOTTOM (solid shape): 146.94,198.46 146.94,196.31 147.21,196.04 147.71,196.04 147.83,195.92 147.83,195.03 147.7,194.91 146.56,194.91 146.27,195.2 142.96,195.2 142.89,195.27 142.89,196.43 142.92,196.47 144.36,196.47 144.48,196.58 144.48,197.54 144.57,197.64 144.85,197.64 145.93,198.72 146.69,198.72
+VIN_VCC_CORE on BOTTOM (solid shape): 137.29,198.46 137.29,196.81 137.3,196.8 137.3,196.37 137.57,196.1 138.01,196.1 138.18,195.92 138.18,195.03 138.05,194.91 136.91,194.91 136.68,195.14 133.35,195.14 133.21,195.28 133.21,196.45 133.25,196.48 134.76,196.48 134.82,196.54 134.82,197.43 135.04,197.65 135.21,197.65 136.27,198.72 137.04,198.72
+VIN_VCC_CORE on IN1 (solid shape): 117.88,197.57 117.88,196.43 117.58,196.13 116.47,196.13 115.76,196.84 115.76,198.01 116.13,198.38 117.07,198.38
+VIN_VCCIN_AUX on TOP (solid shape): 175.85,196.91 175.85,196.48 175.75,196.38 175.06,196.38 174.78,196.66 173.36,196.66 173.21,196.81 173.21,197.9 172.21,198.9 172.21,199.24 172.66,199.69 173.07,199.69
+VIN_VCCIN_AUX on BOTTOM (solid shape): 173.99,201.41 173.99,201.05 174.7,200.34 174.7,198.06 175.85,196.91 175.85,196.48 175.75,196.38 175.06,196.38 174.78,196.66 173.36,196.66 173.21,196.81 173.21,198.26 173,198.46 168.09,198.46 168.04,198.52 168.04,199.57 168.12,199.65 170.44,199.65 170.54,199.75 170.54,200.93 170.51,200.95 169.06,200.95 168.96,201.06 168.96,202.04 169.06,202.14 173.26,202.14
+VIN_VGACORE on TOP (solid shape): 232.02,197.5 232.02,192.54 231.75,192.27 227.66,192.27 226.95,192.97 226.95,197.63 227.31,197.99 231.53,197.99
+VIN_VGACORE on TOP (solid shape): 235.97,93.05 235.97,90.39 235.72,90.13 233.56,90.13 233.43,90.01 233.43,89.62 233.18,89.37 231.02,89.37 230.89,89.5 230.89,91.28 233.05,91.28 233.68,91.91 233.68,92.8 234.06,93.18 235.84,93.18
+VIN_VGACORE on TOP (solid shape): 245.75,93.05 245.75,90.39 245.49,90.13 243.34,90.13 243.21,90.01 243.21,89.62 242.95,89.37 240.8,89.37 240.67,89.5 240.67,91.28 242.83,91.28 243.46,91.91 243.46,92.8 243.84,93.18 245.62,93.18
+VIN_VGACORE on TOP (solid shape): 255.53,93.05 255.53,90.39 255.27,90.13 253.11,90.13 252.99,90.01 252.99,89.62 252.73,89.37 250.57,89.37 250.45,89.5 250.45,91.28 252.61,91.28 253.24,91.91 253.24,92.8 253.62,93.18 255.4,93.18
+VIN_VGACORE on TOP (solid shape): 265.31,93.05 265.31,90.39 265.05,90.13 262.89,90.13 262.77,90.01 262.77,89.62 262.51,89.37 260.35,89.37 260.23,89.5 260.23,91.14 260.37,91.28 262.39,91.28 263.02,91.91 263.02,92.8 263.4,93.18 265.18,93.18
+VIN_VGACORE on TOP (solid shape): 226.19,93.05 226.19,90.39 225.94,90.13 223.78,90.13 223.65,90.01 223.65,89.62 223.4,89.37 221.24,89.37 221.11,89.5 221.11,91.28 222.86,91.28 223.18,91.59 223.64,91.59 223.9,91.86 223.9,92.8 224.29,93.18 226.06,93.18
+VIN_VGACORE on TOP (solid shape): 275.09,93.05 275.09,90.39 274.83,90.13 272.67,90.13 272.55,90.01 272.55,89.62 272.29,89.37 270.13,89.37 270.01,89.5 270.01,91.2 270.08,91.28 272.16,91.28 272.8,91.91 272.8,92.8 273.18,93.18 274.96,93.18
+VIN_VGACORE on TOP (solid shape): 285.12,92.8 285.12,90.13 284.99,90.01 282.83,90.01 282.5,89.68 282.5,89.45 282.3,89.24 281.84,89.24 281.77,89.32 281.77,89.47 281.61,89.62 280.04,89.62 279.91,89.75 279.91,91.4 280.04,91.53 281.79,91.53 283.18,92.93 284.99,92.93
+VIN_VGACORE on TOP (solid shape): 293.57,92.74 293.57,90.51 293.34,90.27 291.89,90.27 291.5,89.88 291.5,89.33 291.42,89.25 289.95,89.25 289.82,89.39 289.82,91.58 289.94,91.71 290.9,91.71 292.12,92.93 293.39,92.93
+VIN_VGACORE on TOP (solid shape): 246.4,85.31 248.24,85.31 248.35,85.2 248.35,81 247.93,80.58 247.51,80.58 247.48,80.61 241.3,80.61 241.05,80.86 241.05,85.79 241.39,86.12 245.59,86.12
+VIN_VGACORE on BOTTOM (solid shape): 231.43,198.72 231.43,198.12 232.24,197.31 232.24,192.75 231.75,192.26 226.59,192.26 226.3,192.55 226.3,196.69 226.71,197.1 226.71,198.57 227.13,198.99 231.16,198.99
+VIN_VGACORE on BOTTOM (solid shape): 245.91,85.43 246.56,85.43 246.57,85.43 248.1,85.43 248.36,85.17 248.36,84.23 247.55,83.43 247.55,76.65 247.1,76.19 244.09,76.19 241.29,78.99 241.29,85.79 241.53,86.03 245.32,86.03
+VIN_VGACORE on BOTTOM (solid shape): 255.47,92.93 255.47,90.33 255.27,90.13 253.11,90.13 252.99,90.01 252.99,89.12 252.33,88.46 251.86,88.46 251.86,89.19 251.79,89.26 250.29,89.26 250.25,89.31 250.25,91.49 250.27,91.52 252.85,91.52 253.24,91.91 253.24,92.8 253.53,93.09 255.31,93.09
+VIN_VGACORE on BOTTOM (solid shape): 235.87,93.01 235.87,90.29 235.72,90.13 233.56,90.13 233.43,90.01 233.43,89.62 232.67,88.86 232.67,88.53 232.59,88.46 232.3,88.46 232.3,89.18 232.22,89.27 231.76,89.27 231.75,89.26 230.71,89.26 230.64,89.33 230.64,91.46 230.69,91.51 233.28,91.51 233.68,91.91 233.68,92.8 233.99,93.11 235.77,93.11
+VIN_VGACORE on BOTTOM (solid shape): 245.69,93.01 245.69,90.33 245.49,90.13 243.34,90.13 243.21,90.01 243.21,89.62 242.57,88.99 242.57,88.61 242.45,88.48 242.08,88.48 242.08,89.14 241.95,89.27 241.71,89.27 241.7,89.26 240.51,89.26 240.47,89.3 240.47,91.49 240.48,91.5 243.06,91.5 243.46,91.91 243.46,93.04 243.6,93.18 245.52,93.18
+VIN_VGACORE on BOTTOM (solid shape): 275.09,92.88 275.09,90.39 274.83,90.13 272.67,90.13 272.55,90.01 272.55,88.86 272.14,88.46 271.43,88.46 271.42,88.46 271.42,89.13 271.33,89.22 271.32,89.22 269.87,89.22 269.78,89.31 269.78,91.47 269.82,91.5 272.39,91.5 272.49,91.6 272.49,92.49 272.95,92.95 275.01,92.95
+VIN_VGACORE on BOTTOM (solid shape): 285.12,92.8 285.12,90.13 284.99,90.01 282.83,90.01 282.45,89.62 282.45,88.99 282.17,88.71 281.45,88.71 281.45,89.48 281.4,89.53 279.87,89.53 279.81,89.59 279.81,91.67 279.9,91.76 282.34,91.76 282.49,91.9 282.49,92.61 282.8,92.92 283.59,92.92 283.59,92.93 284.99,92.93
+VIN_VGACORE on BOTTOM (solid shape): 265.31,93.24 265.31,90.39 265.05,90.13 262.89,90.13 262.77,90.01 262.77,88.86 262.36,88.46 261.64,88.46 261.64,89.23 261.59,89.28 260.07,89.28 260.03,89.32 260.03,91.46 260.06,91.5 262.61,91.5 263.02,91.91 263.02,92.8 263.02,92.8 263.02,92.92 263.43,93.33 265.22,93.33
+VIN_VGACORE on BOTTOM (solid shape): 226.07,92.97 226.07,90.27 225.94,90.13 223.78,90.13 223.65,90.01 223.65,89.62 223.4,89.37 223.4,88.74 223.4,88.58 223.26,88.45 222.53,89.16 222.46,89.23 220.97,89.23 220.88,89.32 220.88,91.48 220.94,91.54 223.53,91.54 223.9,91.91 223.9,93.02 224.07,93.18 225.86,93.18
+VIN_VGACORE on BOTTOM (solid shape): 293.99,93.36 293.99,93.05 294.11,92.93 294.9,92.93 295.02,92.8 295.02,90.68 294.86,90.51 294.44,90.51 294.4,90.55 292.75,90.55 292.71,90.51 292.71,89.39 292.47,89.16 292.47,88.77 292.43,88.72 291.36,88.72 291.36,89.41 291.21,89.56 289.77,89.56 289.75,89.58 289.75,91.69 289.79,91.73 292.3,91.73 292.57,92 292.57,93.23 292.79,93.44 293.91,93.44
+VIN_VGACORE on IN2 (solid shape): outline of 2520 points within 190.07,158.48 232.44,197.85
+VIN_VGACORE on SVCC (solid shape): outline of 163 points within 180.69,76.21 292.74,197.8
+VIN_VGACORE on SVCC1 (solid shape): outline of 460 points within 187.09,75.5 286.74,176.24
GND on TOP (solid shape): 45.37,59.09 45.37,57.42 45.22,57.27 38.2,57.27 38.08,57.39 38.08,59.12 38.18,59.22 45.24,59.22
GND on TOP (solid shape): 50.4,99.35 50.4,98.26 50.32,98.18 48.31,98.18 48.24,98.26 48.24,99.33 48.34,99.43 50.32,99.43
GND on TOP (solid shape): 51.64,51.88 51.64,50.76 51.49,50.61 48.11,50.61 47.86,50.86 47.86,51.83 48.11,52.08 51.44,52.08
GND on TOP (solid shape): 55.17,95.49 55.17,94.43 55.02,94.27 53.67,94.27 53.57,94.37 53.57,95.52 53.62,95.57 55.1,95.57
GND on TOP (solid shape): 55.36,39.37 55.36,38.31 55.27,38.23 53.45,38.23 53.34,38.34 53.34,39.36 53.42,39.44 55.29,39.44
GND on TOP (solid shape): 61.09,42.36 61.09,41.07 60.8,40.78 58.75,40.78 58.39,41.14 58.39,42.12 58.69,42.42 61.03,42.42
GND on TOP (solid shape): 70.59,63.36 70.59,60.01 70.47,59.89 68.89,59.89 68.79,59.99 68.79,63.31 68.96,63.49 70.46,63.49
GND on TOP (solid shape): 130.31,47.92 130.31,46.42 130.2,46.32 125.94,46.32 125.83,46.42 125.83,48.07 126.06,48.3 129.92,48.3
GND on TOP (solid shape): 143.17,215.97 143.17,214.63 143.04,214.51 140.1,214.51 139.95,214.65 139.95,215.96 140.08,216.08 143.05,216.08
GND on TOP (solid shape): 148.54,206.51 148.54,203.87 148.51,203.84 145.88,203.84 145.82,203.9 145.82,206.53 145.85,206.56 148.5,206.56
GND on TOP (solid shape): 154.71,59.55 154.71,57.75 154.69,57.72 152.91,57.72 152.89,57.75 152.89,59.55 152.91,59.58 154.69,59.58
GND on TOP (solid shape): 176.7,42.58 176.7,38.95 176.29,38.54 164.88,38.54 164.21,39.21 164.21,41.98 164.96,42.74 176.55,42.74
GND on TOP (solid shape): 262.89,79.85 262.89,76.52 262.72,76.34 259.26,76.34 259.16,76.44 259.16,79.92 259.34,80.1 262.64,80.1
GND on TOP (solid shape): 279.63,91.66 279.63,89.52 279.38,89.27 277.45,89.27 277.29,89.42 277.29,91.56 277.6,91.86 279.43,91.86
GND on TOP (solid shape): 288.04,129.88 288.04,128.84 286.26,127.06 284.01,127.06 282.77,128.3 282.77,129.73 283.09,130.04 287.87,130.04
GND on TOP (solid shape): 289.54,91.66 289.54,89.55 289.39,89.4 287.71,89.4 287.58,89.52 287.58,91.61 287.79,91.81 289.39,91.81
GND on TOP (solid shape): 312.85,99.83 312.85,99.1 312.8,99.05 311.21,99.05 311.09,99.16 311.09,99.79 311.29,99.99 312.68,99.99
GND on TOP (solid shape): 314.55,68.61 314.55,64.26 314.49,64.19 310.17,64.19 310.1,64.27 310.1,68.63 310.13,68.67 314.49,68.67
GND on TOP (solid shape): 33.87,45.94 33.87,44.49 33.73,44.35 33.73,43.18 33.4,42.84 32.8,42.84 32.61,43.03 32.61,45.96 32.67,46.02 33.78,46.02
GND on TOP (solid shape): 43.14,76.08 43.14,75.41 42.96,75.22 42.41,75.22 42.32,75.31 42.32,75.78 42.14,75.96 42.14,76.28 42.2,76.35 42.88,76.35
GND on TOP (solid shape): 59.68,48.62 59.68,47.86 59.53,47.71 58.43,47.71 58.21,47.49 57.41,47.49 57.31,47.59 57.31,48.61 57.48,48.78 59.52,48.78
GND on TOP (solid shape): 70.62,42.32 70.62,40.59 70.57,40.53 61.54,40.53 61.44,40.63 61.44,42.24 61.51,42.3 69.44,42.3 69.52,42.39 70.55,42.39
GND on TOP (solid shape): 85.77,89.54 85.77,88.73 85.8,88.7 85.8,88.6 85.68,88.48 84.6,88.48 84.24,88.84 84.24,89.8 84.34,89.89 85.41,89.89
GND on TOP (solid shape): 128.84,41.78 128.84,39.42 128.62,39.2 126.83,39.2 126.71,39.32 126.71,40.73 126.04,41.41 126.04,42.01 126.09,42.06 128.56,42.06
GND on TOP (solid shape): 137.89,144.56 137.89,144.22 137.76,144.09 136.23,144.09 136.07,144.26 136.07,144.54 136.19,144.66 137.79,144.66
GND on TOP (solid shape): 147.79,149.17 147.79,148.79 148.04,148.54 148.04,148.28 147.92,148.15 147.28,148.15 147.16,148.28 147.16,149.17 147.28,149.3 147.66,149.3
GND on TOP (solid shape): 186.79,187.31 186.79,187.01 186.72,186.93 183.01,186.93 182.86,187.08 182.86,187.44 183.16,187.75 186.36,187.75
GND on TOP (solid shape): 209.69,204.78 209.69,204.01 209.51,203.84 206.87,203.84 206.45,204.26 206.45,205.42 206.78,205.75 208.71,205.75
GND on TOP (solid shape): 220.6,91.27 220.6,89.6 220.41,89.4 219.03,89.4 218.86,89.57 218.86,91.17 219.07,91.37 220.49,91.37
GND on TOP (solid shape): 226.19,89.75 226.19,88.61 226.06,88.48 224.16,88.48 223.9,88.74 223.9,89.62 224.16,89.88 226.06,89.88
GND on TOP (solid shape): 230.7,213.25 230.7,210.72 230.65,210.68 228.12,210.68 228.09,210.71 228.09,213.24 228.13,213.28 230.67,213.28
GND on TOP (solid shape): 239.67,149.7 240.18,149.7 240.21,149.67 240.21,147.1 240.18,147.07 238.61,147.07 238.6,147.09 238.6,150.16 238.78,150.34 239.03,150.34
GND on TOP (solid shape): 242.2,63.78 243.37,63.78 243.52,63.63 243.52,62.64 243.4,62.51 240.65,62.51 240.24,62.93 240.24,63.84 240.44,64.05 241.94,64.05
GND on TOP (solid shape): 264.47,188.1 264.47,172.97 263.97,172.47 263.21,172.47 262.84,172.85 262.84,186.53 262.72,186.64 262.72,188.16 262.9,188.34 264.23,188.34
GND on TOP (solid shape): 269.5,91.27 269.5,89.39 269.31,89.2 268.01,89.2 267.71,89.5 267.71,91.26 267.93,91.47 269.29,91.47
GND on TOP (solid shape): 274.62,59.72 274.62,59.25 274.32,58.95 273.52,58.95 273.52,58.95 271.42,58.95 271.26,59.11 271.26,59.69 271.38,59.8 274.54,59.8
GND on TOP (solid shape): 230.38,91.24 230.38,89.75 230.38,89.44 230.28,89.34 228.7,89.34 228.49,89.55 228.49,91 228.84,91.35 230.26,91.35
GND on TOP (solid shape): 239.93,91.42 240.1,91.42 240.24,91.27 240.24,89.44 240.09,89.28 238.57,89.28 238.33,89.53 238.33,91.21 238.54,91.42 239.93,91.42
GND on TOP (solid shape): 246.35,190.37 248.41,190.37 248.8,189.98 248.8,188.84 248.52,188.56 242.19,188.56 241.81,188.94 241.81,190.34 241.94,190.46 246.26,190.46
GND on TOP (solid shape): 259.72,91.26 259.72,89.59 259.49,89.35 258.03,89.35 257.8,89.59 257.8,91.29 257.89,91.39 259.59,91.39
GND on TOP (solid shape): 266.26,210.27 266.26,210.05 265.85,209.64 265.85,209.28 265.78,209.21 265.23,209.21 265.14,209.3 265.14,209.69 265.87,210.42 266.1,210.42
GND on TOP (solid shape): 275.09,89.75 275.09,88.15 274.92,87.99 273.18,87.99 272.8,88.37 272.8,89.62 273.05,89.88 274.96,89.88
GND on TOP (solid shape): 290.97,86.56 290.97,86.33 290.32,85.68 290.32,85.49 290.25,85.42 289.86,85.42 289.81,85.47 289.81,86.51 290.05,86.74 290.8,86.74
GND on TOP (solid shape): 224.69,46.37 227.61,46.37 227.71,46.27 227.71,45.96 227.03,45.28 224.44,45.28 224.11,45.61 222.18,45.61 221.62,46.17 221.62,46.44 221.8,46.62 224.44,46.62
GND on TOP (solid shape): 249.94,91.26 249.94,89.45 249.8,89.31 248.17,89.31 248.01,89.47 248.01,91.12 248.32,91.42 249.77,91.42
GND on TOP (solid shape): 255.53,89.75 255.53,88.09 255.34,87.9 253.5,87.9 253.24,88.16 253.24,89.62 253.5,89.88 255.4,89.88
GND on TOP (solid shape): 259.51,217.05 259.51,216.13 259.61,216.02 259.85,216.02 259.88,216 259.88,215.54 259.85,215.5 258.7,215.5 258.59,215.61 258.59,217 258.66,217.07 259.48,217.07
GND on TOP (solid shape): 268.07,65.01 268.07,62.93 268,62.85 266.83,62.85 266.73,62.95 266.73,63.26 266.91,63.44 267.11,63.44 267.31,63.64 267.31,65.14 267.41,65.24 267.85,65.24
GND on TOP (solid shape): 272.27,84.88 272.27,84.29 272.11,84.14 271.22,84.14 270.97,83.88 270.97,83.63 270.61,83.27 270.18,83.27 269.95,83.5 269.95,84.95 270.16,85.15 271.99,85.15
GND on TOP (solid shape): 275.88,189.15 275.88,188.07 275.68,187.87 275.18,187.87 274.92,187.61 274.92,186.48 274.79,186.36 273.43,186.36 273.28,186.51 273.28,189.18 273.4,189.3 275.73,189.3
GND on TOP (solid shape): 307.67,80.24 307.67,78.17 307.04,77.53 307.04,77.23 306.96,77.15 306.06,77.15 305.83,77.38 305.83,79.78 305.83,79.78 305.83,80.44 305.95,80.56 307.35,80.56
GND on TOP (solid shape): 309.96,77.61 309.96,77.18 309.81,77.03 309.48,77.03 309.02,76.57 309.02,75.07 308.92,74.97 308.46,74.97 308.38,75.05 308.38,77 309.12,77.74 309.83,77.74
GND on TOP (solid shape): 179.68,198.82 179.68,197.4 179.53,197.24 177.52,197.24 177.12,197.65 177.07,197.65 176.84,197.88 176.84,198.79 176.96,198.92 177.83,198.92 177.93,199.02 179.48,199.02
GND on TOP (solid shape): 235.97,89.75 235.97,88.19 235.74,87.96 234.46,87.96 234.46,87.96 233.87,87.96 233.68,88.15 233.68,89.62 233.94,89.88 235.84,89.88
GND on TOP (solid shape): 240.54,85.18 240.54,80.56 240.24,80.25 234.29,80.25 233.81,80.73 233.81,85.28 233.99,85.46 240.26,85.46
GND on TOP (solid shape): 245.75,89.75 245.75,88.13 245.57,87.95 244.25,87.95 244.24,87.96 243.7,87.96 243.46,88.2 243.46,89.62 243.72,89.88 245.62,89.88
GND on TOP (solid shape): 265.31,89.75 265.31,88.11 265.09,87.9 263.2,87.9 263.02,88.08 263.02,89.62 263.27,89.88 265.18,89.88
GND on TOP (solid shape): 267.28,214.38 267.3,214.32 267.3,213.45 266.93,213.08 265.07,213.08 264.93,213.22 264.93,214.31 265.05,214.43 267.23,214.43
GND on TOP (solid shape): 17.14,43.67 17.14,43.3 16.89,43.05 16.89,42.28 16.92,42.26 16.92,42.16 16.64,41.88 13.4,41.88 13.27,42 13.27,43.26 13.4,43.39 15.88,43.39 16.24,43.74 17.07,43.74
GND on TOP (solid shape): 20.91,46.01 20.91,43.77 20.86,43.71 20.28,43.71 20.18,43.82 20.18,45 20.17,45.01 20.17,45.09 20.01,45.25 19.93,45.25 19.7,45.48 19.7,46.02 19.79,46.11 20.81,46.11
GND on TOP (solid shape): 45.87,79.08 45.87,78.19 46.38,77.69 47.81,77.69 47.91,77.59 47.91,76.52 47.55,76.16 44.99,76.16 44.57,76.58 44.57,78.17 44.48,78.26 44.48,79.26 44.52,79.3 45.65,79.3
GND on TOP (solid shape): 54.44,55.72 54.44,55.39 54.31,55.26 54.3,55.26 54.15,55.1 54.15,55.09 54.13,55.08 54.13,54.84 54.08,54.79 53.23,54.79 53.21,54.8 53.21,55.79 53.27,55.85 54.31,55.85
GND on TOP (solid shape): 131.05,70.47 131.05,69.72 131.06,69.66 131.08,69.61 131.09,69.6 131.09,69.54 130.85,69.3 129.59,69.3 129.49,69.4 129.49,70.43 129.57,70.5 131.02,70.5
GND on TOP (solid shape): 137.1,215.69 137.1,213.54 136.86,213.3 134.85,213.3 134.62,213.07 134.62,210.02 134.37,209.77 128.96,209.77 128.7,210.02 128.7,215.02 129.62,215.94 135.64,215.94 135.79,216.09 136.71,216.09
GND on TOP (solid shape): 195.38,157.7 195.38,155.89 195.35,155.87 195,155.87 194.8,156.07 192.59,156.07 192.28,155.77 191.06,155.77 191.01,155.82 191.01,157.47 191.44,157.9 195.18,157.9
GND on TOP (solid shape): 219.71,49.32 219.71,48.54 219.07,47.89 219.07,47.47 218.94,47.34 215.56,47.34 215.49,47.42 215.49,49.27 216.36,50.15 218.88,50.15
GND on TOP (solid shape): 277.81,138.32 277.81,138.32 278.34,137.79 278.34,137 277.53,136.2 277.27,136.2 277.18,136.29 277.18,136.86 276.93,137.1 273.17,137.1 272.93,137.34 272.93,138.26 273.16,138.5 277.63,138.5
GND on TOP (solid shape): 303.33,95.73 304.08,95.73 305.25,94.56 305.25,94.38 305.22,94.36 305.22,93.96 305.04,93.78 299.29,93.78 298.81,94.25 298.81,94.55 298.86,94.6 298.86,95.63 298.97,95.74 303.33,95.74
GND on TOP (solid shape): 240.89,153.86 240.89,151.28 240.88,151.27 239.29,151.27 239.28,151.28 239.28,152.52 239.21,152.6 238.8,152.6 238.64,152.76 238.64,153 238.76,153.12 239.24,153.12 239.29,153.17 239.29,153.88 240.87,153.88
GND on TOP (solid shape): 284.22,121.51 284.22,120.57 284.39,120.4 284.39,119.84 284.13,119.58 284.13,119.4 283.88,119.15 282.81,119.15 282.55,119.41 282.55,121.57 282.89,121.91 283.81,121.91
GND on TOP (solid shape): 71.4,54.52 71.4,53.56 71.22,53.37 67.34,53.37 67.28,53.43 64.42,53.43 64.29,53.56 64.29,53.84 64.47,54.01 67.21,54.01 67.52,54.32 70.41,54.32 70.84,54.75 71.17,54.75
GND on TOP (solid shape): 71.44,57.72 71.44,56.96 71.29,56.81 70.18,56.81 69.87,56.5 67.18,56.5 66.84,56.84 65.79,56.84 65.72,56.92 65.72,57.71 65.73,57.74 65.77,57.76 71.4,57.76
GND on TOP (solid shape): 160.63,165.75 160.63,164.96 160.82,164.77 160.82,162.54 161.9,161.46 162.89,161.46 163.05,161.3 163.05,159.35 162.99,159.3 162.61,159.3 161.81,160.1 160.32,160.1 159.85,160.57 159.85,165.8 159.92,165.88 160.51,165.88
GND on TOP (solid shape): 163.82,145.38 163.82,144.26 163.81,144.25 163.81,144.02 163.67,143.89 163.12,143.89 162.89,144.11 159.23,144.11 159.06,144.28 159.06,145.15 159.14,145.24 162.95,145.24 163.22,145.51 163.69,145.51
GND on TOP (solid shape): 172.62,197.65 172.62,196.84 173.23,196.23 176.47,196.23 176.6,196.1 176.6,194.55 176.41,194.36 169.41,194.36 169.22,194.55 169.22,197.84 169.33,197.96 172.32,197.96
GND on TOP (solid shape): 185.5,46.53 185.5,46.05 185.64,45.92 185.64,45.47 185.6,45.43 184.1,45.43 183.98,45.31 183.98,44.76 183.9,44.68 183.12,44.68 183.08,44.72 183.08,46.31 183.43,46.66 185.37,46.66
GND on TOP (solid shape): 238.3,153.77 238.3,151.18 238.3,151.18 236.7,151.18 236.69,151.18 236.69,152.48 236.58,152.59 235.99,152.59 235.83,152.74 235.83,152.97 235.98,153.12 236.67,153.12 236.69,153.14 236.69,153.75 236.71,153.78 238.3,153.78
GND on TOP (solid shape): 277.37,213.79 277.37,213.12 277.04,212.79 277.04,212.19 277.21,212.02 277.21,211.66 277.16,211.61 271.71,211.61 271.71,211.61 271.71,213.45 271.68,213.47 271.68,213.51 271.55,213.64 271.55,213.96 271.58,213.98 277.19,213.98
GND on TOP (solid shape): 288.14,48.02 288.14,46.57 288.01,46.44 284.74,46.44 284.25,46.93 282.65,46.93 282.32,47.26 282.06,47.26 282.05,47.27 281.04,47.27 280.95,47.36 280.95,47.79 281.16,47.99 283.21,47.99 283.57,48.35 287.81,48.35
GND on TOP (solid shape): 317.1,101.59 318.6,101.59 319.05,101.14 319.05,99.58 318.85,99.38 317.13,99.38 317.01,99.49 315.14,99.49 314.72,99.08 313.52,99.08 313.42,99.18 313.42,100.12 313.54,100.24 313.54,101.33 314.1,101.89 316.8,101.89
GND on TOP (solid shape): 36.27,54.88 36.27,54.24 36.26,54.2 36.22,54.19 35.05,54.19 34.96,54.18 34.86,54.16 34.83,54.16 34.77,54.23 34.77,54.93 34.82,54.98 36.17,54.98
GND on TOP (solid shape): 89.76,94.2 89.76,93.19 89.69,93.13 89.16,93.13 88.97,93.32 85.69,93.32 85.18,92.81 84.31,92.81 84.17,92.96 84.17,93.82 84.3,93.95 85.1,93.95 85.27,94.12 85.27,94.98 85.5,95.21 88.74,95.21
GND on TOP (solid shape): 104.71,81.02 104.71,77.84 104.56,77.69 103.21,77.69 103.17,77.73 103.17,81.19 103.16,81.2 103.16,81.22 103.16,81.29 103.17,81.33 103.21,81.34 104.38,81.34
GND on TOP (solid shape): 157.27,75.15 157.27,74.46 156.81,74.46 156.74,74.52 156.38,74.52 156.27,74.41 156.27,72.48 156.13,72.34 155.91,72.34 155.88,72.37 155.88,74.12 155.59,74.41 155.18,74.41 155.06,74.53 155.06,75.06 155.24,75.24 157.18,75.24
GND on TOP (solid shape): 176.29,180.97 176.29,177.16 176.14,177.01 176.14,176.54 175.97,176.37 175.74,176.37 175.52,176.15 175.52,175.57 175.38,175.43 175.04,175.43 174.87,175.6 174.87,180.82 175.06,181.02 176.24,181.02
GND on TOP (solid shape): 190.08,106.05 190.08,100.9 189.82,100.9 189.81,100.92 189.61,101.08 189.37,101.18 189.33,101.19 189.33,102.38 189.51,102.55 189.51,106.01 189.59,106.08 190.05,106.08
GND on TOP (solid shape): 237.1,149.54 237.1,146.98 237.07,146.96 235.49,146.96 235.48,146.97 235.48,147.89 235.37,147.99 235.1,147.99 234.81,147.7 234.61,147.7 234.44,147.87 234.44,148.07 234.89,148.51 235.45,148.51 235.49,148.55 235.49,149.57 237.07,149.57
GND on TOP (solid shape): 285.12,89.62 285.12,88 284.99,87.87 281.05,87.87 280.95,87.97 280.95,88.89 281.1,89.04 282.65,89.04 282.88,89.27 282.88,89.62 283.01,89.75 284.99,89.75
GND on TOP (solid shape): 301.7,81.01 302.9,81.01 303.05,80.86 303.05,80.35 302.63,79.93 302.63,79.65 302.42,79.44 301.32,79.44 301.14,79.63 301.14,80.38 301.13,80.4 301.12,80.44 301.12,81.19 301.17,81.24 301.48,81.24
GND on TOP (solid shape): 23.72,62.8 23.72,62.01 23.25,61.54 22.97,61.54 22.94,61.57 22.94,61.97 22.9,62 22.9,62.02 22.86,62.08 22.8,62.11 22.79,62.12 22.5,62.4 22.5,62.96 22.66,63.12 23.4,63.12
GND on TOP (solid shape): 34.65,36.13 34.65,35.94 34.7,35.88 36.31,35.88 36.42,35.76 36.42,34.56 36.31,34.44 34.1,34.44 34.02,34.52 34.02,34.54 34,34.88 33.96,35.23 33.96,36.15 34.1,36.28 34.49,36.28
GND on TOP (solid shape): 165.89,80.28 165.89,79.87 165.46,79.44 163.4,79.44 163.02,79.06 157.2,79.06 157.03,79.24 157.03,79.97 157.04,80.01 157.08,80.02 159.57,80.02 159.62,79.97 162.74,79.97 163.15,80.38 165.79,80.38
GND on TOP (solid shape): 165.9,208.29 165.9,206.43 165.85,206.39 164.01,206.39 163.94,206.45 163.94,206.46 163.94,206.66 163.94,206.86 163.94,208.26 163.94,208.32 163.97,208.35 165.84,208.35
GND on TOP (solid shape): 62.83,49.34 62.83,49.14 62.82,49.1 62.82,49.06 62.82,49.02 62.83,48.98 62.83,48.26 62.84,48.25 62.84,47.88 62.77,47.82 62.1,47.82 61.96,47.96 61.96,49.34 62.03,49.41 62.76,49.41
GND on TOP (solid shape): 143.45,137.65 143.45,136.47 143.52,136.4 143.52,136.16 143.37,136.01 142.5,136.01 142.45,135.96 141.06,135.96 140.93,136.09 140.93,137.45 141.34,137.86 143.25,137.86
GND on TOP (solid shape): 301.91,104.15 301.91,103.8 302.77,102.93 302.77,100.78 302.54,100.55 302.19,100.55 301.92,100.28 301.92,99.34 301.84,99.26 301.37,99.26 301.27,99.36 301.27,101.61 301.86,102.2 301.86,103.19 301.37,103.67 301.37,104.13 301.5,104.26 301.81,104.26
GND on TOP (solid shape): 164.59,72.74 164.59,72.19 164.34,71.94 163.22,71.94 163.08,72.08 163.07,72.1 163.07,72.13 163.08,72.18 163.08,72.23 163.07,72.33 163.03,72.43 163.03,72.76 163.2,72.93 164.4,72.93
GND on TOP (solid shape): 188.15,66.21 188.15,66.18 188.16,66.14 188.18,66.1 188.18,65.69 188.05,65.56 187.65,65.56 187.57,65.55 187.5,65.5 187.26,65.26 187.03,65.26 186.96,65.33 186.96,66.55 187.02,66.61 187.75,66.61
GND on TOP (solid shape): 264.47,67.06 264.47,62.27 264.09,61.89 263.6,61.89 263.32,61.61 263.32,61.41 263.07,61.15 262.66,61.15 262.49,61.33 262.49,61.71 262.74,61.96 262.74,62.75 262.89,62.9 262.89,67.08 263.18,67.36 264.17,67.36
GND on TOP (solid shape): 300.18,75.1 300.18,74.74 300.05,74.61 300.05,73.34 300.18,73.22 300.18,72.91 300.41,72.68 300.41,71.87 300.38,71.84 300.21,71.84 299.11,72.94 299.11,73.6 299.72,74.21 299.72,74.66 299.67,74.72 299.67,75.12 299.72,75.17 300.1,75.17
GND on TOP (solid shape): 304.25,76.06 304.25,74.67 303.96,74.38 303.93,74.37 303.88,74.38 303.85,74.38 303.71,74.36 303.58,74.29 303.57,74.28 303.48,74.28 303.38,74.38 303.38,75.96 303.51,76.09 304.22,76.09
GND on TOP (solid shape): 308.2,93.67 308.2,91.36 307.96,91.11 307.77,91.11 307.72,91.17 307.72,93.28 307.26,93.74 307.26,93.74 307.2,93.79 307.17,93.83 307.17,94.19 307.19,94.23 307.22,94.24 307.63,94.24
GND on TOP (solid shape): 182.91,76.06 182.91,75.42 182.85,75.36 182.26,75.36 182.16,75.46 182.16,75.68 181.6,76.24 181.6,76.4 181.6,76.41 181.63,76.49 181.64,76.58 181.63,76.66 181.61,76.74 181.6,76.75 181.6,76.78 181.68,76.86 182.11,76.86
GND on TOP (solid shape): 190.39,61.35 190.39,58.41 189.45,57.47 186.85,57.47 186.69,57.63 186.68,57.66 186.68,57.68 186.68,58.07 186.68,58.1 186.67,58.13 186.67,58.16 186.76,58.25 188.07,58.25 188.25,58.43 189.12,58.43 189.62,58.93 189.62,61.29 189.87,61.53 190.2,61.53
GND on TOP (solid shape): 253.19,139.03 253.19,138.34 252.89,138.04 252.33,138.04 251.89,137.61 251.11,137.61 250.99,137.72 250.99,138.69 251.44,139.13 251.59,139.13 251.67,139.05 252.45,139.05 252.5,139.1 252.5,139.1 252.58,139.16 252.64,139.24 252.66,139.26 252.96,139.26
GND on TOP (solid shape): 266.03,206.57 266.03,205.32 266.18,205.17 266.47,205.17 266.5,205.19 268.46,205.19 268.53,205.12 268.53,204.89 268.42,204.78 268.42,204.12 268.66,203.88 268.66,203.34 268.53,203.21 266.88,203.21 266.8,203.29 266.8,203.3 265.16,204.95 265.16,206.51 265.29,206.64 265.96,206.64
GND on TOP (solid shape): 39.69,44.05 39.69,41.82 39.85,41.66 39.96,41.66 40.71,41.66 40.75,41.65 40.76,41.61 40.76,41.55 40.79,41.52 40.79,41.45 40.76,41.42 39.66,41.42 39.65,41.43 37.04,41.43 37,41.48 37,44.04 37.06,44.1 39.63,44.1
GND on TOP (solid shape): 48.31,94.68 48.31,94.22 48.16,94.07 48.16,93.59 47.93,93.36 47.93,92.01 47.83,91.91 47.45,91.91 47.27,92.09 47.27,92.34 47.33,92.4 47.42,92.47 47.49,92.56 47.6,92.67 47.6,94 47.62,94.01 47.62,94.49 47.91,94.78 48.21,94.78
GND on TOP (solid shape): 129.47,73.69 132.91,73.69 133.25,74.03 134.85,74.03 135.11,73.78 135.11,73.3 134.8,73 134.8,72.61 134.68,72.48 133.23,72.48 132.95,72.76 129.72,72.76 129.4,72.44 126.75,72.44 126.54,72.65 126.54,73.83 126.77,74.05 129.11,74.05
GND on TOP (solid shape): 139.09,42.13 146.61,42.13 146.63,42.12 147.73,41.01 147.73,39.04 147.73,39.03 147.27,38.57 133.15,38.57 133.14,38.58 133.03,38.69 133.02,38.7 133.02,39.74 132.87,39.9 131.4,39.9 131.09,40.2 131.09,45.82 131.35,46.08 135.14,46.08
GND on TOP (solid shape): 249.49,136.68 249.49,134.52 249.39,134.43 248.84,134.43 248.71,134.56 248.71,134.81 248.8,134.9 248.93,134.9 248.95,134.92 248.96,134.92 249.13,135.08 249.13,135.25 248.97,135.4 248.55,135.4 248.48,135.47 248.48,135.68 248.53,135.73 248.94,135.73 249.16,135.95 249.16,136.68 249.2,136.72 249.45,136.72
GND on TOP (solid shape): 274.42,82.06 274.42,81.14 274.63,80.94 274.96,80.94 275.62,80.28 275.62,78.83 275.49,78.7 275.34,78.7 275.29,78.75 275.29,80.05 275.01,80.33 274.5,80.33 274.42,80.25 273.51,80.25 273.28,80.48 273.28,80.76 273.66,81.14 273.84,81.14 274.04,81.34 274.04,82.06 274.09,82.11 274.37,82.11
GND on TOP (solid shape): 22.84,93.84 22.84,93.16 22.61,92.93 18.47,92.93 18.25,92.94 17.99,92.94 17.94,93 17.94,93.16 17.96,93.18 21.36,93.18 21.47,93.17 21.57,93.18 21.69,93.18 21.92,93.41 21.92,93.87 22.05,93.99 22.69,93.99
GND on TOP (solid shape): 143.12,72.84 143.14,72.83 146.7,72.83 146.94,73.06 148.8,73.06 149.03,72.84 149.03,71.64 148.85,71.46 147.09,71.46 146.7,71.86 143.53,71.86 143.23,71.57 140.39,71.57 140.2,71.76 140.2,72.82 140.49,73.11 142.85,73.11
GND on TOP (solid shape): 236.91,44.18 236.91,40.63 235.26,38.98 235.26,37.4 234.92,37.07 234.92,36.33 234.62,36.03 226.18,36.03 226.09,36.12 226.09,37.88 226.22,38.01 230.1,38.01 230.33,37.78 232.39,37.78 232.54,37.63 232.54,37.38 232.8,37.11 233.94,37.11 234.04,37.22 234.04,43.83 234.8,44.59 236.5,44.59
GND on TOP (solid shape): 249.58,217.54 250.18,217.54 250.19,217.53 250.19,217.35 250.18,217.34 249.8,217.34 249.68,217.22 249.68,216.8 249.56,216.68 249.17,216.68 249.11,216.74 248.75,216.74 248.68,216.67 248.59,216.67 248.52,216.74 248.52,217.67 248.54,217.69 249.43,217.69
GND on TOP (solid shape): 52.1,72.58 54.08,72.58 54.39,72.27 57.4,72.27 57.4,72.27 57.61,72.48 58.22,72.48 58.25,72.51 59.82,72.51 60.05,72.28 60.05,71.54 59.71,71.2 57.85,71.2 57.7,71.35 53.97,71.35 53.66,71.03 50.5,71.03 50.35,71.18 50.35,72.45 50.52,72.63 52.05,72.63
GND on TOP (solid shape): 306.11,67.84 306.13,67.83 306.14,67.82 306.25,67.71 306.9,67.71 306.9,67.71 306.94,67.71 306.96,67.68 306.96,67.43 306.3,66.76 305.13,66.76 304.96,66.94 304.96,67.13 304.96,67.33 304.96,67.53 304.96,67.7 305.09,67.84
GND on TOP (solid shape): 137.28,54.51 137.28,53.83 137.34,53.77 137.34,53.05 137.54,52.85 137.54,49.16 137.58,49.13 137.58,48.76 137.67,48.67 137.67,47.52 137.62,47.46 136.35,47.46 136.15,47.66 136.15,49.47 135.65,49.96 134.95,49.96 134.72,50.19 134.72,52.5 135.3,53.08 135.3,53.42 136.5,54.62 137.16,54.62
GND on TOP (solid shape): 168.11,76.58 168.12,76.57 168.16,76.43 168.25,76.32 168.27,76.29 168.27,75.61 168.22,75.57 167.76,75.57 167.34,75.98 167.34,76.22 167.34,76.42 167.34,76.56 167.36,76.58 167.36,76.82 167.42,76.88 167.82,76.88
GND on TOP (solid shape): 47.73,98.31 47.73,97.37 47.63,97.27 45.44,97.27 45.27,97.09 45.27,96.2 44.88,95.82 43.11,95.82 42.83,95.54 42.83,94.86 41.07,93.1 41.07,92.8 41,92.72 40.39,92.72 40.34,92.77 40.34,93.59 40.54,93.79 40.74,93.79 41.07,94.12 41.43,94.12 42.24,94.93 42.24,95.49 42.95,96.2 42.95,98.21 43.18,98.44 47.6,98.44
GND on TOP (solid shape): 60.87,55.22 60.89,55.22 61.03,55.13 61.18,55.1 61.28,55.12 61.37,55.15 61.4,55.16 61.43,55.14 61.66,54.92 61.66,52.24 61.5,52.08 59.72,52.08 59.58,52.22 59.58,55.09 59.71,55.22
GND on TOP (solid shape): 166.4,142.61 166.4,142.23 166.27,142.1 164.77,142.1 164.63,141.96 164.01,141.96 163.87,142.1 163.38,142.1 163.12,141.85 163.12,139.99 158.31,139.99 157.97,140.33 157.97,142.36 158.2,142.6 163.24,142.6 163.3,142.66 163.71,142.66 163.87,142.5 164.57,142.5 164.73,142.66 165.74,142.66 165.79,142.71 166.3,142.71
GND on TOP (solid shape): 252.33,121.15 252.33,120.99 252.45,120.87 253.01,120.87 253.46,120.42 253.46,119.89 252.95,119.38 252.8,119.38 252.61,119.19 252.61,118.66 252.78,118.48 252.78,118.15 252.73,118.1 252.43,118.1 252,118.53 252,121.15 252.05,121.2 252.28,121.2
