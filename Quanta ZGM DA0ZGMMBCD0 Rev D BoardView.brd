# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+VCC_V1P05EXT_1P05: length 1.4
  TOP w0.14: v1(217.75,65.81) 217.52,65.58 R480.1
  BOTTOM w0.254: U49.AN28 217.69,65.81 v1(217.75,65.81)
+VCC_VNNEXT_1P05: length 1.5
  TOP w0.14: R487.1 217.48,65.04 v1(217.74,64.78)
  BOTTOM w0.254: U49.AN29 217.35,65.16 v1(217.74,64.78)
+VCCIN_AUX: length 31.7
  IN2 w0.508: v1(170.15,205.1) 170.15,206.03 170.95,206.82 170.95,209.34 169.68,210.61 169.68,212.37 167.04,215 166.73,215
  IN3 w0.508: v1(170.15,205.1) 170.15,202.94 171.68,201.41 171.68,199.15 172.65,198.18 172.65,192.76 173.87,191.54 173.87,189.37 172.24,187.75
  vias: v1(164.84,158.46) v1(164.84,157.7) v1(164.84,156.93) v1(165.48,158.46) v1(165.48,157.7) v1(165.48,156.93) v1(166.07,215.66) v1(166.05,215) v1(173.33,175.41) v2(144.67,136.26) v2(145.45,136.24) v2(145.48,135.49) v2(157.37,149.71) v2(158.14,149.71) v2(158.56,148.42) v2(158.9,149.71) v2(159.33,148.42) v2(159.67,150.36) v2(159.67,149.71) v2(160.44,149.71) v2(160.86,148.42) v2(161.63,148.42) v2(161.97,149.71) v2(162.91,146.89) v2(163.4,148.95) v2(163.51,152.96) v2(163.51,151.01) v2(163.51,149.71) v2(163.56,146.89) v2(163.56,145.89) v2(163.56,143.51) v2(164.21,145.89) v2(164.21,144.67) v2(164.28,154.27) v2(164.28,153.62) v2(164.28,152.96) v2(164.28,152.31) v2(164.28,151.66) v2(164.28,151.01) v2(164.28,150.36) v2(164.28,149.71) v2(164.28,149.06) v2(164.23,148.19) v2(164.22,143.58) v2(164.88,148.23) v2(164.86,146.89) v2(164.86,144.64) v2(164.85,143.58) v2(165.04,154.26) v2(165.04,153.61) v2(165.04,152.96) v2(165.04,151.66) v2(165.04,150.36) v2(165.04,149.71) v2(165.04,149.06) v2(165.51,145.93) v2(165.51,143.71) v2(165.52,148.2) v2(165.81,152.31) v3(168.87,175.13) v3(169.16,174.44) v3(169.35,177.01) v3(169.54,180.7) v3(169.68,175.16) v3(169.91,174.36) v3(169.93,178.78) v3(170.15,176.9) v3(170.35,180.68) v3(170.47,179.88) v3(170.43,177.6) v3(170.49,176.07) v3(170.49,175.31) v3(170.61,179.12) v3(170.61,178.36) v3(170.63,174.57) v3(170.88,182.12) v3(170.83,181.37) v3(170.91,176.84) v3(171.11,180.68) v3(171.19,177.6) v3(171.24,179.88) v3(171.25,176.07) v3(171.25,175.31) v3(171.37,179.12) v3(171.37,178.36) v3(171.67,176.84) v3(171.72,182.17) v3(171.76,181.42) v3(171.88,180.68) v3(172,179.88) v3(171.96,177.6) v3(172.01,176.07) v3(172.13,179.12) v3(172.13,178.36) v3(172.43,176.84) v3(172.64,180.68) v3(172.76,179.88) v3(172.72,177.6) v3(172.89,179.12) v3(172.89,178.36) v3(173.11,176.47) v3(173.4,180.68) v3(173.36,177.19) v3(173.57,178.74) v3(174.16,180.68) v3(174.3,176.89) v3(174.33,178.72)
+VCCIO_OUT: length 20.2
  IN1 w0.508: v1(181.21,158.86) 182.22,158.86 184.49,156.6 184.49,153.68 v1(185.52,152.65)
  IN4 w0.508: v1(181.21,158.86) 179.86,158.86 178.54,160.18 176.71,160.18 176.2,159.68 176.2,159.51 v1(176.17,159.47)
  BOTTOM w0.254: U42.G35 172.37,150 176.47,150 177.5,151.03
  vias: v1(185.87,149.71)
+VCCPRIM_1P05_OUT:
  vias: v1(214.89,70.22) v1(215.55,70.22) v1(216.19,69.19)
+VCCST: length 347
  TOP w0.508: v1(113.92,127.56) 112.62,127.56 108.78,123.72 108.78,116.93 110.08,115.64 110.08,113.3 110.59,112.78 110.59,104.77 109.67,103.85 109.67,97.96 108.16,96.44 108.16,84.45 107.23,83.53 107.23,76.74 106.76,76.26 106.76,73.61 106.29,73.14 106.29,70.75 106.76,70.28 106.76,68.64 v1(108.21,67.19) ; v1(124.23,143.73) 122.78,143.73 118.51,148 118.51,158.85 109.47,167.89 109.47,195.5 110.51,196.54 110.51,203.06 112.78,205.34 112.78,207.32 115.85,210.39 115.85,213.14 116.97,214.27 116.97,215.18 118.54,216.75 v1(119.51,216.75)
  TOP w1.016: 183.75,156.68 184.39,156.68 187,159.29 187,159.61 191.1,163.71 192.45,163.71 194.64,165.9 194.64,167.25 194.87,167.48 194.87,177.53 197.45,180.11 203.78,180.11 204.83,179.06 205.62,179.06
  IN2 w0.508: v1(124.23,143.73) 124.23,143.3 114.51,133.57 114.51,128.41 113.92,127.81 v1(113.92,127.56) 113.93,127.55 123.62,127.55 126.82,124.35 171.78,124.35 174.93,127.5 174.93,129.43 175.92,130.41 175.92,137.22 172.33,140.81 167.97,140.81 167.46,141.32 v2(167.46,141.39)
  IN3 w0.508: v1(108.21,67.19) 108.73,67.71 122.07,67.71 123.78,69.42 129.17,69.42 129.58,69.83 129.58,70.24 131.04,71.71 138.38,71.71 139.89,73.22 149.92,73.22 150.17,73.47 153.18,73.47 153.26,73.39 155.42,73.39 v1(156.6,72.21)
  BOTTOM w0.203: U42.R22 v2(166.81,142.38)
  vias: v1(182.71,154.74) v1(182.81,155.44) v1(183.06,146.72) v1(206.86,179.08) v1(206.92,179.75) v2(166.81,141.39)
+VCCSTG: length 163.9
  TOP w0.508: v2(172.01,148.25) 176.5,148.25 178.18,146.57 180.27,146.57 185.11,141.73 v1(192.23,141.73) ; v1(231.15,64.26) 231.18,64.23 Q48.2 ; v1(197.38,182.86) 197.32,182.91 196.31,182.91 193.3,179.9 193.3,168.11 192.32,167.13 183.45,167.13 181.98,165.66 v1(181.98,164.24)
  IN1 w0.508: v1(219.61,85.54) 219.61,85.89 220.75,87.03 225.07,87.03 226.52,85.59 231.52,85.59 232.03,85.08 v1(232.03,85.02)
  IN2 w0.508: v1(192.23,141.73) 192.23,131.41 199.34,124.3 202.8,124.3 204.65,122.44 204.65,119.81 209.98,114.49 209.98,108.95 210.25,108.68 v1(210.25,107.96)
  IN4 w0.508: v1(219.61,85.54) 219.61,86.94 219.26,87.29 218.54,87.29 218.21,86.96 216.11,86.96 215.6,87.46 215.6,92.72 215.74,92.87 215.74,98.07 215.02,98.79 215.02,103.77 213.28,105.51 213.28,106.38 212.77,106.89 210.94,106.89 210.25,107.59 v1(210.25,107.96)
  BOTTOM w0.508: v1(231.15,64.26) 231.15,66.8 231.63,67.28 231.63,68.53 232.5,69.39 232.5,71.81 231.67,72.64 231.67,77.31 232.49,78.13 232.49,83.91 232.03,84.37 v1(232.03,85.02)
  vias: v2(168.11,148.25) v2(168.11,149.71) v2(168.88,149.71) v2(169.65,149.71) v2(171.36,148.25)
+VCCSTG_12: length 1.2
  BOTTOM w0.254: U42.P17 167.57,138.9 v2(167.46,139.05) ; U42.R17 v2(166.81,139.05)
+VCCSTG_OUT_1: length 0.6
  BOTTOM w0.254: U42.T17 v2(166.16,139.05)
+VCCSTG_OUT_23456:
  vias: v2(166.16,137.81) v2(166.61,136.88) v2(166.81,137.81) v2(167.24,136.84) v2(167.88,136.84)
+VDD_DCI: length 3.5
  TOP w0.14: U24.5 19.41,66.97 19.34,67.03 v1(19.34,67.16)
  BOTTOM w0.381: v1(18.55,67.53) 18.92,67.16 v1(19.34,67.16) 19.34,67.03 19.46,66.92 C767.1 18.85,66.56 18.62,66.33 R981.2
+VDDQ: length 1
  BOTTOM w0.203: PR652.1 114.31,42.13 PC511.1
+VIN: length 253.6
  TOP w0.508: v1(277.69,76.84) 277.69,76.72 277.8,76.62 277.8,74.81 279.92,72.69 280.82,72.69 281.06,72.92 281.92,72.92 282.42,72.42 282.42,71.78 284.99,69.21 284.99,68.42 285.53,67.88 286.57,67.88 287.26,68.57 v1(287.26,68.82) ; PR344.1 v1(34.67,38.23)
  IN1 w0.508: v3(183.16,182.11) 184.37,182.11 187.31,185.04 198.68,185.04 202.9,189.26 205.92,189.26 207.85,187.33 212.02,187.33 213.08,188.39 217.89,188.39 218.09,188.19 237.61,188.19 237.85,187.95 241.94,187.95 241.94,187.94 253.85,187.94 254.19,188.29 263.86,188.29 265.07,189.5 269.48,189.5 270.88,190.89 v1(274.42,190.89)
  IN3 w0.508: v1(277.69,76.84) 277.69,77.54 278.93,78.77 281.96,78.77 282.53,79.34 282.53,81.67 284.38,83.53 289.16,83.53 290.96,85.33 292.05,85.33 293.25,86.53 293.25,87.55 294.01,88.31 294.01,89.7 295.03,90.73 v1(295.03,94.22) ; v1(297.06,63.97) 297.12,64.03 297.12,68.37 296.01,69.48 293.7,69.48 293.19,68.97 288.47,68.97 288.31,68.82 v1(287.26,68.82) 287.2,68.76 287.2,67.49 286.3,66.59 285.7,65.99 285.7,60.14 285.96,59.88 285.96,58 285.1,57.15 285.1,55.49 282.05,52.44 278.64,52.44 277.87,51.67 273.78,51.67 273.43,51.31 270.26,51.31 268.09,49.14 259.92,49.14 v1(259.26,48.48) ; v1(34.67,38.23) 34.67,38.75 35.38,39.46 36.28,39.46 37.47,40.65 39.55,40.65 40.29,41.4 40.29,44.08 43.33,47.12 v3(44.47,47.12)
  IN4 w0.508: v1(297.06,63.97) 298.14,65.06 303.99,65.06 305.22,66.29 v1(305.22,66.3) ; v1(259.26,48.48) 258.55,47.78 251.14,47.78 248.82,45.45 v3(248.35,45.45)
  BOTTOM w0.203: v1(305.22,66.3) 305.24,66.29 305.24,65.88 305.36,65.76 R985.1 ; R728.1 282.37,194.98 281.87,194.48
  BOTTOM w0.254: v3(100.61,116.93) 100.54,116.86 C873.1
  BOTTOM w0.508: v1(295.03,94.22) 295.55,94.22 296.01,94.68 PR669.1 ; 281.87,194.48 281.65,194.25 281.65,192.4 280.47,191.22 279.21,191.22 278.9,191.54 277.99,191.54 277.35,190.89 v1(274.42,190.89)
  vias: v1(50.07,47) v1(63.94,60.62) v1(119.18,56.96) v1(119.71,57.44) v1(192.64,168.36) v1(278.06,183.48) v1(278.06,182.77) v1(278.77,183.99) v1(278.77,183.33) v1(278.77,182.67) v3(44.23,47.91) v3(44.49,46.35) v3(45,47.89) v3(45.28,47.14) v3(45.29,46.38) v3(45.77,47.93) v3(48.67,49.39) v3(48.66,48.64) v3(49.43,49.39) v3(49.42,48.64) v3(50.19,49.39) v3(50.24,48.63) v3(50.96,49.39) v3(51.02,48.62) v3(51.72,49.39) v3(51.82,48.6) v3(52.44,49.77) v3(52.62,49) v3(53.23,49.76) v3(53.47,49.05) v3(86.46,89.75) v3(86.48,88.96) v3(87.25,89.76) v3(87.27,88.97) v3(100.56,118.58) v3(100.59,117.74) v3(101.48,118.66) v3(101.58,117.77) v3(101.55,116.93) v3(102.42,118.66) v3(102.42,117.77) v3(102.42,116.93) v3(103.28,118.68) v3(103.25,117.82) v3(103.25,116.93) v3(112.73,170.22) v3(112.86,169.33) v3(113.06,174) v3(113.06,173.24) v3(113.06,172.48) v3(113.06,171.69) v3(113.03,170.9) v3(113.48,170.3) v3(113.85,173.62) v3(113.87,172.84) v3(113.9,172.02) v3(113.92,171.18) v3(121.03,40.5) v3(121.89,40.44) v3(137.49,202.67) v3(137.49,201.91) v3(138.27,202.69) v3(138.29,201.91) v3(138.36,205.11) v3(138.37,204.32) v3(138.36,203.53) v3(139.07,202.67) v3(139.07,201.88) v3(139.14,205.1) v3(139.15,204.29) v3(139.13,203.53) v3(143.11,56.2) v3(143.11,55.31) v3(144.1,56.2) v3(144.1,55.31) v3(148.47,56.22) v3(148.47,55.33) v3(164.89,54.31) v3(164.91,55.13) v3(167.49,203.2) v3(167.53,55.45) v3(167.8,202.47) v3(168.26,203.78) v3(168.29,55.45) v3(168.33,203.01) v3(168.31,201.83) v3(169.29,54.87) v3(169.25,54.12) v3(181.46,180.56) v3(181.46,179.79) v3(181.46,179.03) v3(181.51,181.34) v3(182.35,182.11) v3(182.35,181.29) v3(182.35,180.53) v3(182.35,179.77) v3(182.35,179.01) v3(183.11,181.29) v3(183.11,180.53) v3(183.11,179.77) v3(183.11,179.01) v3(246.27,44.89) v3(247.06,44.89) v3(247.85,44.89)
+VIN_GPU_TOTAL: length 33.6
  TOP w0.254: v1(224.72,191.9) 224.39,191.9 223.57,191.08 223.57,190.79 223.3,190.52 R64.1
  IN1 w0.254: v3(227.67,200.98) 226.44,199.75 226.44,192.76 225.8,192.11 224.92,192.11 v1(224.72,191.9)
  IN3 w0.508: v1(255.04,215.96) 255.5,215.96 256.25,215.22 256.25,213.02 255.71,212.48 254.59,212.48 252.41,210.3 250.87,210.3 250.22,209.65 246.73,209.65 246.04,208.97 v1(246.04,208)
  BOTTOM w0.203: PR437.2 229.57,199.48 PR435.2
  BOTTOM w0.508: v1(255.04,215.96) 254.26,215.96 PR352.1
  vias: v1(237.49,208.05) v1(238.15,208.04) v1(238.87,208.03) v1(239.57,208.04) v1(245.38,208.03) v3(228.46,200.99) v3(229.22,200.99) v3(229.98,200.99) v3(230.75,200.99) v3(231.51,200.99) v3(256.24,208.37) v3(256.8,208.88) v3(257.36,208.32) v3(257.86,208.88) v3(258.42,208.37) v3(258.98,208.88) v3(259.21,208.12) v3(260.02,208.53) v3(260.79,208.45) v3(261.56,208.46)
+VIN_PANEL_R:
  vias: v1(271.29,183.89) v1(272.09,184.19) v1(272.8,183.86)
+VIN_SRC: length 290
  TOP w0.14: v1(41.59,50.06) 41.59,49.74 42.15,49.18 PD3.1 42.15,48.74 42.01,48.6 41.81,48.6 41.4,49.01 36.72,49.01 PR316.1 ; v1(100.85,58.88) 103.14,61.16 103.14,66.18 105.74,68.78 105.74,69.85 105.26,70.33 105.26,73.56 105.74,74.04 105.74,76.69 106.21,77.16 106.21,81.64 105.03,82.82 105.03,88.86 105.79,89.62 105.79,96.08 v1(101.56,100.32)
  IN1 w0.086: v1(114.94,161.48) 114.54,161.08 114.54,158.73 119.04,154.23 119.04,144.79 118.12,143.87 118.12,141.04 114.53,137.45 114.53,134.97 114.99,134.51 114.99,130.07 110.7,125.78 110.7,112.9 108.72,110.92 108.72,108.16 107.52,106.96 107.52,106 107.09,105.57 107.09,105.56 101.86,100.32 v1(101.56,100.32)
  IN2 w0.089: v1(191.37,187.69) 191.37,186.94 187.37,182.94 187.37,174.95 v1(186.82,174.4)
  IN3 w0.089: v1(41.59,50.06) 42.84,51.31 58.15,51.31 60.8,48.66 71.89,48.66 73.14,49.91 73.14,51.15 77.08,55.09 94.6,55.09 97.92,58.41 100.38,58.41 v1(100.85,58.88)
  IN4 w0.086: v1(114.94,161.48) 115.37,161.48 118.52,164.63 118.52,169.33 120.47,171.28 153.87,171.28 154.54,171.95 171.17,171.95 173.41,174.18 176.01,174.18 176.1,174.27 177.07,174.27 177.46,173.88 186.29,173.88 v1(186.82,174.4)
  BOTTOM w0.14: PR507.1 187.23,174.81 v1(186.82,174.4)
  vias: v3(189.66,196.43) v3(190.07,195.72) v3(190.48,196.43) v3(190.91,195.72) v3(191.24,196.43) v3(191.67,195.72) v3(192,196.43) v3(192.43,195.72) v3(192.76,196.43) v3(193.2,195.72) v3(193.53,196.43) v3(193.96,195.72) v3(194.29,196.43) v3(194.72,195.72) v3(195.05,196.43) v3(195.48,195.72) v3(195.81,196.43) v3(196.24,195.72) v3(196.57,196.43) v3(197.01,195.72) v3(197.34,196.43) v3(197.77,195.72) v3(198.1,196.43) v3(198.53,195.72) v3(198.86,196.43)
+VIN_VCC_CORE: length 23.6
  IN1 w0.508: v3(116.84,197.96) 114.43,197.96 112.75,199.63 112.75,200.09 111.49,201.35 111.49,202.94 112.19,203.64 112.19,206.23 115.5,209.54 115.5,213.91 v1(116.11,214.52)
  BOTTOM w0.254: PR376.1 114.92,214.01 115.43,214.52 v1(116.11,214.52)
  vias: v1(130.12,208.9) v1(130.13,208.18) v1(130.12,207.46) v1(130.96,208.94) v1(130.97,208.22) v1(130.96,207.49) v1(131.77,208.93) v1(131.78,208.21) v1(131.77,207.48) v1(132.66,208.92) v1(132.67,208.2) v1(132.66,207.48) v1(133.47,208.92) v1(133.48,208.2) v1(133.47,207.48) v1(134.31,208.93) v1(134.32,208.21) v1(134.31,207.48) v1(135.09,207.42) v1(135.18,208.93) v1(135.19,208.21) v3(116.84,197.07) v3(117.48,196.43) v3(126.5,197.96) v3(126.5,197.07) v3(127.13,196.43) v3(136.15,197.96) v3(136.15,197.07) v3(136.78,196.43) v3(145.8,197.96) v3(145.8,197.07) v3(146.43,196.43) v3(155.45,197.96) v3(155.45,197.07) v3(156.09,196.43) v3(165.1,197.96) v3(165.1,197.07) v3(165.74,196.43)
+VIN_VCCIN_AUX:
  vias: v1(172.85,198.88)
+VIN_VGACORE: length 27.5
  TOP w0.203: PR102.2 226.98,192.99 227.51,193.51
  TOP w0.508: PR238.2 262,71.6 PC195.1 v1(262,70.91)
  IN4 w0.508: v1(262,70.91) 262,70.57 261.4,69.98 254.6,69.98 250.29,74.28 249.84,74.28 v1(247.3,76.83)
  BOTTOM w0.203: PR444.2 229.54,198.72 PR437.1 ; PR479.1 226.12,192.79 PR474.2
  vias: v1(192.5,160.39) v1(192.5,159.7) v1(193.17,161.09) v1(193.2,160.43) v1(193.22,159.74) v1(193.22,159.09) v1(193.86,161.09) v1(193.88,160.43) v1(193.91,159.74) v1(193.93,159.09) v1(221.36,91.02) v1(221.36,89.88) v1(222.13,89.88) v1(222.25,91.02) v1(223.02,89.88) v1(231.14,91.02) v1(231.14,89.88) v1(231.91,89.88) v1(232.03,91.02) v1(232.79,89.88) v1(240.92,91.02) v1(240.92,89.88) v1(241.68,89.88) v1(241.81,91.02) v1(242.57,89.88) v1(250.7,91.02) v1(250.7,89.88) v1(251.46,89.88) v1(251.59,91.02) v1(252.35,89.88) v1(260.48,91.02) v1(260.48,89.88) v1(261.24,89.88) v1(261.37,91.02) v1(262.13,89.88) v1(270.26,91.02) v1(270.26,89.88) v1(271.02,89.88) v1(271.15,91.02) v1(271.91,89.88) v1(280.29,91.15) v1(280.29,90.01) v1(281.08,91.12) v1(281.05,90.01) v1(281.89,90.51) v1(290.07,91.4) v1(290.1,90.06) v1(290.86,90.06) v1(290.96,91.4) v1(291.16,90.69) v3(227.42,197.22) v3(228.22,197.23) v3(228.98,197.23) v3(230,197.2) v3(230,196.4) v3(230,195.63) v3(230,194.87) v3(230,194.11) v3(230,193.35) v3(230,192.59) v3(230.8,197.21) v3(230.8,196.45) v3(230.8,195.69) v3(230.8,194.93) v3(230.8,194.17) v3(230.8,193.4) v3(230.87,192.57) v3(231.56,197.21) v3(231.56,196.45) v3(231.56,195.69) v3(231.56,194.93) v3(231.56,194.17) v3(231.56,193.4) v3(231.62,192.57) v3(241.68,85.05) v3(242.05,85.74) v3(242.45,85.05) v3(242.81,85.74) v3(243.21,85.05) v3(243.57,85.77) v3(243.97,85.05) v3(244.33,85.73) v3(244.73,85.05) v3(245.16,85.7) v3(245.57,85.03) v3(246.36,84.21) v3(246.38,83.33) v3(246.38,82.51) v3(246.43,85) v3(246.41,81.76) v3(247.12,84.16) v3(247.15,83.33) v3(247.15,82.49) v3(247.23,84.97) v3(247.88,84.24) v3(248.03,84.99)
DVDD_IO: length 30.9
  TOP w0.14: v1(297.89,62.43) 297.73,62.43 297.42,62.12 R517.1 296.93,62.34 C463.2 296.93,63.11 297.65,63.83 U21.12 ; R378.1 R377.1 293.83,74.59 294.03,74.79 Q37.2 Q37.5 294.03,76.77 293.88,76.92 293.17,76.92 v1(292.74,76.49)
  IN3 w0.089: v1(297.89,62.43) 297.89,65.17 297.52,65.54 297.52,68.54 296.11,69.94 293.25,69.94 292.74,69.43 290.35,69.43 289.63,70.15 289.63,71.89 291.98,74.23 291.98,75.17 292.36,75.55 292.36,76.11 v1(292.74,76.49)
GND: length 3708.1
  TOP w0.14: v2(203.5,149.33) 203.74,149.08 CG196.2 ; v1(22.07,63.61) 21.98,63.7 U24.31 ; PC167.2 131.19,75.78 130.82,76.15 v1(130.8,76.15) 130.43,75.78 PC166.2 ; PR43.2 263.09,211.82 263.09,211.54 263.33,211.31 v1(263.33,211.31) ; PU11.11 PU11.15 ; R53.1 277.23,201.96 277.36,201.83 v1(277.36,201.14) ; PU12.11 PU12.15 ; PC47.2 228.24,191.94 v1(228.33,191.85) ; v1(12.16,79.51) 12.17,79.52 D22.3 ; R405.2 217.8,72 v1(218.02,72) ; 159.37,136.42 159.32,136.47
  TOP w0.178: v1(146.28,206.06) 146.15,206.06 145.62,206.59 U1.9 ; 36.82,71.05 U16.B1 ; 36.82,71.05 36.36,71.05 U16.B2 ; 36.82,71.05 v2(37.44,71.05) ; U24.13 16.48,64.9 v1(16.26,64.68) ; C525.2 21.64,48.37 21.78,48.23 v1(22.14,48.23) ; C183.1 147.04,97.67 147.18,97.53 v1(147.7,97.53) ; v2(37.44,71.97) 37.22,71.96 U16.D1 U16.D2 ; R1215.2 162.66,201.34 162.54,201.46 v1(162.33,201.46) 162.31,201.43 162.31,201.16 162.69,200.77 R1216.2 ; v1(17,77.31) 17.08,77.39 U15.10 ; v2(31.05,73.8) 31.06,73.81 U16.H12 U16.H11 ; v1(169.76,207.66) 169.76,207.75 169.29,208.22 PR70.2 ; U9.H11 U9.H12 v2(35.66,91.08) ; v1(164.3,213.67) 164.3,213.67 163.93,213.67 PR28.1 ; v2(42.21,90.16) U9.F1 U9.F2 ; v2(42.21,89.24) 41.79,89.24 U9.D1 U9.D2 ; U9.B11 U9.A11 36.79,87.73 36.55,87.48 v2(35.89,87.48) ; 41.39,88.32 U9.B1 ; 41.39,88.32 v2(42.01,88.32) ; 41.39,88.32 40.94,88.32 U9.B2 ; R1217.2 246.69,208.75 246.87,208.57 v1(246.94,208.57) ; U16.F2 U16.F1 v2(37.37,72.88) ; U16.K2 U16.K1 37.3,74.73 v2(37.49,74.73) ; U9.K2 U9.K1 41.87,92 v2(42.17,92) ; U8.10 18.73,94.07 v1(18.65,93.99) ; U16.B11 U16.A11 32.22,70.45 31.88,70.11 v2(31.67,70.11)
  TOP w0.203: R676.2 18.35,7.99 v1(18.16,8.19) ; U16.J9 v2(32.66,74.74) ; PR248.2 267.64,71.75 267.86,71.97 v1(267.86,72.24) ; CG283.1 247.05,139.13 v2(247.3,138.88) ; v1(127.54,216.85) 127.05,216.85 126.85,216.65 PR2.1 ; C164.2 154.91,101.82 v1(155.25,101.49) ; v1(185.19,161.31) 184.82,160.95 184.53,160.95 184.38,161.1 R91.1 ; v1(221.89,57.39) 222.2,57.08 U28.3 ; v1(13.86,93.51) 13.7,93.67 R160.2 ; RG27.2 RG26.2 267.25,153.97 266.98,153.7 v2(266.98,153.68) ; CG287.1 230.4,138.77 v2(230.5,138.87) ; CG119.1 249.65,157.25 249.95,157.56 v2(249.95,158.04) ; 11.05,81.5 11.45,81.89 v1(11.45,82.02) 11.49,81.97 R266.1 ; 33.39,80.07 33.39,78.68 33.51,78.56 33.51,77.34 v2(33.61,77.24) ; v1(12.6,83.3) 12.4,83.5 R253.1 ; CG172.2 270.12,151.56 v2(269.99,151.42) ; R547.1 216.4,60.28 216.08,60.59 ; C275.2 130.02,86.66 v1(129.95,86.59) ; R259.2 314.03,83.27 v1(314.12,83.27) ; U30.3 210.76,45.03 210.57,44.84 210.57,44.41 209.93,43.78 v1(209.79,43.78) 209.56,44 R633.2 ; v2(30.92,74.78) 30.98,74.73 U16.K12 U16.K11 ; CG70.2 217.63,172.81 218.15,172.3 v2(218.15,172.27) ; v1(11.2,90.21) 11.31,90.31 C242.1 ; v1(11.2,90.21) 11.41,90.01 R183.1 ; v1(11.2,90.21) 10.9,90.21 10.54,90.56 C241.1 ; v1(299.47,89.42) 299.57,89.53 C244.2 ; R194.1 v1(11.12,88.48) ; R194.1 v1(12.37,88.48) ; R194.1 11.81,88.13 v1(12.17,87.77) ; RG65.2 260.28,121.27 261.31,122.3 v1(261.34,122.3) ; R573.1 203.44,56.69 v1(203.17,56.42) ; PC3.2 125.43,213.8 PR29.1 125.44,213.39 125.16,213.11 v2(125.16,212.63) ; R326.2 34.8,78.17 34.8,78.56 v1(34.97,78.73) ; RG43.2 206.54,139.39 v2(206.89,139.73) ; D49.2 19.88,49.32 v1(19.91,49.28) ; D49.2 20.11,49.92 v1(20.41,50.22) ; D49.2 19.88,50.5 v1(19.84,50.54) ; v2(236.1,155.68) 236.51,155.68 236.61,155.78 CG132.1 ; CG284.1 240.39,138.77 v2(240.3,138.87) ; v2(201.25,128.06) 200.99,128.06 200.49,127.55 CG366.2 ; CG134.1 240.76,155.69 240.66,155.58 240.39,155.58 v2(240.3,155.67) ; v2(250.27,183.63) 250.4,183.76 CG8.2 ; v2(246.6,157.07) 246.71,157.18 CG115.1 ; C455.1 306.07,65.2 C450.2 306.07,66.33 C447.2 ; v2(244.52,131.17) 244.14,131.55 RG56.1 ; CG247.2 206.72,143.54 v2(207.25,144.08) ; v2(221.27,180.57) 221.27,180.79 221.05,181.01 CG24.2 ; C93.2 168.94,146.68 v2(169.42,147.16) ; v2(221.25,183.67) 221.36,183.78 CG6.2 ; CG28.2 239.87,180.38 239.52,180.03 v2(239.29,180.03) ; v2(131.76,144.42) 131.97,144.21 C102.2 ; CG96.1 234.44,158.75 v2(234.09,159.11) ; C426.2 C425.2 185.7,69.21 185.56,69.35 185.35,69.35 v1(185.33,69.37) 185.28,69.37 185.21,69.3 U23.91 ; R401.2 C406.2 321.06,70.22 v1(321.11,70.17) ; v1(263.32,119.32) 263.13,119.12 RG77.2 ; C417.2 294.77,68.72 295.14,68.35 v1(295.4,68.35) 295.49,68.44 C418.2 ; v2(166.16,143.71) 165.9,143.45 C105.2 ; v1(303.63,74.51) 303.4,74.27 R383.2 ; v1(147.46,84.08) 147.55,84.17 C295.1 ; CG140.1 239.15,155.42 v2(238.9,155.67) ; C286.2 153.15,85.48 v1(152.9,85.73) ; v1(62.64,91.93) 62.33,91.62 C237.1 ; v2(168.76,148.25) 168.76,148.09 C86.2 ; CG91.2 200.47,159.36 v2(200.49,159.34) ; v2(256.26,178.33) 256.26,178.45 256.36,178.55 256.65,178.55 256.79,178.41 CG43.2 ; CG32.2 217.89,180.32 v2(218.16,180.6) ; v1(165.49,98.32) 165.1,98.32 164.9,98.12 R134.2 ; v2(257.87,172.42) 257.96,172.51 CG69.2 ; CG355.1 245.67,132.77 245.46,132.56 v2(245.2,132.56) ; U16.B12 31.35,71.04 v2(31.16,70.86) ; CG199.1 224.19,148.42 224.33,148.28 224.33,148.09 v2(224.21,147.98) ; v2(249.5,173.8) 249.61,173.8 250.04,173.37 CG65.2 ; v2(266.25,150.59) 266.4,150.75 CG182.2 ; v1(210.57,48.76) 211.53,47.79 C526.2 ; v2(243.34,180.63) 243.5,180.47 CG29.2 ; v1(17.55,80.83) 17.52,80.86 C322.1 R284.1 ; C354.1 10.6,76.61 v1(11.05,76.16) ; v2(273.06,161.94) 273.2,161.8 CG87.2 ; R138.1 v1(12.68,97.5) ; R138.1 v2(12.07,97.94) ; R138.1 v1(11.46,97.5) ; C302.2 153.48,83.79 v1(153.01,83.32) ; R658.1 v1(17.98,25.49) ; C119.2 168.13,141.39 v2(168.18,141.43) ; v2(132.82,154.26) 132.68,154.4 C63.2 ; v2(239.33,176.02) 239.01,176.02 238.81,176.22 CG52.2 ; CG203.2 272,148.12 271.79,148.32 v2(271.48,148.32) ; v2(257.9,179.26) 257.99,179.35 CG35.2 ; CG74.2 196.12,167.82 v1(196.05,167.9) ; v2(253.72,180.25) 253.65,180.18 CG33.2 ; v1(166.44,83.39) 166.76,83.71 C305.2 ; PU17.11 PU17.15 ; D48.2 18.44,49.35 v1(18.4,49.32) ; D48.2 17.95,49.92 v1(17.87,50.01) ; D48.2 18.44,50.35 v1(18.27,50.51) ; v2(274.6,148.32) 274.69,148.23 CG204.2 ; CN2.27 271.26,190.35 v1(271.53,190.08) ; U9.F7 38.22,90.39 v2(37.89,90.71) ; R38.1 145.42,208.98 v1(145.34,208.9) ; R1232.2 310.51,85.89 311.48,86.85 v1(311.48,87.09) ; R285.2 15.22,80.84 v1(15.42,81.04) ; R660.1 22.96,24.26 v1(23.07,24.15) 23.9,24.15 C554.2 ; CG92.1 246.83,159.4 v2(246.6,159.17) 246.5,159.07 CG98.2 ; v1(225.89,204.95) 226.21,204.95 226.74,205.48 PR86.1 ; v2(205,156.25) 205.23,156.01 CG143.2 ; CG51.2 218.86,175.44 v2(218.98,175.32) ; CG47.2 247.99,178.3 v2(247.97,178.32) ; v2(231.9,138.87) 232.04,138.73 CG297.1 ; v2(233.3,137.46) 233.46,137.3 CG310.1 ; U9.L12 35.8,92.46 v2(35.66,92.6) ; R521.1 R522.1 v1(46.72,61.64) ; v1(266,74.71) 266.04,74.67 PC179.2 ; v1(12.68,82.13) 12.53,81.97 R266.1 ; v1(24.02,18.15) 23.42,18.75 R667.2 R666.2 ; U13.C1 46.87,81.37 v1(46.87,81.58) ; C39.2 205.14,183.65 v1(204.72,184.06) ; Q15.1 209.79,183.59 210,183.8 v1(211.91,183.8) ; v2(247.3,144.47) 247.48,144.29 248.23,144.29 248.34,144.4 CG232.1 ; CG118.2 224.2,157.4 224.09,157.5 224.09,157.78 v2(224.15,157.83) ; v2(238.9,138.87) 239,138.77 CG286.1 ; v1(196.78,155.64) 197.1,155.96 CG127.2 ; v1(197.49,161.33) 197.64,161.17 198.28,161.17 CG85.2 ; v1(220.6,77.48) 220.6,77.92 220.87,78.19 R320.2 ; 10.29,81.5 10.29,81.55 v1(10.75,82) ; v2(12.07,84.02) R253.1 ; R253.1 v1(11.43,83.5) ; U16.F9 v2(32.68,73.43) ; R169.1 311.15,92.57 v1(311.26,92.47) ; 299.42,68.4 U21.47 ; CG122.1 232.81,156.66 233.22,157.07 v2(233.3,157.07) 233.37,157.14 233.37,157.4 233.27,157.5 CG108.1 232.84,157.5 232.79,157.55 CG106.2 ; v1(46.51,55.21) 46.51,55.08 46.03,54.6 R607.1 R606.1 ; v2(251.38,181.64) 251.38,182.12 251.58,182.32 CG14.2 ; v2(227.71,140.96) 228.1,141.36 CG260.1 ; v2(131.79,150.66) 131.82,150.7 C71.2 ; CG103.1 241.04,158.33 240.77,158.61 v2(240.77,158.83) ; CG267.1 229.04,140.34 v2(229.1,140.27) ; R623.1 209.3,46.6 v1(208.84,47.06) ; v2(268.86,152.85) 268.51,152.5 RG33.2 RG32.2 ; CG236.2 264.69,144.08 264.36,144.41 v2(264.36,144.81) ; v1(267.11,188.25) 267.11,188.85 266.91,189.05 CN1.26 ; CG222.1 247.74,145.61 v2(248,145.87) ; CG18.2 250.75,181.8 v2(250.27,181.32) ; R659.1 20.63,25.44 19.36,24.17 v1(19.36,24.17) ; v1(207.47,50.03) 207.73,50.28 R617.1 C523.2 ; v1(43.56,84.44) 43.56,84.7 R226.2 ; v2(233.5,175.3) 233.5,175.55 233.3,175.76 CG53.2 ; v2(236.78,180.14) CG34.2 ; v1(307.1,72.47) 306.74,72.11 C400.2 R409.2 ; v1(258.79,210.93) 258.97,211.11 PR45.2 ; CG224.2 200.34,144.95 v2(200.47,144.83) ; v1(39.54,95.97) 39.54,95.74 39.28,95.47 R155.2 ; v1(148.78,86.79) 148.69,86.79 148.08,87.39 C266.2 ; v2(37.27,92.02) 37.57,91.72 U9.J9 ; v2(248,143.78) 248.14,143.78 248.35,143.57 CG248.1 ; D47.2 18.38,54.66 18.49,54.55 v1(18.49,54.45) ; D47.2 18.19,55.06 17.87,54.74 v1(17.87,54.66) ; D47.2 18.38,55.34 18.33,55.39 v1(18.33,55.77) ; v2(31.09,71.99) 31.11,71.96 U16.D12 U16.D11 ; U23.49 175.91,56.45 175.55,56.09 v1(175.51,56.09) 175.51,55.59 176.25,54.86 C516.2 ; v2(240.94,130.4) 241.2,130.65 RG58.1 ; C137.2 164.5,135.68 164.21,135.39 v2(164.21,134.84) ; v2(243.41,178.66) 243.44,178.68 CG37.2 ; CG218.1 246.83,146.06 246.95,146.18 247.15,146.18 247.3,146.04 v2(247.3,145.87) ; v2(227.7,155.67) 227.48,155.45 CG145.1 ; RG10.2 230.08,176.57 v2(229.86,176.35) 230.1,176.1 RG15.2 ; v1(11.05,76.16) 11.21,76.01 R350.1 ; v1(11.05,76.16) 11.43,76.54 C355.1 ; C424.2 215.41,69.23 v1(214.85,68.67) ; v2(247.3,157.08) 247.25,157.12 CG113.1 ; CG217.1 227.51,145.68 v2(227.7,145.87) ; R171.1 317.04,92.45 v1(316.89,92.6) ; v1(279.46,207.32) 279.37,207.41 R42.1 ; v2(248,140.97) 248.31,140.97 CG265.1 ; CG36.2 229.04,179.33 v2(228.85,179.14) ; C298.2 156.92,84.72 156.92,84.85 v1(156.84,84.94) ; v2(201.96,160.13) 201.94,160.16 CG89.2 ; v2(268.55,140.65) 268.55,140.57 268.01,140.03 RG42.2 ; v2(227.7,157.07) 227.64,157.07 CG123.2 ; v2(271.04,161.92) 270.98,161.86 CG88.2 ; R266.1 v1(12.07,81.47) 12.07,81.06 C325.2 ; CG309.1 230.67,137.31 v2(230.5,137.47) ; PC180.2 266.73,74.53 v1(266.65,74.61) ; v2(35.62,88.32) U9.B12 ; CG104.1 238.94,157.76 239.23,157.76 v2(239.37,157.91) 239.75,158.29 CG97.1 ; v1(228.41,60.01) 228.11,60.31 R548.2 ; CG333.2 276.91,134.33 v1(276.85,134.26) ; CG301.1 239.07,137.64 v2(238.9,137.47) ; RG8.2 245.2,177.53 v2(245.84,178.17) ; CG338.2 241.3,133.97 241.23,133.9 240.43,133.9 v2(240.34,133.99) ; v2(250.07,139.56) 250.08,139.55 CG293.1 ; U16.M12 31.22,75.65 v2(30.92,75.94) ; C506.2 211.87,57.28 v2(211.84,57.25) ; CG60.2 232.48,173.8 v2(232.65,173.98) ; PU4.10 162.69,206.56 v1(162.66,206.59) ; v2(247.3,141.67) 247.28,141.69 CG254.1 ; R222.1 39.75,84.8 v1(39.4,84.44) 39.25,84.6 39.25,85.05 39.09,85.21 R221.1 ; RG11.2 227.51,176.55 v2(227.26,176.81) ; v2(237.5,137.47) 237.29,137.26 CG311.1 ; CG336.2 241.9,134.62 v2(241.73,134.79) ; CG155.2 272.92,155.17 v2(273.01,155.27) ; v1(159.13,99.6) 158.97,99.44 158.92,99.44 158.65,99.17 C179.2 ; CG165.1 224.63,153.51 224.15,153.99 v2(224.15,154.2) ; v2(213.19,57.08) 213.33,57.21 C508.2 ; CG142.1 232.37,155.77 232.26,155.87 232.09,155.87 v2(231.9,155.67) ; v2(233.3,155.67) 233.46,155.51 233.69,155.51 233.79,155.61 CG133.1 ; CG81.2 202.45,163.37 202.14,163.06 v2(202.14,162.9) ; PC267.1 37.81,39.37 v2(37.73,39.29) ; v1(29.34,67.17) R442.1 ; CG83.2 271.77,163.06 v2(271.5,162.79) ; C184.2 178.16,98.23 v1(178.21,98.29) ; CG150.1 229.36,154.7 v2(229.1,154.96) ; R532.1 219.55,60.77 219.34,60.56 v1(219.34,60.24) ; C273.2 153.54,87.06 v1(153.74,86.87) ; RG72.2 261.62,118.86 261.62,120.05 262.16,120.59 v1(262.38,120.59) ; v1(270.82,67.98) 271.31,68.48 C432.2 272.25,68.48 272.28,68.45 C433.2 ; v2(133.71,141.86) 133.71,141.8 C115.2 ; CG82.2 200.08,163.47 v2(200.39,163.78) ; PR41.1 224.62,211.85 224.75,211.72 v1(224.75,211.66) 224.47,211.38 PR49.1 ; U16.G7 v2(33.31,74.1) ; R154.2 13.93,95.65 14.13,95.85 v1(14.13,96.12) ; CN2.24 270.54,191.85 270.88,191.5 272.37,191.5 v1(272.51,191.64) ; CG194.2 264.91,149.24 v2(264.73,149.06) ; C345.2 63.05,78.17 v1(62.54,78.68) 62.85,78.99 R307.2 ; PC120.2 198.37,103.76 198.78,103.35 198.78,103.34 199.15,102.97 PR130.2 200.25,102.97 v1(200.36,103.09) ; R1190.1 173.3,55.03 173.96,55.69 v1(173.96,55.72) ; v2(226.49,179.82) 226.43,179.76 CG39.2 ; PR89.1 161.7,205.43 v1(161.34,205.07) ; v1(204.08,188.04) U3.3 ; v1(294.74,106.11) 294.74,105.83 295.43,105.15 PR128.1 ; v2(200.5,130.34) 200.46,130.31 CG362.2 ; v2(237.5,138.87) 237.38,138.75 CG296.1 ; v2(256.26,175.32) 256.27,175.32 RG16.2 ; CG110.2 200.35,157.91 v2(200.43,157.83) ; CG314.1 228.62,136.99 v2(229.1,137.47) ; v2(268.51,143.08) 267.73,142.31 CG253.2 ; PR24.1 233.22,213.9 v1(233.31,213.81) 233.43,213.69 PR34.2 ; v1(156.19,87.97) 155.9,88.26 C258.2 ; R518.2 298.69,62.08 298.5,62.26 v1(298.5,62.65) 298.49,62.65 298.11,63.03 297.46,63.03 C463.1 ; v2(216.45,174.02) 216.28,174.02 215.74,173.49 CG63.2 ; v1(16.66,14.28) 16.48,14.1 R669.1 ; v2(247.23,182.84) 246.94,182.84 246.74,183.04 CG12.2 ; R286.2 72.39,81.34 v1(72.39,81.62) ; R523.1 v1(37.42,61.63) ; CG353.2 241.35,132.92 v2(240.99,132.56) ; v1(165.53,59.54) 165.74,59.75 C492.2 C491.2 ; C468.2 14.29,62.28 v1(13.91,61.91) ; U9.M12 36.11,92.92 35.82,93.21 v2(35.61,93.21) ; C84.2 168.7,148.88 v2(168.88,149.06) ; CN2.7 271.22,200.35 v1(271.55,200.01) ; v2(208.01,150.07) 208.01,150 208.61,149.4 CG192.2 ; U16.F5 34.94,73.14 v2(35.25,73.44) 35.29,73.44 35.59,73.14 U16.F3 ; C277.2 163.68,86.5 163.35,86.17 v1(163.27,86.17) ; CG185.2 267.94,150.01 v2(267.75,149.82) ; PR94.1 232.93,204.29 v1(233.28,204.64) ; v2(200.43,143.33) 200.29,143.19 CG249.2 ; CG208.2 200.56,147.36 200.38,147.18 200.1,147.18 199.98,147.3 v2(199.98,147.49) ; RG78.2 292.01,117.84 v1(291.68,117.51) ; CG99.2 197.72,158.15 197.64,158.06 v1(197.17,158.06) ; R463.2 269.14,66.91 269.27,67.05 v1(269.33,67.05) ; R327.2 36.17,78.57 36.2,78.6 v1(36.2,78.62) ; C374.2 171.71,75.75 172.22,76.26 v1(172.22,76.61) 172.6,76.23 R355.2 ; v1(163.43,99.73) 163.71,100.01 163.71,100.02 C171.2 ; v1(34.9,67.17) 34.93,67.2 R448.1 ; CG153.2 271.39,155 v2(271.63,155.23) ; v2(235.02,181.32) 235.24,181.1 CG26.2 ; CG178.2 274.04,152.09 v2(274.02,152.11) ; C279.2 162.26,86.48 161.83,86.04 v1(161.75,86.04) ; v1(169.01,60.86) 168.99,60.88 168.99,60.88 168.97,60.9 U23.27 ; v2(263.99,141.55) 264.52,141.02 CG266.2 ; R291.1 214.49,80.13 v1(214.49,80.13) ; R216.1 v1(33.91,84.44) ; RG73.2 245.78,118.56 245.98,118.76 v1(245.98,119.29) ; PU13.11 PU13.15 ; v1(31.12,67.17) R444.2 ; C216.1 46.99,92.9 v1(47.15,92.75) ; CG264.2 204.9,141.65 v2(205,141.75) ; C103.2 133.51,144.19 133.06,143.74 v2(133.06,143.65) ; v2(37.26,90.72) 37.26,90.69 U9.F9 ; v2(265.32,140.62) 265.49,140.45 CG278.2 ; v1(211.72,183.1) 211.63,183.19 R77.1 ; v1(196.75,165.9) 197.23,165.9 CG78.2 ; R350.1 11.81,76.32 v1(11.98,76.48) ; R350.1 v1(12.45,76.01) ; v2(243.33,182.05) 243.41,181.97 CG20.2 ; v1(224.92,59.22) 225.53,59.82 R537.1 ; v2(236.1,138.87) 235.95,138.72 CG298.1 ; v2(11.81,73.99) R370.1 ; R370.1 v1(12.4,74.48) ; R370.1 v1(11.23,74.48) ; v2(201.25,134) 201.08,133.83 CG349.2 ; R93.2 169.87,154.91 v1(170.01,154.78) 170.24,154.78 170.31,154.85 R94.2 ; C510.2 20.9,57.77 22.13,58.99 v1(22.13,59.22) 22.13,59.5 C497.2 ; CG55.2 232.52,174.86 v2(232.64,174.74) ; CG16.2 224.66,182.14 v2(224.79,182.01) ; U16.F11 U16.F12 31.09,72.88 31.08,72.9 v2(31.07,72.9) ; CG352.2 234.61,133.12 v2(234.61,133.12) 234.6,133.12 CG351.2 ; CG75.2 197.52,167.27 196.79,167.27 v1(196.74,167.22) ; CG250.2 208.22,142.77 208.45,142.54 v2(208.75,142.54) ; v2(228.93,215.26) 228.7,215.49 228.47,215.49 PR15.2 ; v2(209.54,156.21) 209.54,156.09 209.28,155.83 CG144.2 ; v2(245.9,143.07) 246.38,143.55 CG237.1 ; v2(228.4,149.37) 228.62,149.58 CG188.1 ; v2(265.12,155.15) 264.97,155 CG154.2 ; v2(234.68,157.07) 234.23,157.53 CG114.1 ; C35.2 202.82,183.04 v1(202.69,182.91) ; C140.2 224.01,134.17 v2(223.51,134.67) ; R150.1 v1(12.07,95.49) ; R150.1 11.43,95.97 v1(11.39,95.93) 11.2,95.75 11.2,95.62 C207.1 ; R150.1 12.53,95.97 v1(12.68,96.13) ; v2(251.25,171.72) 251.04,171.72 250.96,171.8 250.62,172.13 CG73.2 ; CG79.2 274.76,164.5 v2(274.58,164.31) ; v1(284.23,86.48) 284.01,86.48 283.98,86.45 PR144.2 ; v1(224.64,65.6) 224.44,65.6 224.16,65.87 R478.2 ; v1(20,56.31) 19.85,56.16 19.85,55.7 19.86,55.7 v1(19.86,55.68) 19.82,55.64 D46.2 19.82,54.38 v1(19.86,54.34) ; CG80.2 197.78,164.27 v1(197.43,164.62) ; C189.1 R147.1 15.94,96.36 v1(15.7,96.11) ; U55.25 272.21,46.07 C536.2 271.4,45.63 271.39,45.65 C535.2 ; PR76.2 234.05,207.85 v1(233.84,207.63) 233.18,208.29 PR67.2 233.18,208.56 PR64.1 ; CG275.2 271.64,140.58 v2(271.48,140.74) ; CG186.1 248.09,150.3 248.56,149.83 CG187.1 248.74,149.5 248.02,148.77 v2(248.02,148.67) ; C444.1 227.46,66.69 C449.2 227.46,65.62 227.66,65.42 228.1,65.42 v1(228.4,65.72) ; v1(123.17,99.66) 123.27,99.55 C177.2 ; CG59.2 218.11,173.87 v2(218.15,173.83) ; v1(216.38,71.38) 216.04,71.05 C409.1 ; R568.1 217.68,57.72 v2(217.87,57.9) ; R39.1 146.66,208.98 v1(146.52,208.84) ; v2(247.19,132.71) 247.55,132.35 CG358.2 ; v1(165.03,82.69) 164.9,82.82 C307.2 ; U9.D11 U9.D12 v2(35.76,89.24) ; v2(268.28,144.73) 268.37,144.82 CG219.2 ; v1(181.77,86.97) 181.89,87.09 C272.2 ; R311.2 v1(71.89,78.32) R331.2 ; R189.1 167.77,88.43 v1(168.01,88.19) ; v2(231.89,137.48) 232.02,137.35 CG307.1 ; CG160.1 227.89,154.08 v2(227.7,154.27) ; CG107.1 231.32,157.55 231.21,157.43 v2(231.21,157.07) ; v2(273.77,155.23) 273.99,155.01 CG156.2 ; v2(163.31,134.84) 163.19,134.95 C139.2 ; C262.2 139.78,87.7 v1(139.64,87.56) ; v2(264.75,157.58) 264.96,157.36 CG116.2 ; C317.2 v1(165.61,80.06) ; v2(229.11,157.07) 229.33,157.29 CG111.1 ; v2(250.1,147.97) 250.1,148.01 249.61,148.49 CG197.2 ; v1(164.29,61.34) 164.72,61.77 C470.1 164.82,61.97 165.18,61.61 R514.1 ; v2(272.78,147.44) 273.1,147.12 CG213.2 ; v2(227.01,142.36) 226.94,142.36 226.77,142.53 CG251.1 ; CG183.1 228.62,151.16 228.92,151.46 v2(229.1,151.46) ; v2(263.34,140.64) 264,139.98 CG280.2 ; v2(37.88,91.37) U9.G7 ; CG112.1 227.67,158.26 v2(228.04,158.64) ; v2(229.1,138.87) 228.99,138.76 CG295.1 ; CG152.2 225.73,154.58 226.03,154.28 v2(226.26,154.28) ; C547.2 218.95,41.49 v1(218.9,41.54) ; U9.F11 U9.F12 35.66,90.16 v2(35.64,90.17) ; v1(23.31,65.43) 23.21,65.43 22.86,65.08 C454.2 ; v2(200.39,134.78) 200.39,134.67 200.19,134.47 CG337.2 ; U2.3 v1(200.52,188.08) ; v2(271.53,151.43) 271.31,151.65 CG173.2 ; v2(241.7,138.89) 241.81,138.77 CG285.1 ; v1(288.99,124.09) 288.83,123.93 PU7.14 288.83,122.87 288.6,122.64 PU7.17 288.6,121.52 288.38,121.29 PU7.6 288.38,119.44 v1(288.49,119.33) ; U16.F7 33.64,73.12 v2(33.32,73.44) ; RG57.1 246.12,131.02 246.27,131.17 v2(246.59,131.17) ; U9.K11 U9.K12 v2(35.66,92) ; RG53.2 277.63,132.39 v1(277.83,132.39) ; R501.2 220.05,63.17 220.1,63.22 R492.1 219.73,63.56 v1(219.56,63.4) ; v2(37.47,73.81) U16.H1 U16.H2 ; C92.2 129.2,147.1 v2(129.12,147.18) ; PR338.2 28.99,39.84 28.76,39.61 v1(27.61,39.61) ; CG312.1 245.49,137.06 v2(245.9,137.47) ; v1(172.82,102.38) 172.98,102.53 C158.2 ; CG64.2 236.03,173.41 236.31,173.69 v2(236.59,173.69) ; v1(10.77,95.92) 10.59,95.92 10.29,95.62 C206.1 ; v2(243.35,182.84) 243.36,182.83 CG13.2 ; CG94.2 273.91,158.87 274.42,158.37 v2(274.61,158.37) 274.77,158.52 CG95.2 ; C551.2 203.66,39.36 203.33,39.36 v1(203.05,39.08) ; v1(160.48,85.99) 160.38,85.99 159.89,86.48 C278.2 ; v2(232.61,154.27) 232.37,154.52 CG151.1 ; v2(234,154.26) 233.79,154.47 CG147.1 ; CG354.1 244.79,133.17 v2(244.84,133.12) ; C300.2 161.75,84.44 v1(160.99,85.21) ; v2(168.11,143.73) 168.11,143.38 167.76,143.03 C108.2 ; v1(203.9,62.37) 203.51,61.98 R513.1 ; D10.3 12.13,93.47 v1(12.15,93.49) ; C187.2 308.68,96.7 v1(308.26,96.28) ; R393.2 216.98,73.2 v1(216.41,73.77) ; C97.2 166.36,144.88 v2(166.21,144.73) ; v1(204.71,182.73) 204.57,182.87 C38.2 ; R300.2 v1(14.85,78.89) ; v2(131.76,145.19) 131.39,144.82 C101.2 ; R297.2 185.8,79.81 R296.2 185.79,79.59 185.65,79.45 v1(185.65,78.96) ; v1(265.81,188.12) 265.43,188.5 265.43,189.35 265.63,189.55 CN1.25 ; CG41.2 246.48,179.19 v2(247.07,179.79) 246.91,179.95 CG31.2 ; v1(11.87,90.53) 11.81,90.48 R183.1 ; v1(162.67,63.99) 162.95,64.28 R489.1 C456.2 ; RG25.2 207.73,155 v2(207.96,154.77) ; CG200.1 228.67,148.42 228.83,148.26 228.83,147.79 228.41,147.37 v2(228.41,147.27) ; v2(168.89,153.63) 168.86,153.6 R97.2 ; v1(88.91,86.41) 89.33,86.83 PR143.2 ; v1(207.5,45.99) 207.78,45.71 C538.2 ; CG262.2 201.98,141.64 v2(202.08,141.74) ; C255.2 v1(71.41,88.48) ; CG268.1 246.05,140.12 v2(245.9,140.27) ; CG27.2 229.13,180.86 v2(228.95,180.68) ; v2(255.5,181.32) 255.4,181.42 255.11,181.42 CG25.2 ; C82.2 133.46,148.76 133.06,148.36 v2(133.06,148.26) ; R218.2 v1(35.69,84.44) ; v2(208.32,140.11) 208.34,140.12 RG41.2 ; v2(227.7,152.87) 228.33,152.24 CG176.1 ; CG198.2 248.72,148.45 v2(248.72,148) ; 30.64,79.33 32.39,77.58 32.39,77.06 v2(32.6,76.86) ; C166.2 149.61,101.97 149.25,102.32 v1(149.08,102.32) ; CG205.1 227.17,147.8 v2(227.7,147.27) ; v2(236.25,133.13) 236,133.38 CG345.2 ; v1(20.73,67.9) 20.46,67.9 20.25,67.7 C443.2 ; R404.1 v1(286.26,72.73) ; CG38.2 255.3,179.6 v2(255.52,179.82) ; CG319.2 242.3,135.74 242.63,136.07 v2(243.1,136.07) ; v2(231.96,160.51) 231.96,159.75 231.66,159.45 CG93.1 ; CG40.2 218.03,178.92 v2(218.18,179.07) ; R663.1 26.87,23.13 v1(27.03,22.97) ; R433.1 220.68,69.48 220.68,68.74 v1(220.86,68.57) ; C289.2 288.2,85.58 v1(288.06,85.71) ; CG263.2 203.63,141.61 v2(203.5,141.75) ; PR251.2 v1(263.56,70.57) ; C156.2 138.32,103.18 v1(138.2,103.07) ; CG235.1 225.34,144.32 224.92,144.74 v2(224.92,145.17) ; CG124.1 225.69,156.26 225.89,156.45 v2(226.06,156.45) ; v1(156.41,99.95) 156.48,99.88 C172.2 ; v2(202.75,129.56) 202.98,129.8 CG363.2 ; U5.C1 54.23,98.89 v1(54.37,99.03) ; CG22.2 239.93,181.68 239.72,181.88 v2(239.34,181.88) ; C473.1 219.2,61.79 219.34,61.93 v1(219.34,62.15) ; C419.2 296.25,69.22 296.29,69.18 v1(296.29,67.91) ; v1(186.33,62.17) 186.05,61.89 C472.2 R520.1 ; v2(205.34,152.48) 205.34,152.59 205.89,153.15 RG28.2 ; v2(236.1,136.07) 235.97,136.2 CG316.1 ; v2(38.23,94.48) 38.13,94.58 38.13,95.67 v1(37.4,96.4) ; v1(279.12,189.74) D6.3 ; C138.2 142.82,135.95 v2(142.52,136.25) ; C434.2 164.87,68.63 164.54,68.3 v1(164.54,68.14) 164.88,68.14 165.08,67.93 C440.2 ; v2(133.71,139.26) 133.76,139.31 C122.2 ; RG31.1 226.41,152.75 226.55,152.89 226.55,153.33 v2(226.29,153.59) ; CG135.1 235.17,155.58 235.07,155.48 234.89,155.48 234.77,155.6 v2(234.7,155.67) ; C308.1 301.98,83.6 v1(302.14,83.75) ; v2(239.43,182.82) 239.24,183.01 CG11.2 ; CG158.2 269.79,154.38 270.31,154.9 270.31,155.64 v2(270.74,156.07) ; CG66.2 221.72,173.36 222.03,173.66 v2(222.32,173.66) ; CG90.2 197.71,159.46 v1(197.56,159.6) ; R670.2 22.2,13.79 21.83,14.16 v1(21.54,14.16) ; v1(163.94,215.28) 163.78,215.12 PR21.1 ; v2(240.29,136.77) 240.13,136.6 CG313.1 ; CG320.2 246.97,135.74 v2(247.3,136.07) 247.76,135.61 CG325.2 ; C549.2 v1(285.64,39.37) ; U9.F3 40.17,90.41 39.86,90.72 v2(39.82,90.72) 39.52,90.41 U9.F5 ; v1(99.81,61.87) 99.89,61.87 100.34,62.31 R504.1 ; v1(166.01,214.33) 166,214.33 165.54,213.88 PR31.2 ; C376.1 178.72,74.61 v1(178.82,74.51) 178.82,74.13 179.11,73.85 U23.104 ; C556.2 C555.2 23.89,22.01 v1(23.37,22.01) ; v2(236.59,171.56) 236.04,172.1 CG71.2 ; CG302.1 244.63,137.6 v2(244.5,137.47) ; v1(196.24,153.16) 196.55,152.85 CG167.2 ; R183.1 12.17,90.01 12.35,90.19 v1(12.37,90.19) ; v2(165.51,146.89) 165.65,147.03 C87.2 ; C40.2 183.93,164.52 v1(183.26,165.19) ; CG175.2 272.92,151.55 v2(273.08,151.39) ; v1(264.75,191.71) 265.36,191.71 265.7,192.05 CN1.20 ; v2(202.06,131.11) 201.86,131.31 CG359.2 ; R301.2 218.04,79.47 218.71,79.47 219.05,79.81 219.05,79.82 v1(219.13,79.9) ; R450.1 36.71,67.23 v1(36.77,67.17) ; CG146.2 196.93,154.93 v1(196.82,154.82) ; U16.L12 31.18,75.19 31,75.36 v2(30.77,75.36) ; v2(225.6,159.17) 225.43,159 CG100.1 ; RG30.1 224.14,152.41 224.14,152.11 v2(224.09,152.07) ; v1(63.27,83.79) 63.27,83.86 63.25,83.88 C294.1 ; CG67.2 254.9,172.9 v2(255.5,172.3) ; U9.G5 v2(39.83,91.35) ; CG86.2 200.08,161.15 199.92,160.99 199.63,160.99 199.46,161.17 v1(199.46,161.37) ; CG46.2 249,177.8 v2(249.52,178.32) ; R96.2 170.37,152.34 v2(170.41,152.31) ; R472.1 160.66,66.38 160.79,66.26 160.8,66.26 v1(160.8,66.25) ; CG323.1 227.36,135.72 v2(227.01,136.07) ; RG71.2 260.5,118.24 260.45,118.19 v1(260.45,118.18) ; CG57.2 226.24,174.81 v2(225.73,175.32) ; v2(227.27,175.33) 227.31,175.28 CG56.2 ; v1(291.72,70.3) 291.87,70.3 292.05,70.12 292.38,70.12 292.58,69.92 C408.2 293.12,69.56 293.3,69.38 C420.2 ; CG321.2 244.07,135.63 v2(244.5,136.06) ; RG44.2 283.47,139.55 v1(283.43,139.59) ; CG190.2 202.72,150 202.03,150.69 v2(202.03,150.82) ; RG14.2 244.12,175.37 243.39,174.64 v2(243.39,174.52) ; v2(230.51,155.66) 230.51,155.67 CG138.1 ; v1(153.99,102.32) 153.87,102.2 C160.2 ; v2(228.85,182.85) 229.06,183.06 CG10.2 ; v2(227.7,138.87) 227.24,139.33 CG282.1 ; R546.1 220.16,60.14 v1(219.81,59.79) ; CG21.2 247.01,181.46 v2(247.2,181.27) ; U9.H2 U9.H1 v2(42.17,91.08) ; R245.2 v1(36.83,82.92) ; v1(299.69,84.45) 299.87,84.27 C303.2 ; RG13.2 248.48,175.82 248.99,175.82 v2(249.5,175.31) ; v2(254.7,183.64) 254.51,183.83 CG7.2 ; C265.2 150.6,87.44 150.28,87.13 150.26,87.13 150.11,86.98 v1(150.06,86.98) ; CG288.1 244.62,138.75 v2(244.5,138.87) ; C552.2 205.43,39.08 v1(205.41,39.07) ; v2(270.98,144.89) 270.83,145.04 CG220.2 ; v1(19.17,9.36) 19.17,9.84 C559.2 ; v1(127.83,103.06) 127.87,103.01 C155.2 ; v2(200.43,128.83) 200.05,129.21 CG364.2 ; R542.1 203.77,60.33 204.44,60.33 204.89,60.78 v1(205.3,60.78) ; PR180.1 253.66,81.62 253.26,82.02 v1(253.26,82.2) ; v1(152.66,101.08) 152.86,100.87 C170.2 ; CG42.2 230.17,178.46 v2(230.51,178.8) 230.71,178.8 230.94,178.57 RG6.2 ; CG233.2 274.93,144.11 v2(274.57,143.74) ; v1(276.38,128) 276.71,128 276.91,127.8 CG365.2 ; PR192.2 267.8,79.08 v1(267.95,78.93) ; v1(40.9,95.87) 40.74,95.71 R156.2 ; v2(251.27,173.63) 251.58,173.63 251.9,173.3 CG72.2 ; CG292.2 286.58,139.5 v1(286.46,139.61) ; v2(272.86,144.83) 272.97,144.94 CG221.2 ; C299.2 159.77,84.41 v1(159.34,84.85) ; C267.2 v1(75.95,87.59) ; v2(207.34,154.77) 207.33,154.76 RG29.2 ; C558.2 15.81,21.03 v1(15.42,21.42) ; v1(152.33,86.07) 152.33,86.19 151.89,86.63 C276.2 ; R141.1 v1(31.98,97.7) ; v2(244.5,155.67) 244.74,155.91 CG126.1 ; C134.1 165.77,136.67 v2(165.52,136.92) ; v1(153.88,63.06) 154.05,62.88 PC210.2 ; CN2.13 271.05,197.35 v1(271.33,197.07) ; RG35.1 226.81,151.58 226.91,151.47 v2(227.7,151.47) ; v1(27.1,80.3) 27.41,79.99 R299.1 ; C62.2 130.76,154.57 v2(130.9,154.44) ; v1(181.83,102.95) 182.01,102.95 182.28,103.22 C154.2 ; v1(209.6,68.42) 209.8,68.22 C436.2 ; v2(240.22,176.07) 240.46,175.83 241.71,175.83 241.93,176.06 CG50.2 ; R555.1 v1(204.42,58.93) ; CG141.2 203.6,155.98 v2(203.39,156.19) ; v1(33.82,67.12) 34.04,67.33 R447.1 ; v2(196.38,153.82) 196.43,153.87 CG159.2 ; PR201.1 269.32,77.81 v2(269.46,77.67) ; CG289.1 243.26,138.71 v2(243.1,138.87) ; v1(11.03,92.07) 11.7,92.07 C236.2 ; R99.2 168.29,151.48 v2(168.11,151.66) ; CG77.2 274.22,165.55 v2(273.76,165.08) ; R469.2 v1(32.26,65.65) ; v2(205.75,142.54) 205.77,142.52 RG40.2 ; RG46.2 207.57,136.71 207.25,136.4 v2(207.25,136.33) ; v2(215.87,176.48) 215.87,176.34 216.07,176.14 216.54,176.14 216.7,176.3 RG12.2 ; v2(272.25,143.85) 272.22,143.88 CG234.2 ; v2(215.87,177.68) 215.87,177.73 216.07,177.93 216.51,177.93 216.71,177.73 RG7.2 ; R411.1 220.12,71.55 v1(220.84,72.27) ; v2(237.94,183.85) 237.87,183.92 CG9.2 ; CG294.1 225.97,139.11 225.8,139.28 225.39,139.28 v2(225.12,139.01) ; v1(149.24,62.82) 149.38,62.67 PR282.1 ; U23.1 168.65,71.3 169.01,70.94 v1(169.01,70.8) ; R224.1 41.53,84.52 41.48,84.47 v1(41.48,84.42) ; CG276.1 225.68,140.2 225,140.88 v2(225,141.07) ; CG207.2 202.04,148.32 v2(202.07,148.35) ; v1(271.33,198.79) 271.27,198.85 CN2.10 ; v2(272.23,158.33) 272.02,158.12 CG101.2 ; CG48.2 241.16,178.15 v2(240.98,178.32) ; v2(200.4,151.58) 200.25,151.73 CG177.2 ; R275.2 v1(163.58,80.06) ; v2(228.4,136.08) 228.17,135.85 CG327.2 ; v1(257.63,80.82) 257.61,80.84 256.87,80.84 256.76,80.73 PC158.2 ; C373.1 169.9,75.91 v1(169.23,76.58) ; v1(224.11,207.35) 223.9,207.35 223.6,207.66 R41.2 ; RG9.2 246.19,176.67 245.99,176.47 v2(245.99,176.22) ; C550.2 v1(286.36,39.33) ; v2(200.39,165.34) 199.89,165.84 CG76.2 ; v2(269.25,156.05) 268.84,156.05 268.7,155.9 CG136.2 ; 34.49,96.55 34.76,96.55 35.14,96.17 35.64,96.17 36.97,94.85 36.97,94.33 v2(37.17,94.13) ; CG44.2 232.43,178.16 v2(232.65,178.38) ; v2(263.25,155.23) 263.25,154.8 264.42,153.63 CG163.2 ; CN2.19 v1(271.32,194.35) ; R530.1 203.57,61.07 204.05,61.07 v1(204.19,61.2) ; v2(206.73,154.87) RG24.2 ; C182.2 152.64,98.29 v1(152.61,98.26) ; v1(255.71,50.21) 255.91,50.41 C524.2 ; CG305.2 227.61,137.55 v2(227.7,137.47) ; R1189.1 167.12,57.22 166.66,57.68 v1(166.66,57.91) ; v1(162.58,58.14) 162.71,58.28 R560.2 ; C72.2 165.8,151 v2(165.81,151.01) ; v1(159.13,101.69) 159.05,101.62 C165.2 ; v1(271.32,193.25) 271.22,193.35 CN2.21 ; v1(39.66,38.81) PC266.1 ; v1(271.31,195.58) 271.05,195.85 CN2.16 ; CG174.2 264.97,151.63 v2(264.76,151.43) ; v2(236.8,154.27) 237.27,154.75 CG148.1 ; C375.2 175.36,75.69 175.36,76.51 v1(175.45,76.6) ; v2(274.63,162.87) 275.15,162.36 275.15,161.87 274.8,161.52 CG84.2 ; v2(241.01,157.07) 240.9,157.18 CG117.1 ; v1(218.55,64.78) 219.12,65.35 C451.1 ; CG277.2 270.22,140.62 v2(270.08,140.76) ; CG308.2 204.45,136.89 v2(204.24,137.09) ; v1(185.47,60.35) 185.6,60.22 R534.2 ; v1(146.35,102.42) 146.86,102.42 C163.2 ; CG149.1 235.18,154.49 v2(235.4,154.27) ; v1(164.33,66.12) 164.47,66.26 C448.2 ; v1(308.57,60.54) 308.62,60.6 C484.2 ; v2(236.9,134.89) 236.62,135.16 CG332.2 ; R500.2 268.2,62.73 v3(267.8,63.13) ; PR72.1 PR73.1 232.21,207.86 232.28,207.8 v1(232.48,207.8) ; R452.2 38.74,67.37 v1(38.94,67.17) ; v1(158.93,82.4) R277.1 ; U16.G5 v2(35.26,74.08)
  TOP w0.254: v2(227.7,143.07) 227.77,143.15 CG246.1 ; D19.2 v1(32.39,86.2) ; D19.2 v1(31.75,85.56) ; D19.2 v1(31.12,86.2) ; C32.2 277.98,186.08 v1(277.88,185.99) ; C94.2 166.76,147.37 v2(166.76,148.21) ; C392.2 277.85,72.65 278.01,72.49 278.24,72.49 278.42,72.31 v1(278.58,72.31) ; C208.2 163.94,95.81 C200.2 ; v1(27.78,71.04) 27.74,71.01 D33.2 26.58,71.01 v1(26.55,71.04) ; R645.2 190.22,40.65 v1(190.22,40.65) ; v1(26.52,70.37) 26.57,70.32 D35.2 27.74,70.32 v1(27.79,70.37) ; v1(27.79,74.44) 27.74,74.49 D29.2 26.57,74.49 v1(26.52,74.44) ; v1(284.18,172.82) 283.69,172.82 283.43,172.57 QG2.1 ; v1(277.85,186.98) 277.89,186.98 278.13,187.22 C28.2 ; v1(32.35,90.35) 32.34,90.36 D13.2 31.13,90.36 v1(31.12,90.35) ; v1(269.58,62.14) 269.58,62.43 269.83,62.69 U26.3 ; CG324.2 241.45,135.61 v2(241.7,135.35) ; v2(252.29,134.73) 252.34,134.73 CG340.1 ; v2(240.98,173.83) v2(241.75,173.06) ; R113.1 113.19,116.58 v1(113.54,116.23) ; C141.2 243.84,133.91 CG342.2 243.3,133.45 v2(243.12,133.27) ; v2(238.19,155.67) 237.97,155.9 CG125.1 ; CG304.1 247.19,137.59 v2(247.3,137.48) ; v1(32.35,88.32) 32.31,88.28 D16.2 31.16,88.28 v1(31.12,88.32) ; v1(164.78,88.19) 164.94,88.19 165.33,87.8 C269.2 ; v1(224.18,214.36) 223.47,215.07 PC1.2 223.47,215.46 223.73,215.72 224.46,215.72 224.77,216.02 PR4.2 ; D27.2 26.65,76.57 v1(26.58,76.63) ; D27.2 27.74,76.57 v1(27.82,76.49) ; D27.2 27.18,77.05 v1(27.09,77.14) ; C442.2 16.31,68.72 v1(16.28,68.75) ; v2(227.69,144.48) 227.84,144.63 CG231.1 ; v1(19.9,51.83) 19.89,51.82 L16.5 ; CG49.2 219.53,177.04 v2(219.74,176.83) ; v1(269.63,216.64) 269.63,216.19 QG1.4 ; v1(285.81,171.84) 285.3,171.32 QG2.4 ; v1(31.09,87.64) 31.14,87.59 D17.2 32.31,87.59 v1(32.36,87.64) ; v2(243.1,137.47) 243.3,137.67 CG300.1 ; v1(277.89,185.02) 277.97,184.94 C33.2 ; L15.5 v1(20.19,56.96) ; v1(284.88,179.8) 285.21,180.13 285.21,180.91 284.96,181.16 R81.1 ; UG1.3 244.72,114.84 244.89,114.68 245.15,114.68 v1(245.42,114.95) ; v1(31.91,94.38) 31.75,94.23 D9.2 ; v1(26.55,75.11) 26.61,75.17 D28.2 27.71,75.17 v1(27.78,75.11) ; v2(62.34,90.06) 62.12,89.84 U11.H2 ; R592.1 37.98,54.74 v1(37.62,54.38) ; R359.2 R360.2 180.22,75.91 179.87,76.26 v1(179.87,76.59) ; v2(125.16,212.63) 125.16,211.94 125.85,211.24 PU3.3 ; QG15.1 250.19,112.06 v1(250.07,112.18) 249.91,112.34 249.91,112.82 249.66,113.06 QG15.4 ; v2(253.6,134.67) 253.67,134.6 CG341.1 ; v1(27.82,68.92) D38.2 ; D38.2 v1(26.55,68.92) ; D38.2 v1(27.18,68.29) ; PC171.2 144.91,75.47 v1(144.15,76.24) PC170.2 ; v1(294.39,83.76) 292.36,81.72 C321.2 ; v1(31.12,92.38) 31.18,92.44 D11.2 32.29,92.44 v1(32.35,92.38) ; C545.2 187.59,42.34 v1(187.59,41.8) ; v1(31.09,91.71) 31.14,91.76 D12.2 32.31,91.76 v1(32.36,91.71) ; v1(270.11,214.19) 270.91,214.99 QG1.1 ; D3.2 267.92,193.35 267.11,192.55 CN1.19 ; R479.1 v1(13.54,65.95) ; U22.3 v1(268.94,65.23) ; D9.2 31.22,93.84 31.22,93.84 v1(31.18,93.84) ; D9.2 32.33,93.84 v1(32.39,93.91) ; v1(112.46,124.36) 112.46,124.14 112.21,123.89 R109.1 ; 211.37,80.15 211.37,80.17 211.72,80.17 212.03,80.47 212.03,81.33 211.58,81.79 211.58,82.39 211.23,82.75 C310.1 211.33,82.89 211.89,83.45 v1(211.89,84.29) 211.89,85.31 211.57,85.63 208.96,85.63 208.69,85.36 v1(208.69,84.83) 208.69,82.9 C312.1 208.88,81.3 v1(208.88,80.84) 209.02,80.7 209.02,80.43 209.5,79.95 v1(209.5,79.73) 209.69,79.54 209.69,78.46 211.07,77.08 v1(211.07,76.93) 211.07,76.48 211.57,75.99 212.12,75.99 213.19,77.05 v2(213.19,77.96) 212.99,77.96 211.39,79.56 211.39,80.13 211.37,80.15 ; 211.37,80.15 v1(211.36,80.15) ; v1(17.97,56.96) L15.6 ; v1(224.87,67.93) 225.74,67.93 226.01,67.67 U19.2 ; v2(228.88,172.4) 229.01,172.53 CG68.2 ; v1(27.78,73.08) 27.77,73.09 D30.2 26.56,73.09 v1(26.55,73.08) ; v1(219.13,79.9) 219.15,79.87 219.36,79.87 219.73,79.51 R325.2 ; v1(27.79,72.4) D32.2 26.52,72.4 v1(26.52,72.4) ; v2(224.96,136.85) 224.96,136.72 CG406.1 ; v2(248,138.87) 248.4,139.27 CG281.1 ; v1(17.68,51.82) L16.6 ; PC172.2 55.63,74.51 v1(56.07,74.96) 56.39,74.64 PC173.2 ; R608.2 31.63,54.27 v1(32,53.89) 32.42,54.31 R609.2 ; CG317.2 240.87,136.21 v2(241,136.08) ; v1(32.36,89.68) D14.2 31.09,89.68 v1(31.09,89.68)
  TOP w0.305: C123.2 137.72,138.61 138.26,139.14 v2(138.26,139.26) ; U34.3 25.8,14.35 26.33,14.88 v1(26.51,14.88) ; C91.2 137.66,147.41 138.26,146.81 v2(138.26,146.72) ; Q39.1 158.39,71.44 v1(158.71,71.12) ; v1(163.76,201) 163.76,200.46 164.16,200.05 Q126.1 ; v1(98.19,62.23) 97.74,62.69 U25.3 ; v1(166.53,201.89) 166.28,201.65 Q126.4 ; Q21.1 v1(74.8,90.51) ; PU16.3 262.63,57.86 v1(263.34,58.56)
  TOP w0.35: v2(257.97,177.44) 257.66,177.44 257.04,176.82 257.04,176.82 257.03,176.82 v2(257.02,176.82) 257.02,176.82 257.01,176.8 v2(256.26,176.8) ; v2(240.98,174.56) v2(240.98,173.83) ; v2(267.75,149.06) v2(267.75,149.82)
  TOP w0.381: v1(18.21,31.46) U33.3 v1(15.83,31.46) ; Q8.1 139.35,209.02 v1(139.35,208.47) ; v1(224.11,207.35) 224.11,207.96 224.02,208.05 Q7.1 ; Q67.1 20.24,11.53 v1(20.62,11.15) ; v1(15.83,36.28) U32.3 v1(18.21,36.28) ; v2(244.5,144.47) 244.16,144.81 CG226.2 ; v1(282.59,83.21) 282.52,83.29 PQ18.1 ; v1(193.27,44.76) 193.27,45.05 C534.2 ; v1(246.94,208.57) 246.94,208.19 247.44,207.69 Q127.1 ; PC25.2 173.21,205.09 173.92,205.81 v1(173.92,207.38) ; PQ9.1 233.06,204.87 v1(233.28,204.64) ; Q55.1 174.76,53.92 174.37,53.53 174.37,52.19 v3(174.42,52.13) ; v3(173.61,52.13) 173.16,51.69 PC223.2 ; v2(241.7,144.48) 241.3,144.08 CG239.2 ; C485.2 310.7,60.86 310.7,60.66 v1(310.6,60.55) ; PQ2.1 261.7,215.68 261.43,215.41 261.43,214.24 v1(261.58,214.08) ; CG329.2 229,132.46 v2(229.11,132.56) ; CG407.1 224.27,135.47 223.73,135.47 v2(223.57,135.3) ; PQ7.1 199.94,206.39 v1(199.57,206.02) ; Q69.1 24.05,10.88 v1(23.84,11.08) ; v1(19.17,9.36) 20.28,9.36 Q70.1 ; v2(244.5,143.07) 244.15,143.42 CG242.2 ; v1(18.63,9.82) ESD1.3 v1(16.16,9.82) ; C107.2 136.31,143.69 v2(136.31,144.42) ; v2(154.31,151.03) 154.31,150.38 C75.2 ; v1(277.04,83.45) 276.55,82.97 PQ19.1 ; C413.1 298,70.77 297.69,71.08 v1(297.54,71.08) ; CG214.2 202.19,145.88 v2(202.37,145.71) ; PQ8.1 197.3,206.09 v1(197.12,205.92) ; v1(25.14,11.52) 25.67,12.06 Q68.1
  TOP w0.508: PC88.2 v1(130.82,174.81) ; v1(153.74,86.87) 154.17,86.43 C282.2 ; v2(135.01,141.83) 135.01,142.57 C106.2 ; v2(257.87,173.81) 258.55,174.49 CG54.2 ; v1(164.27,94.4) 163.94,94.72 C208.2 ; CG343.2 249.13,133.75 249.13,133.16 v2(249.16,133.13) ; PQ27.1 60.42,60.23 v1(60.25,60.39) ; CG206.2 196.73,147.87 v1(196.19,148.41) ; v1(187,39.43) 187.27,39.43 187.36,39.35 Q64.1 ; v2(273.78,140.72) 273.7,140.65 CG279.2 ; v2(160.16,136.2) 159.59,136.2 159.37,136.42 ; C168.2 159.79,101.3 159.46,100.98 v1(159.13,100.98) ; C297.2 145.97,84.23 v1(145.97,83.47) ; CG241.2 238.19,144.05 237.91,144.05 v2(237.5,144.46) ; CG193.2 246.83,148.67 v2(247.3,148.67) ; v1(214.85,68.67) 214.75,68.78 C427.1 ; C114.2 137.82,141.52 v2(138.17,141.87) ; CG2.2 234.72,184.27 v2(234.17,183.72) ; v2(248.76,183.65) 248.86,183.75 CG5.2 ; C59.2 167.7,156.44 v1(167.09,157.04) ; C88.2 135.64,148.25 v2(135.66,148.26) ; C129.2 138.66,136.89 138.46,136.69 v2(138.26,136.69) ; v2(218.18,182.15) 217.96,182.37 CG19.2 ; v2(204.45,152.5) 204.47,152.52 CG164.2 ; v1(43.58,44.82) 43.57,44.81 PC243.2 ; PQ26.1 64.35,64.72 v1(63.86,64.22) 63.51,63.88 PQ24.1 ; v1(292.91,122.38) 292.63,122.66 292.43,122.66 PC98.2 ; C68.2 161.73,152.58 v2(161.97,152.34) ; CG157.2 248.14,154.27 v2(247.3,154.27) ; D1.2 268.02,195.95 267.73,196.24 v1(267.63,196.24) ; CG180.2 229.57,151.46 v2(229.1,151.46) ; v2(233.3,145.87) 232.93,145.5 CG225.2 ; CG256.2 229.11,141.68 v2(229.1,141.67) ; PQ17.1 280.87,84.9 v1(280.87,84.9) ; CG273.2 243.04,140.21 v2(243.1,140.27) ; CG291.2 201.23,138.72 v2(201.23,137.92) ; PR239.2 262.77,72.35 PC195.2 v1(262.77,70.86) ; v2(196.07,144.93) 196.14,145 CG230.2 ; CG62.2 246.95,174.01 v2(247.1,173.86) ; v1(267.47,201) 268.09,201 C23.2 ; v1(276.61,193.46) 276.98,193.83 D2.2 ; v1(156.24,85.79) 156.78,85.79 C280.2 ; CG240.2 232.93,143.44 v2(233.3,143.07) ; CG335.2 245.26,135.27 245.89,135.91 v2(245.89,136.08) ; PC225.1 v1(69.65,50.17) ; PQ23.1 60.3,62.93 v1(60.68,62.93) ; v1(268.94,190.13) 268.62,190.45 D5.2 ; v1(290.73,125.68) 290.77,125.64 PC96.2 ; v2(236.1,144.48) 236.01,144.48 235.71,144.18 CG238.2 ; CG261.2 200.88,141.45 v2(201.09,141.66) ; v2(138.26,148.26) 138.26,148.94 C83.2 ; PC26.2 161.62,204.39 v1(160.84,204.39) ; CG61.2 244.14,174.01 243.63,174.52 v2(243.39,174.52) ; v1(234.7,215.08) 234.29,214.66 PC2.1 ; D8.2 268.56,186.82 268.91,187.17 v1(268.91,187.91) 268.91,188.13 268.41,188.64 D7.2 ; v1(124.49,85.99) 123.64,85.99 C284.2 ; v1(222.13,213.2) 222.42,212.91 PC4.1 ; v2(136.35,153.61) 136.14,153.4 C65.2 ; v2(241.02,145.87) 241.1,145.78 241.1,145.34 CG227.2 ; v1(155.79,68.14) 155.79,67.62 Q46.1 ; PQ10.1 228.07,205.81 227.56,205.31 v1(227.56,204.96) ; CG290.2 204.89,138 v2(204.91,137.99) ; CG252.2 235.73,142.69 v2(236.11,143.07) ; v1(57.26,60.5) 57.26,60.99 57.77,61.5 PR292.2 ; Q45.1 152.43,70.55 152.81,70.93 v1(152.81,71.13) ; v1(102.61,94.08) 102.01,94.08 C223.2 ; CG181.2 243.96,150.07 v2(243.1,150.07) ; CG169.2 247.99,152.6 v2(247.99,152.16) 247.99,151.31 CG179.2 ; v3(146,68.38) 146.54,68.38 147.05,68.89 PC205.2 ; v1(190.22,40.65) 190.54,40.97 C874.2 ; U12.3 99.97,83.91 v1(100.83,83.05) ; CG3.2 241.77,184.34 v2(241.77,183.68) ; v1(209.33,62.89) 209.48,63.04 C461.2 ; v1(254.89,214.05) 255.29,214.05 PQ4.1 ; v1(177.95,83.43) 178.18,83.43 178.62,83.87 C306.2 ; C133.2 163.27,136.23 v2(163.19,136.15) ; C61.2 163.78,154.8 163.56,154.58 v2(163.56,154.38) ; PC24.1 v1(225.89,204.95) ; v2(162.4,148.42) 162.4,148.19 161.98,147.78 C89.1 ; Y2.4 211.29,84.07 211.67,84.07 v1(211.89,84.29) ; v2(237.51,157.07) 237.51,157.8 CG102.2 ; PC87.2 111.33,174.36 v1(111.14,174.17) ; v1(210.5,186.09) 210.12,186.48 Q14.1 ; PC226.2 v1(71.68,50.17) ; v2(141.07,151.65) 141.05,151.68 C69.2 ; C67.2 131.25,153.65 v2(131.28,153.61) ; PR38.1 144.51,212.89 v1(144.76,212.89) ; v1(171.26,99.68) 171.16,99.58 C174.2 ; PC86.2 159.1,174.82 v1(159.23,174.96) ; CG258.2 245.87,141.64 v2(245.9,141.67) ; C135.2 138.24,135.91 v2(138.26,135.92) ; PC89.2 v1(139.99,174.81) ; CG243.2 229.83,143.66 229.24,143.07 v2(229.1,143.07) ; C167.2 157.47,101.3 v1(157.53,101.23) ; CG272.2 235.6,140.28 v2(234.7,140.28) ; L13.1 187.33,63.85 188.65,63.85 v1(188.68,63.82) ; CG4.2 256.27,184.42 v2(256.27,183.62) ; C290.2 134.66,85.24 v1(135.39,85.97) ; C557.2 16.24,22.19 v1(15.42,22.19) ; CG322.2 232.89,135.66 v2(233.3,136.06) ; v2(201.25,152.44) 201.62,152.81 CG162.2 ; v1(133.26,70.02) 133.15,70.13 PC202.2 ; v1(152.6,74.82) Q42.1 ; C291.1 v1(158.3,85.81) ; PQ16.1 v1(88.27,88.25) ; C517.1 v1(100.87,55.45) ; v1(279.46,207.32) 280.29,208.15 Q6.1 ; v1(171.34,215.5) 170.95,215.5 PQ3.1 ; CG1.2 220.25,184.27 219.69,183.71 v2(219.69,183.63) ; v1(268.85,199.18) 268.85,198.99 268.34,198.48 C27.2 ; QG5.1 276.26,133.92 v1(276.38,133.8) ; v2(253.9,182.11) 253,182.11 CG15.2 ; PC155.2 277.97,83.01 v1(278.41,83.45) ; v2(200.39,137.11) 200.29,137.22 CG303.2 ; CG109.2 242.68,157.33 v2(243.14,157.79) ; v2(257.95,180.68) 258.84,180.68 CG23.2 ; v1(168,85.97) 167.83,85.79 C283.2 ; PC90.2 v1(120.95,174.81) ; CG195.2 229.68,149.49 v2(229.11,150.06) ; v2(232.66,179.13) 232.45,179.13 231.96,179.61 CG30.2 ; C268.2 173.28,86.77 v1(172.73,86.77) ; PC214.2 249.89,57.99 v1(249.6,57.99) ; v1(165.48,102.33) 164.6,102.33 C159.2 ; PC204.2 143.61,69.12 144.12,68.61 v3(144.12,68.61) 144.58,69.06 PC203.2 ; PQ22.1 v1(250.33,64.3) ; CG161.2 209.98,153.11 210.36,152.73 v2(210.36,152.46) ; C176.1 162.33,99.78 162.13,99.58 v1(161.69,99.58) ; PQ28.1 248.56,60.55 v1(247.82,61.29) ; PQ13.1 208.89,105.81 v1(209.61,105.09) ; CG228.2 239.31,144.9 v2(238.88,144.47) ; CG270.2 245.85,140.22 v2(245.9,140.27) ; C70.2 148.04,151.66 v2(147.35,151.66) ; C66.2 132.85,152.93 v2(132.82,152.96) ; PR532.2 294.88,104.05 v1(294.44,104.5) ; C76.2 150.06,148.47 v2(150.04,148.45) ; v1(136.95,209.14) 136.63,209.46 PC11.2 ; C74.2 135.55,151 v2(135.56,151.01) ; PQ5.1 261.99,213.67 v1(261.58,214.08) ; v1(196.25,149.87) 196.27,149.85 CG189.2 ; v1(149.24,62.82) 150.24,63.82 PR274.2 ; C198.2 148.07,97.16 v1(147.7,97.53) ; CG17.2 222.72,181.76 222.52,181.96 v2(222.12,181.96) ; CG166.2 229.96,152.87 v2(230.5,152.87) ; PC219.2 154.65,53.68 v3(155.17,53.68) ; D3.2 268.75,193.35 v1(268.97,193.57) ; v2(230.5,136.07) 230.06,136.07 229.73,135.74 CG328.2 ; v1(55.15,68.81) 55.08,68.81 54.78,68.5 PC206.2 ; C64.2 139.05,153.97 v2(138.69,153.61) ; v1(20.31,2.31) 20.31,3.01 C563.2 ; v1(55.18,60.78) PR276.2 ; v2(253.76,173.37) 253.74,173.38 252.95,173.38 CG58.1 ; v2(165.81,154.26) 165.77,154.3 C60.2 ; PR329.1 v1(71.38,41.24) ; CG255.2 231.91,141.69 v2(231.91,141.68) ; C292.2 151.66,84.93 150.93,85.66 150.05,85.66 v1(150.03,85.68) ; v3(155.15,51.37) 154.45,51.37 154.09,51.73 PC222.2 ; C460.2 v1(13.39,63.92) ; C196.2 133.29,97.23 v1(132.94,97.58) ; v2(244.5,154.27) 244.5,154.13 244.95,153.67 CG168.2 ; v2(202.01,156.2) 201.32,156.2 CG129.2 ; v2(243.1,141.67) 243.09,141.68 CG257.2 ; PC102.1 290.01,117.37 290.01,117.38 v1(290.51,117.89) 290.43,117.97 PC101.1 ; C401.1 278.38,71.63 278.39,71.64 v1(278.61,71.64) ; PC91.2 v1(149.86,174.81) ; v3(158.25,51.37) 158.94,51.37 159.2,51.63 PC224.2 ; C44.1 167.55,159.99 v1(168.04,160.49) ; C304.1 149.69,83.93 v1(149.06,83.93) ; CG271.2 233.71,140 v2(233.29,139.58) ; CG215.2 v1(196.17,146.42) ; C562.2 v1(16.31,2.36) ; v2(229.09,145.17) 229.17,145.09 CG229.2 ; PQ11.1 222.7,203 v1(222.43,202.73) ; v2(237.5,140.27) 237.58,140.19 CG274.2 ; PC9.2 v1(165.05,211.21) ; CG121.2 248.63,155.93 248.36,155.66 v2(247.99,155.66) ; CG45.2 258.62,177.44 v2(257.97,177.44) ; C245.2 v1(66.07,90.51) ; v2(245.9,147.96) 245.9,147.46 CG210.2 ; CG223.2 235.7,145.19 234.98,144.47 v2(234.7,144.47) ; QG3.1 v1(285.54,142.1) ; CG209.2 247.29,147.23 246.64,146.58 v2(246.59,146.58) ; CG259.2 240.25,141.62 v2(240.3,141.67) ; v1(208.69,84.83) 208.78,84.92 Y2.2 ; CG269.2 229.12,140.25 v2(229.1,140.27) ; PC46.1 v1(175.36,191.98) ; CG244.2 v2(196.09,143.47) ; CG105.2 245.18,157.09 v2(245.2,157.07) ; 159.32,136.47 C132.2 ; v1(276.48,191.61) 276.48,191.49 276.99,190.98 D4.2 ; PC220.2 v1(156.98,55.03) ; PC8.2 168.6,211.9 168.68,211.83 v1(169,211.83) ; v2(230.49,147.27) 230.19,146.97 CG211.2 ; U10.4 v1(52.45,84.57) ; v2(137.92,151.01) 137.94,151 C73.2 ; v1(150.48,102.22) 150.61,102.22 150.63,102.2 151.26,102.2 C169.2 ; C316.2 v1(164.6,80.06) ; v1(170.28,211.36) PC5.1 ; U14.4 v1(71.63,81.62)
  IN1 w0.203: v2(136.29,130.22) 136.25,130.26 v2(136.25,130.85)
  IN2 w0.254: v2(212.64,133.96) 212.65,133.95 v2(213.29,133.95)
  IN3 w0.508: v1(321.11,70.17) 320.81,69.86 320.81,69.15 321.44,68.52 321.44,65.79 v3(319.26,63.6)
  IN4 w0.203: v2(164.23,134.23) 164.21,134.26 v2(164.21,134.84) ; v2(126.6,135.93) 127.18,135.93 v2(127.2,135.94) 127.81,135.94 v2(127.82,135.93)
  BOTTOM w0.079: UG6.K39 230.15,159.3 230.16,159.28 230.16,158.65 v2(230.15,158.64) ; U42.C13 174.71,136.27 173.59,136.27 173.3,135.98 U42.F13
  BOTTOM w0.089: U42.F16 173.34,138.2 174.72,138.2 U42.C16 ; U42.F18 173.34,140.13 173.56,140.13 174.72,140.13 U42.C18
  BOTTOM w0.102: v2(224.9,131.17) 224.45,131.17 224.19,130.91 v2(224.19,130.46) ; v2(273.06,161.94) 272.63,162.38 VRAM5.T5 ; UG6.E43 227.35,163.02 227.01,163.36 226.19,163.36 v2(226.07,163.24) ; v2(244.5,160.57) 244.51,160.57 244.96,160.11 245.45,160.11 UG6.J17 ; UG6.AG51 221.38,147.99 220.79,147.99 220.42,147.62 UG6.AG53 ; 226.87,171.95 VRAM1.T3 ; UG6.U31 235.75,154.61 ; v2(272.25,163.56) 271.88,163.93 VRAM5.R3 271.88,163.97 v2(271.53,164.32) ; v2(257.82,155.18) 257.44,154.81 257.09,154.81 256.91,154.98 256.39,154.98 UG6.T2 ; UG6.BJ20 243.52,132.22 243.78,131.95 243.78,131.33 243.93,131.18 ; UG6.BE4 254.65,135.02 ; U42.CL16 131.43,138.02 v2(131.81,138.39) ; v2(226.5,181.31) 226,181.31 225.62,181.7 VRAM1.C5 ; 131.75,143.6 v2(131.75,143.66) ; 131.8,133.86 U42.CK9 ; 245.2,154.27 v2(245.2,154.26) ; 270,164.32 v2(270,164.33) ; U49.AD5 212.9,77.67 ; 236.44,154.62 UG6.U30 ; 255.37,135.04 v2(255.37,135.12)
  BOTTOM w0.12: v2(272.23,158.33) 272.26,158.3 v2(272.26,157.58) ; v2(225.76,180.58) 225.23,180.58 224.7,180.05 v2(224.7,179.98) ; 235.02,172.33 235.74,172.33 VRAM2.C5 ; v2(235.01,179.09) v2(235.75,179.09) ; VRAM5.L11 268.49,158.33 v2(268.49,159.38) ; v2(235.78,176.82) 235.78,177.55 v2(235.76,177.56)
  BOTTOM w0.127: U49.AT1 218.82,79.13 218.82,78.1 218.73,78.01 218.73,77.53 U49.AT5 ; 250.12,140.99 250.81,140.99 251.15,140.65 UG6.AU9 ; v2(224.67,73.8) 224.64,73.82 224.08,73.82 224.02,73.77 U49.BF13
  BOTTOM w0.14: CN6.3 v1(107.95,75.73) ; CN7.45 300.93,82.25 ; CN12.18 274.59,65.24 v1(274.15,64.81) ; C836.2 C838.2 277.19,48.35 v1(277.27,48.43) ; R1166.1 R1168.1 v1(277.29,44.79) ; R968.1 v1(270.82,67.98) ; JDIM1.27 v1(127.83,103.06) ; PR482.2 109.2,192.12 109.2,193.98 108.89,194.29 108.89,197.42 109.28,197.82 109.28,201.77 112.8,205.3 112.8,207 113.57,207.76 114.48,207.76 PC320.1 114.53,207.13 v1(113.98,207.13) ; R1155.1 277.12,46.57 v1(277.22,46.47) ; v1(26.11,53.22) 25.67,53.66 25.54,53.66 25.54,53.66 C817.2 ; PR354.2 249.54,216.79 v1(249.43,216.9) ; PR590.1 v1(237.37,86.35) ; v1(151.56,210) 151.82,209.74 R709.2 ; v1(276.32,86.49) 276.34,86.49 276.48,86.63 PR573.1 ; CN7.51 300.93,80.75 ; C839.1 v1(277.22,47.46) ; CN7.33 300.93,85.25 ; v1(12.16,79.51) D59.3 ; C659.2 v1(124.36,154.79) ; D57.3 v1(12.15,93.49)
  BOTTOM w0.15: U42.G17 172.64,138.88 172.94,139.18 173.98,139.18 U42.D17
  BOTTOM w0.152: v1(216.94,55.24) 216.78,55.4 U49.AM49 ; U49.AA49 211.09,55.56 v1(211.09,55.22) ; v1(219.76,55.13) 219.55,55.13 U49.AT49 ; v1(204.4,79.81) 204.4,79.81 204.57,79.64 U49.G1 ; v1(214.68,55.13) 214.58,55.24 U49.AG49 ; v1(217.76,77.09) 217.87,77.2 U49.AP5 ; 203.9,72.45 203.9,72.81 203.76,72.95 203.76,73.31 203.57,73.5 U49.E13 203.31,73.5 U49.D13 203.01,73.8 U49.C12 ; 203.9,72.45 203.36,72.45 U49.E15 ; 203.9,72.45 v1(203.98,72.37) ; U49.BG22 224.35,69.18 v1(224.61,68.92) ; U42.F16 173.54,137.42 173.88,137.42 174.36,136.94 U42.D14 ; v1(200.61,61.63) 200.81,61.43 U49.A37 ; v2(251.28,175.93) 251.14,176.06 250.24,176.06 249.88,175.7 VRAM3.L11 ; v1(224.64,65.6) 224.44,65.6 U49.BG28 ; U49.A33 201.08,63.12 v1(201.08,63.09) ; v1(201.59,71.84) 201.59,71.84 U49.A17 ; U49.A41 201.59,58.94 v1(201.3,58.65) ; U49.T49 208.84,55.69 v1(208.62,55.47) ; v1(214.49,80.13) 214.59,80.03 214.59,79.32 U49.AG1 ; U49.D33 203.28,63.48 203.9,62.86 v1(203.9,62.37) ; v1(224.71,75.9) 224.61,75.79 U49.BG9 ; v1(201.01,65.82) U49.A28 ; v1(212.96,54.22) 212.9,54.28 U49.AD49 ; U49.BG17 224.03,71.56 v1(224.03,72.41) ; U49.BF42 224.05,59.04 U49.BG41 224.91,59.21 v1(224.92,59.22) ; v1(224.49,64.13) 224.49,64.1 224.21,63.82 U49.BG33
  BOTTOM w0.178: UG6.AU2 256.4,140.27 256.4,139.64 256.53,139.51 256.53,139.1 ; v1(270.11,214.19) 270.3,214.19 270.8,213.69 U36.40 ; v1(209.5,79.73) 209.38,79.73 209.03,79.37 U49.T1 ; v1(224.78,61.46) 224.74,61.43 U49.BG37 ; v3(116.74,45.05) 117.03,44.76 PU38.1 ; v2(240.22,176.07) 239.39,176.07 v2(239.33,176.02) ; U49.V38 209.77,60.87 208.95,60.87 U49.T38
  BOTTOM w0.2: U42.BH12 146.24,136.2 v2(146.3,136.2) ; U42.C1 175.01,128.66 174.61,129.05 174.61,129.47 U42.C3 ; v2(170.07,135.77) U42.K13 170.42,136.48 170.47,136.78 v2(170.5,136.81) ; U42.Y22 163.56,142.25 v2(163.56,142.38) ; U42.D20 174.01,141.07 172.88,141.07 172.68,140.86 U42.G20 ; v2(166.16,143.71) 166.16,143.47 U42.T24 ; U42.J39 v2(170.41,152.31) ; U42.BF6 147.4,131.91 147.56,131.75 147.56,131.33 U42.BF5 ; v2(171.99,142.5) 172.39,142.9 172.39,143.09 U42.G24 ; v2(156.6,151.01) U42.AM36 ; v2(165.51,144.65) U42.U26 ; U42.W10 164.88,134.65 v2(165.11,134.84) ; v2(159.97,130.84) 160.3,131.16 U42.AF5 U42.AD5 ; U42.AT36 154.25,151.03 v2(154.31,151.03) ; v2(143.29,136.23) 143.67,135.85 U42.BM12 ; U42.BL6 144.45,131.91 144.61,131.75 144.61,131.33 U42.BL5 ; v2(147.07,136.19) 147.84,136.19 148.04,135.99 U42.BE12 ; U42.AY12 v2(151.35,136.17) ; U42.AA41 v2(163.56,154.38) ; U42.U29 165.83,146.57 v2(165.51,146.89) ; U42.V22 164.86,142.25 v2(164.86,142.38) ; U42.BL10 144.57,134.39 144.57,133.99 U42.BL9 144.46,133.86 144.61,133.71 144.61,133.38 U42.BL8 ; v2(156.6,149.71) U42.AM34 ; v2(158.14,152.96) 158.08,152.96 U42.AK39 ; U42.CU20 126.69,139.74 126.35,139.74 v2(125.89,139.29) ; U42.CA5 U42.CC5 ; v2(166.64,130.84) 166.97,131.16 U42.R5 U42.P5 ; U42.P10 v2(168.45,134.84) ; U42.BL2 144.64,129.41 144.64,129.66 U42.BL3 144.61,130.04 144.61,130.34 U42.BL4 ; U42.AC34 v2(162.74,149.71) ; v2(153.87,148.43) U42.AR33 ; v2(166.16,142.38) 166.16,142.25 U42.T22 ; v2(126.39,134.3) 126.74,133.94 127.41,133.94 U42.CU9 ; v2(159.67,151.01) U42.AG36 ; v2(166.76,148.21) 166.76,148 U42.T31 ; U42.W7 164.51,132.35 164.04,132.35 U42.Y7 ; v2(165.51,142.38) 165.51,142.25 U42.U22 ; U42.BB35 v2(150.46,150.36) ; U42.V39 v2(165.81,152.96) ; v2(175.98,152.85) 176.31,152.52 U42.A39 ; v2(166.21,144.73) 166.21,145.15 U42.T28 ; v2(163.38,130.79) 163.46,130.79 U42.Y5 U42.W5 ; v2(169.98,130.84) 170.31,131.16 U42.K5 U42.H5 ; U42.AW35 v2(152,150.36) ; U42.U13 165.83,136.43 165.52,136.74 v2(165.52,136.92) U42.U15 ; v2(168.14,135.71) U42.N13 v2(168.51,136.86) ; 170.72,134.94 U42.H10
  BOTTOM w0.203: v2(144.99,152.31) U42.BK38 v2(144.99,151.66) U42.BK37 ; v2(144.99,152.31) 144.67,152.64 U42.BK39 ; v2(144.99,152.31) 145.32,152.64 U42.BJ39 145.45,152.64 v2(145.78,152.31) U42.BH39 v2(146.57,152.31) U42.BG39 v2(147.35,152.31) U42.BE38 v2(147.35,151.66) U42.BE37 147.59,151.2 v2(147.35,151.01) ; 159.2,131.54 159.19,131.54 U42.AH6 ; 159.2,131.54 U42.AH5 158.74,131.16 v2(158.41,130.83) ; 159.2,131.54 v2(159.24,131.54) ; U42.CH2 133.09,128.89 v2(132.9,128.89) ; U42.AR6 U42.AN5 155.81,130.84 v2(155.87,130.84) ; U42.AR6 154.83,131.91 U42.AN7 155.54,132.56 v2(155.87,132.89) 156.19,133.21 U42.AM8 156.31,133.21 v2(156.63,133.54) ; U42.AR6 154.67,131.91 v2(154.34,132.25) ; v2(175.37,142.19) 175.37,142.14 U42.C22 ; v2(126.98,153.61) 127.18,153.61 U42.CU40 ; R949.1 229.59,73.75 v1(229.52,73.67) ; 141.45,132.56 U42.BR7 ; 141.45,132.56 141.43,132.56 v2(141.11,132.89) 141.43,133.21 U42.BR8 141.16,133.54 ; 141.45,132.56 v2(141.1,132.22) 141.4,131.91 U42.BR6 ; U42.H10 171.62,134.74 171.94,134.74 U42.G10 172.23,134.51 v2(172.55,134.19) ; U42.CN20 130.13,140.62 v2(129.75,141.01) 130.13,141.39 U42.CN21 U42.CN22 129.81,142.68 v2(129.81,142.74) ; U42.V36 165.75,151.01 v2(165.81,151.01) ; R869.1 214.43,86.38 215.06,85.75 v1(215.06,85.54) 215.06,85.03 C729.2 ; UG6.BR6 253.21,127.98 253.21,125.95 255.15,124.02 v1(255.15,122.47) ; U42.CE10 135.02,134.51 v2(134.7,134.84) ; U42.CE10 135.14,134.51 v2(135.47,134.84) 135.79,134.51 U42.CD10 135.91,134.51 v2(136.23,134.84) 136.56,134.51 U42.CC10 136.81,134.51 v2(137.14,134.84) 137.46,134.51 U42.CA10 137.71,134.51 v2(138.04,134.84) 138.36,134.51 U42.BY10 138.74,134.84 v2(138.8,134.84) 139.13,134.51 U42.BW10 139.53,134.17 v2(139.57,134.17) ; U42.CE10 135.14,134.45 135.14,133.93 U42.CE9 135.14,133.8 135.14,133.28 U42.CE8 135.08,133.2 134.77,132.88 v2(134.7,132.88) 134.63,132.88 U42.CF7 ; v2(135.47,130.84) 135.41,130.84 ; 135.41,130.84 U42.CE4 135.02,130.51 v2(134.7,130.84) 134.64,130.84 U42.CF5 U42.CH5 133.22,131.16 v2(132.9,130.84) 132.84,130.84 U42.CJ5 132.45,131.16 v2(132.13,130.84) 132.07,130.84 U42.CK4 132.07,130.19 132.07,130.19 ; 135.41,130.84 U42.CE5 135.41,131.49 v2(135.47,131.49) ; U49.P45 207.93,57.59 v2(207.65,57.87) ; U42.AW4 151.88,130.51 U42.AV5 152.56,131.16 v2(152.9,131.51) ; U42.AL38 157.64,152.64 U42.AK39 ; U42.G8 172.22,133.21 v2(172.56,133.55) ; v2(129.81,142.74) 130.13,143.07 U42.CN23 130.19,143.21 130.72,143.21 U42.CM23 131.09,143.58 v2(131.09,143.65) 131.43,143.32 U42.CL23 ; v2(129.81,142.74) 129.79,142.76 v2(129.1,142.76) 128.86,142.76 128.28,142.18 U42.CT22 ; R778.2 171.98,158.34 172.18,158.55 v1(172.41,158.55) 172.67,158.55 172.87,158.34 R779.2 ; U42.AF7 160.62,132.56 v2(160.97,132.92) ; U42.AF7 160.16,132.89 v2(159.97,132.89) 159.91,132.89 U42.AG7 ; U42.AF7 160.82,132.23 v2(161.01,132.23) ; U42.AH3 159.15,130.19 v2(159.2,130.19) 158.88,130.51 U42.AH4 ; U42.AH3 158.65,129.86 158.05,129.27 U42.AJ2 158.37,128.9 v2(158.45,128.9) 158.78,128.56 U42.AH1 ; U42.AH3 158.88,129.86 v2(159.2,129.54) 159.53,129.21 U42.AG2 159.66,129.21 v2(159.97,128.91) 160.27,129.21 U42.AF2 ; v2(131.46,134.9) 131.47,134.9 131.49,134.88 132.09,134.88 v2(132.13,134.84) ; v2(149.96,134.84) 150.02,134.84 U42.BA10 150.02,134.19 ; v1(211.07,76.93) 210.79,76.93 210.15,77.56 U49.V5 ; U42.BR37 v2(141.07,151.01) ; U42.BR37 v2(141.86,151.01) ; U42.BR37 141.39,151.34 v2(141.07,151.65) 141.41,151.99 U42.BR38 U42.BR39 ; v2(141.07,151.01) U42.BR36 v2(141.86,151.01) ; v2(141.07,151.01) U42.BT36 v2(140.29,151.01) U42.BU36 139.68,150.89 139.3,150.89 U42.BW36 138.71,151.01 ; v2(152.76,151.01) U42.AV36 ; v1(268.1,45.84) 268.13,45.81 R1165.1 ; C812.2 18.82,54.78 v1(18.49,54.45) ; U42.CU35 127.38,150.51 127.26,150.51 v2(127.08,150.68) 127.45,151.04 U42.CU36 ; v1(267.16,131.92) 267.06,131.82 RG127.2 ; PC291.1 123.1,214.97 v2(122.98,215.1) 122.96,215.1 122.47,214.61 PC290.1 ; U42.CP7 129.56,132.56 U42.CN7 130.54,132.24 v2(130.6,132.24) 130.92,132.56 U42.CM7 131.3,132.89 v2(131.36,132.89) 131.69,133.21 U42.CK8 132.07,133.54 v2(132.13,133.54) 131.81,133.86 131.8,133.86 v2(132.13,134.19) 132.07,134.19 U42.CK10 131.8,134.51 v2(132.13,134.84) ; U42.CP7 129.44,132.51 v2(129.12,132.83) 129.44,133.16 U42.CP8 ; U42.CP7 129.44,132.26 v2(129.14,131.95) ; R726.2 v1(273.7,195.71) ; U42.AJ5 158.08,131.16 v2(158.41,130.83) ; RG111.2 207.09,169.36 v1(207.2,169.47) ; v1(11.39,95.93) 11.43,95.97 R150.1 ; U42.CP27 129.32,145.41 v2(129.12,145.64) ; U42.AR12 154.4,136.13 v2(154.4,136.28) ; U42.BL10 144.38,134.51 v2(144.06,134.84) ; U42.AG10 v2(159.2,134.19) 159.15,134.19 U42.AH9 158.88,133.86 v2(159.2,133.54) 159.15,133.54 U42.AH8 158.76,133.21 158.44,132.89 ; U42.AG10 159.91,134.84 v2(159.97,134.84) 160.16,134.84 U42.AF10 160.81,134.84 v2(160.87,134.84) ; U42.AG10 159.53,134.51 v2(159.2,134.84) 159.15,134.84 U42.AH10 158.76,134.51 v2(158.42,134.18) 158.42,133.57 v2(158.44,133.55) 158.44,132.89 ; v2(129.61,127.41) 129.66,127.46 v2(129.66,128.08) ; U42.AB7 162.81,132.56 U42.AC6 ; R370.1 v1(12.4,74.48) ; R370.1 v1(11.23,74.48) ; R370.1 v2(11.81,73.99) ; v2(176,151.87) 176.31,151.57 U42.A37 ; U42.AA12 163.46,135.88 v2(163.19,136.15) 163.15,136.15 U42.AB12 ; v1(299.47,89.42) 298.83,90.07 C716.2 ; Q96.1 119.98,143.89 v1(119.73,143.64) ; 132.41,143.6 v2(132.41,143.65) ; 132.41,143.6 U42.CK23 131.75,143.6 131.75,143.59 U42.CL23 ; 132.41,143.6 U42.CJ23 133.06,143.6 v2(133.06,143.65) 133.38,143.33 133.38,143.31 ; U42.F6 172.78,131.81 v2(172.78,131.64) 172.8,131.62 173.26,131.16 U42.E5 173.47,131.26 174.1,131.26 U42.D5 174.27,131.09 174.27,130.59 U42.D4 ; R150.1 12.53,95.97 v1(12.68,96.13) ; R150.1 v1(12.07,95.49) ; v2(135.01,145.96) U42.CE28 ; v1(19.54,17.57) 19.53,17.56 D74.1 19.53,16.39 v1(19.51,16.38) ; 138.71,151.01 U42.BY36 v2(137.92,151.01) ; 138.71,151.01 U42.BY37 v2(137.92,151.01) ; v2(158.6,154.5) 158.52,154.42 U42.AJ41 ; v1(311.26,92.47) 311.44,92.65 R839.1 ; v1(192.52,60.03) 192.5,60 191.12,60 190.92,59.8 C790.1 ; v2(151.6,154.53) 151.61,154.51 U42.AW41 ; U42.BN40 143.08,153.29 v2(143.42,153.62) 143.11,153.94 U42.BN41 143.03,153.94 v2(142.61,154.36) ; v2(247,161.79) 247.18,161.62 UG6.G14 ; PR505.1 v1(185.25,174.35) ; v2(157.58,134.17) 157.24,134.51 U42.AL10 ; v2(157.58,134.17) 157.92,134.51 U42.AJ10 ; v2(157.58,134.17) 157.59,134.16 v2(157.59,133.55) v2(157.59,132.88) 157.47,132.88 U42.AL7 157.48,132.24 ; U42.L7 169.48,132.56 U42.N6 U42.L5 v2(169.98,130.84) ; U42.L7 169.34,132.82 169.22,132.82 U42.N8 U42.N9 v2(169.21,134.19) U42.N10 ; U42.L7 169.64,132.56 v2(169.97,132.89) U42.K7 U42.H7 ; U42.BM5 143.71,131.16 v2(144.04,130.84) ; U42.BM5 143.56,131.16 U42.BN4 ; U42.BM5 142.92,131.91 U42.BN6 ; v1(257.34,124.33) 257.34,124.33 257.86,123.81 RG141.2 ; U42.BL4 144.36,130.51 v2(144.04,130.84) ; v2(137.14,132.89) 137.14,132.31 v2(137.23,132.22) 137.57,132.56 U42.CA7 137.71,132.56 v2(138.04,132.89) 138.36,133.21 ; v2(137.14,132.89) 137.14,133.43 v2(137.2,133.5) 137.2,134.08 v2(137.17,134.12) ; v2(137.14,132.89) 137.08,132.89 U42.CC7 136.53,132.56 v2(136.23,132.86) ; v2(132.13,134.84) 132.46,134.51 U42.CJ10 132.84,134.84 v2(132.9,134.84) 133.22,134.51 U42.CH10 133.74,134.84 v2(133.8,134.84) 134.12,134.51 U42.CF10 134.64,134.84 v2(134.7,134.84) ; v2(147.35,151.01) U42.BE36 ; v2(147.35,151.01) U42.BG36 v2(146.57,151.01) U42.BH36 v2(145.78,151.01) U42.BJ36 v2(144.99,151.01) ; v1(29,44.56) 29,44.86 29.37,45.23 PR643.2 ; v1(221.63,73.77) 221.97,74.1 221.97,74.11 222.46,74.61 U49.BC11 ; v2(138.8,133.54) 138.74,133.54 ; 138.74,133.54 U42.BY8 138.36,133.21 ; 138.74,133.54 U42.BY9 138.42,133.96 138.64,134.18 v2(138.81,134.18) ; U42.CD7 135.88,132.56 136.18,132.86 v2(136.23,132.86) ; U42.BH2 146.18,128.9 v2(146.22,128.9) 146.25,128.9 146.57,129.21 U42.BG2 146.95,128.89 v2(147.01,128.89) ; v1(210.57,48.76) R1133.1 ; U42.V1 165.44,128.56 v2(165.11,128.89) 164.79,129.21 U42.W2 ; v2(169.21,134.84) U42.N10 ; U42.N10 v2(168.45,134.84) ; v2(166.58,151.01) 166.64,151.01 U42.R36 ; v2(211.74,150.84) 212.13,150.45 VRAM6.T3 ; U42.BT5 140.07,130.51 U42.BV4 139.91,130.51 v2(139.58,130.18) 139.59,130.17 v2(139.59,129.54) 139.62,129.54 U42.BV2 139.9,129.21 v2(139.57,128.89) ; U42.BT5 140.79,131.09 141.42,131.09 U42.BR5 U42.BR4 141.45,130.51 v2(141.11,130.17) 141.21,130.17 141.49,129.89 U42.BR3 141.55,129.8 141.55,129.28 U42.BR2 141.46,129.21 v2(141.1,128.86) 141.19,128.86 U42.BR1 ; U42.BT5 140.72,131.23 v2(140.4,131.56) 140.04,131.91 U42.BV6 ; U42.CN5 130.25,131.16 v2(130.58,130.82) ; U42.BY1 v2(138.04,128.89) 137.71,129.21 U42.CA2 137.99,129.55 v2(138.03,129.55) 138.34,129.86 U42.BY3 138.75,129.53 v2(138.82,129.53) ; v1(221.34,76.09) 221.1,76.33 U49.AY7 ; v1(203.51,186.27) 203.33,186.27 203.06,186.54 Q87.4 ; U42.W5 164.79,131.16 v2(165.1,130.85) 165.44,130.51 U42.V4 165.59,130.61 165.59,131.07 U42.V5 165.52,131.19 165.52,131.88 U42.V6 165.49,132.02 165.86,132.39 165.86,132.85 v2(165.89,132.88) ; U42.D40 174.08,153.01 v2(174.08,152.85) 174.08,152.77 U42.E39 173.71,152.39 174.1,151.99 v2(174.1,151.87) 174.1,151.65 U42.D37 ; v2(149.19,132.24) 148.87,131.91 U42.BD6 ; U44.3 264.96,125.68 265.3,126.03 v1(265.55,126.03) ; U42.BB38 149.72,152.31 U42.BC39 ; U42.BB38 v2(150.46,152.31) 150.79,152.64 U42.BA39 150.9,152.64 v2(151.23,152.31) ; U42.BB38 149.72,151.68 U42.BC37 ; U42.BB38 150.15,151.99 v2(150.47,151.67) ; R794.2 R795.2 181.22,152.78 v1(181.36,152.92) ; U42.BR39 141.27,152.82 140.85,152.82 U42.BT39 140.51,152.79 140.04,152.79 U42.BU39 139.63,152.89 139.61,152.89 139.55,152.95 v2(139.47,152.95) 139.41,152.95 U42.BW39 138.91,152.82 138.49,152.82 U42.BY39 138.2,152.64 v2(137.88,152.31) ; U42.BR39 U42.BP39 142.34,152.64 v2(142.65,152.95) ; v2(142.53,129.54) 142.58,129.54 U42.BN2 ; C728.2 217.17,85.16 v1(216.86,85.47) ; v2(175.34,144.11) 175.34,144.06 175.01,143.73 U42.C25 ; v1(115.39,144.44) 115.29,144.54 C664.2 ; U42.BF33 147.54,148.68 v2(147.79,148.42) ; PR666.2 244.62,36.34 v1(244.78,36.34) 244.9,36.34 PR663.2 ; U42.N20 168.15,141.33 v2(168.18,141.43) 168.07,141.45 U42.P22 167.78,142.05 v2(168.11,142.38) 168.11,142.62 168.43,142.94 U42.N24 168.43,143.41 v2(168.11,143.73) 168.11,143.89 U42.P26 168.11,144.54 v2(168.11,144.9) 168.43,145.22 U42.N28 168.43,145.74 v2(168.11,146.07) 168.11,146.17 U42.P29 ; R1100.2 207.97,50.53 v1(207.47,50.03) ; R1017.1 228.21,59.66 228.41,59.87 v1(228.41,60.01) 228.41,60.21 228.21,60.41 R1009.1 ; v1(98.03,59.1) 98.33,59.4 R1013.2 ; U42.CH12 133.38,135.6 v2(133.71,135.92) ; v2(141.86,151.01) U42.BP36 ; U42.V37 165.75,151.66 v2(165.81,151.66) 165.87,151.66 U42.U38 ; v1(230.81,67.68) 230.67,67.82 R976.1 ; v1(150.07,164.17) 150.16,164.08 RG113.2 ; v1(213.3,84.17) 213.31,84.18 213.6,84.18 C731.2 ; U42.D23 174.36,142.87 v2(174.1,143.13) ; U42.C28 174.71,145.34 v2(174.71,145.07) 174.7,145.07 174.36,144.72 U42.D27 ; R785.2 148.81,157.27 R777.2 149.4,158.45 v1(149.63,158.68) ; v2(133.06,148.26) U42.CH31 ; v2(138.26,146.72) U42.CA28 ; v1(253.52,122.9) 253.37,122.75 RG146.2 ; v2(168.45,130.84) 168.12,131.16 U42.P5 ; v2(168.45,130.84) 168.77,131.16 U42.N5 ; v2(168.45,130.84) 168.77,130.51 U42.N4 168.92,130.43 168.92,129.95 U42.N3 169.48,129.21 U42.L2 169.92,128.89 v2(169.98,128.89) 170.17,128.89 U42.K2 ; U42.N17 168.11,138.9 v2(168.11,139.01) ; v2(126.41,129.99) 126.57,129.83 127.41,129.83 U42.CU3 ; U42.AC6 162.11,131.91 v2(161.79,131.6) ; U42.AC6 162.22,131.85 162.22,131.23 U42.AC5 ; v2(158.41,130.83) 158.5,130.83 U42.AH4 ; v1(115.76,49.55) 115.76,49.22 PC499.2 ; U42.K20 170.39,140.89 v2(170.06,141.44) 169.73,141.76 U42.L22 169.91,142.1 169.91,142.38 v2(170.03,142.5) 170.03,142.69 170.38,143.05 U42.K24 170.38,143.41 v2(170.06,143.73) ; v2(205,127.25) 205.03,127.21 CG513.2 ; v2(141.11,136.14) U42.BT12 v2(141.11,135.49) ; v2(127.89,132) 127.89,132.2 U42.CT7 127.83,132.77 v2(127.83,132.83) 128.14,133.14 U42.CT8 128.79,133.89 U42.CR9 128.79,134.08 v2(128.47,134.41) 128.14,134.73 U42.CT11 ; v1(262.98,216.65) 262.76,216.87 C564.2 ; U42.AC5 162.1,131.16 v2(161.77,130.83) 161.72,130.83 U42.AD5 ; U42.AC5 162.27,131.05 162.75,131.05 162.86,131.16 U42.AB5 163.02,131.16 v2(163.38,130.79) ; R873.2 218.32,85.87 v1(217.87,86.31) 217.81,86.37 PR580.1 ; v2(127.54,128.03) 128.07,128.56 U42.CT1 U42.CR1 ; v2(154.3,152.96) 154.24,152.96 U42.AT39 153.8,152.64 U42.AU38 ; 138.64,153.61 U42.BY41 ; 138.64,153.61 v2(138.69,153.61) ; 138.64,153.61 138.63,153.61 U42.BY40 ; v2(133.06,149.89) U42.CH35 ; v1(63.41,85.37) 63.41,86 62.71,86.7 R863.2 ; U42.F40 173.53,153.76 U42.E41 173.53,154.15 v2(173.8,154.41) ; U42.F16 172.97,137.82 172.06,137.82 v2(172.03,137.8) ; v2(135.47,131.49) 135.08,131.87 U42.CE6 ; v2(135.47,131.49) 135.53,131.49 U42.CD5 136.17,130.85 v2(136.25,130.85) 136.56,131.16 U42.CC5 ; v2(203.11,68.91) 203.34,68.91 203.53,69.1 U49.E22 ; v2(224.9,141.68) 224.9,141.67 UG6.AT47 ; PR518.2 201.54,106.19 v1(201.53,106.19) ; v2(172.55,134.19) 172.66,134.3 172.76,134.3 172.86,134.35 172.95,134.35 U42.F10 173.05,134.52 v2(172.73,134.84) 172.73,134.91 U42.F11 173.18,135.11 173.18,135.04 v2(173.38,134.84) 173.57,135.04 173.57,135.11 U42.E11 U42.D11 175.01,134.59 U42.C10 175.01,134.38 174.72,134.1 174.69,134.1 v2(174.68,134.09) 174.68,134.06 U42.D9 ; v2(172.55,134.19) 172.43,134.19 172.17,133.92 U42.G9 172.21,133.86 172.52,133.55 v2(172.56,133.55) ; R837.1 38.33,94.38 v2(38.23,94.48) ; U42.CF12 134.68,134.86 v2(134.7,134.84) ; CG504.2 263.71,136.26 v2(264.14,136.69) ; v2(255.02,133.26) 255.36,132.92 UG6.BH2 ; v2(147.01,128.89) 147.34,128.56 U42.BF1 ; v2(147.01,128.89) 147.01,129.34 147.39,129.73 U42.BF3 147.32,129.86 v2(147.02,130.16) 147.37,130.51 U42.BF4 U42.BF5 147.24,131.01 146.77,131.01 146.63,131.16 U42.BG5 ; v1(23.68,16.38) 23.69,16.39 D78.1 23.69,17.56 v1(23.71,17.58) ; U42.AV2 152.85,128.89 v2(152.94,128.89) ; R1184.1 26.79,23.21 v1(27.03,22.97) ; v2(137.88,152.31) 138.2,151.99 U42.BY38 ; v2(137.88,152.31) 137.55,152.64 U42.CB39 137.46,152.64 v2(137.14,152.31) U42.CC39 v2(136.35,152.31) U42.CD39 v2(135.58,152.31) ; v2(269.18,125.46) 269.18,125.1 269.42,124.85 CG518.2 ; RG125.2 262.48,132.7 v1(262.69,132.91) ; RG166.2 265.97,119.98 v1(265.87,120.09) ; U42.BC40 149.37,153.29 v2(149.7,153.61) ; v2(144.99,151.01) U42.BK37 ; v2(144.99,151.01) U42.BK36 v2(144.2,151.01) ; U42.BK37 v2(144.2,151.01) ; v2(132.82,152.96) U42.CH40 ; v1(112.08,144.88) 112.32,144.88 112.53,144.67 R801.1 ; v2(162.54,134.19) 162.21,133.86 U42.AC9 ; v2(162.54,134.19) U42.AC10 ; v2(162.54,134.19) 162.86,134.51 U42.AB10 162.98,134.51 v2(163.31,134.84) 163.63,134.51 U42.Y10 v2(164.21,134.84) ; UG6.L10 249.95,158.32 v2(249.95,158.04) ; v2(132.82,154.26) 132.88,154.26 U42.CH41 ; U42.G15 172.34,137.5 v2(172.03,137.8) ; v1(198.66,106.47) 198.66,106.16 198.55,106.05 PC398.2 ; U42.Y2 163.63,129.21 v2(163.31,128.89) 162.98,129.21 U42.AB2 162.81,129.21 U42.AC3 162.24,129.95 162.24,130.43 U42.AC4 ; UG6.K9 251.15,160.11 v2(250.96,160.3) ; R954.1 R952.1 227.91,72.26 228.12,72.46 v1(228.4,72.46) ; CN12.13 280.08,63.99 279.17,63.09 v1(278.81,63.09) ; R757.2 166.3,164.77 R754.2 166.73,164.79 166.94,164.99 v1(166.94,165.15) ; v2(202.14,51.52) 202.14,51.35 201.96,51.17 R1094.1 ; v1(272.88,134.35) 272.78,134.45 RG122.1 ; C593.1 144.76,208.32 v1(145.34,208.9) ; R769.2 v1(169.06,160.49) ; v2(140.34,132.88) 140.34,133.48 U42.BV9 140.01,133.86 v2(140.34,134.19) ; v2(155.87,130.84) 156.19,131.16 U42.AM5 U42.AM6 ; v2(155.87,130.84) 156.19,130.51 U42.AM4 ; RG108.2 259.78,176.48 259.99,176.69 260.41,176.69 v2(260.73,176.37) ; U42.F18 172.86,139.64 U42.G18 172.34,139.9 v2(172.01,140.22) 172.34,140.55 U42.G20 ; v2(149.73,154.29) U42.BB41 149.75,153.61 v2(149.7,153.61) ; v2(153.53,150.36) U42.AU35 v2(153.53,149.71) ; U42.G26 U42.H26 ; U42.G26 172.54,144.21 U42.F25 ; U42.G26 172.34,144.04 v2(172,143.71) 172,143.48 U42.G24 ; J4.2 226.46,52.21 226.66,52.41 227.96,52.41 v1(228.04,52.33) 228.19,52.19 C824.1 ; v1(270.22,182.83) 270.38,183 C614.2 ; 211.53,51.68 211.55,51.7 C822.2 211.26,52.2 211.23,52.17 R1068.2 ; 211.53,51.68 v1(211.56,51.68) ; 211.53,51.68 211.53,51.1 R1087.2 ; VRAM2.L4 235.38,177.93 v2(235,177.55) ; v1(196.47,205.82) 196.42,205.82 196.3,205.71 PR409.2 ; 157.48,132.24 U42.AL6 157.42,131.64 v2(157.59,131.64) 157.15,131.21 U42.AL5 157.16,131.16 157.55,130.77 157.55,130.18 v2(157.56,130.17) 157.56,130.17 v2(157.56,129.53) 157.24,129.21 U42.AL2 U42.AL1 157.15,128.17 v2(157.28,128.04) ; 157.48,132.24 v2(157.54,132.24) ; v2(137.92,151.01) U42.CB36 v2(137.14,151.01) U42.CC36 ; v1(268.15,46.95) 268.4,46.7 R1154.1 ; U42.AD2 161.42,129.21 v2(161.76,128.88) 162.07,128.56 U42.AC1 ; UG6.L8 UG6.M8 ; v2(163.51,151.66) U42.AA37 ; R935.1 33.76,77.09 v2(33.61,77.24) ; C834.2 230.13,50.94 230.35,51.17 v1(230.35,51.35) 230.35,51.62 230.13,51.85 C825.2 ; v2(30.92,75.94) 31.19,76.21 C745.1 ; v2(154.33,128.89) 154.39,128.89 U42.AR2 154.68,129.21 v2(154.36,129.54) 154.36,130.17 v2(154.35,130.18) ; v2(165.89,133.55) 165.81,133.55 U42.V9 165.82,134.19 v2(165.88,134.19) ; v2(165.89,133.55) 165.55,133.21 U42.V8 164.84,132.56 U42.W7 ; v2(165.89,133.55) v2(165.89,132.88) ; U42.G13 172.64,135.98 U42.F13 173.05,136.11 172.81,136.35 v2(172.81,136.45) ; v2(173.38,146.09) 173.38,145.96 U42.F28 ; v2(159.88,154.8) 160.06,154.62 U42.AF41 ; U42.CT2 U42.CU2 126.9,129.21 v1(126.84,129.16) ; v1(255.45,118.42) 255.45,118.23 255.81,117.87 QG21.4 ; v2(168.13,137.89) 167.85,137.45 U42.P15 167.73,137.43 167.57,137.66 v2(167.46,137.81) ; U42.CD36 v2(135.56,150.37) U42.CE36 v2(135.56,151.01) ; U42.CD36 v2(136.35,151.01) U42.CC36 ; U42.CD36 v2(136.33,150.37) U42.CC36 ; v2(165.81,153.61) U42.V41 v2(165.81,154.26) U42.U41 v2(165.81,153.61) ; v2(165.81,153.61) U42.V40 v2(165.81,152.96) ; U42.V3 165.61,129.86 U42.U2 166.59,128.89 v2(166.64,128.89) 166.97,129.21 U42.R2 ; 151.8,133.86 v2(152.12,134.19) ; 151.8,133.86 U42.AW9 ; 151.8,133.86 151.8,133.86 v2(152.12,133.54) ; v2(152.9,131.51) 153.3,131.91 U42.AU6 ; v2(152.9,131.51) 152.95,131.51 U42.AU5 ; C859.2 17.22,24.56 v1(17.22,25.11) ; v2(131.79,150.66) 131.79,150.69 U42.CL36 ; v1(261.29,136.46) 261.54,136.71 RG119.2 ; UG6.AE29 237.22,149.09 237.78,149.09 UG6.AE28 ; C774.1 297.83,63.2 298.38,62.65 v1(298.5,62.65) ; R1198.2 154.89,165.43 v1(155.02,165.29) ; R1092.1 204.58,51.29 204.35,51.52 v2(204.22,51.52) 204.16,51.52 203.86,51.22 R1091.1 ; v2(153.12,154.53) 153.15,154.5 U42.AU41 ; C658.2 123.59,154.82 v1(123.5,154.72) ; U42.AE39 160.47,152.29 v2(160.43,152.29) 160.36,152.29 U42.AF38 ; v2(157.79,148.42) U42.AL33 ; U42.BK10 v2(145.48,134.84) ; v2(152.94,128.89) 153.26,129.21 U42.AU2 ; v2(152.94,128.89) 153.27,128.56 U42.AU1 153.3,128.4 152.99,128.1 v2(152.95,128.1) 152.87,128.02 151.76,128.02 v2(151.69,128.09) 151.69,127.99 151.18,127.49 v2(150.91,127.49) 150.77,127.49 150.35,127.92 U42.BA1 ; R893.2 215.04,84.03 v2(214.99,84.09) ; RG165.2 268.89,119.77 v1(268.38,119.77) ; v2(129.12,147.18) U42.CP31 ; 133.38,143.31 U42.CH23 ; 133.38,143.31 133.62,143.56 v2(133.71,143.65) ; v2(140.72,148.4) U42.BU33 ; U42.CD40 v2(136.35,153.61) U42.CD41 ; v1(12.6,83.3) 12.4,83.5 R253.1 ; v1(207.78,48.38) 208.06,48.66 R1127.2 ; v2(163.51,153.61) U42.AA40 ; U42.C8 175.33,132.55 v2(175.33,132.51) 175.46,132.39 175.46,132.35 175.66,132.16 U42.B6 U42.A6 U42.A5 U42.A4 U42.A3 ; R1054.1 v1(23.27,56.65) ; v1(207.17,51.5) 207.2,51.47 R1098.1 ; U42.AD35 v2(161.97,150.36) U42.AC36 ; v1(220.45,82.25) 220.45,82.32 220.69,82.56 R907.2 ; v2(131.76,149.89) 131.54,150.15 U42.CL35 ; v2(135.47,130.19) 135.41,130.19 U42.CE3 135.73,129.21 U42.CD2 135.91,129.21 v2(136.24,128.88) 136.24,128.89 U42.CC2 136.75,129.23 136.4,129.58 v1(136.32,129.58) 136.32,130.19 v2(136.29,130.22) ; R1231.2 270.34,58.72 270.84,59.22 v1(271.67,59.22) ; v2(138.26,148.26) U42.CA33 ; v1(11.43,83.5) R253.1 ; R253.1 v2(12.07,84.02) ; v1(21.64,16.38) 21.61,16.41 D76.1 21.61,17.6 v1(21.62,17.61) ; R350.1 11.81,76.32 v1(11.98,76.48) ; R350.1 v1(12.45,76.01) ; R350.1 11.21,76.01 v1(11.05,76.16) ; v2(149.96,130.84) 150.29,131.16 U42.BA5 150.34,131.17 150.34,131.91 U42.BA6 ; v2(149.96,130.84) 149.64,131.16 U42.BC5 149.58,131.18 v2(149.23,131.53) 149.19,131.53 U42.BD6 ; v2(149.96,130.84) 150.29,130.51 U42.BA4 150.67,130.19 ; C613.1 269.62,183.38 269.13,182.89 v1(269.13,182.73) ; U42.BY6 v2(138.04,131.54) ; U42.BY6 138.35,131.91 v2(138.05,132.22) ; U42.BY6 138.73,131.61 138.8,131.61 v2(138.81,131.59) 138.81,131.56 U42.BY5 ; U49.T33 208.97,63.24 v1(209.33,62.89) ; R1093.1 201.15,51.44 201.25,51.54 v2(201.25,51.58) ; U42.AN10 155.81,134.84 v2(155.87,134.84) 155.93,134.84 U42.AM10 ; v1(222.74,85.84) 222.74,85.66 222.35,85.28 R877.2 ; C698.2 309.32,95.56 v1(309.12,95.37) ; U42.BL5 144.36,131.16 v2(144.04,130.84) ; Q112.1 232.4,51.86 231.21,51.86 231,51.65 v1(231,51.36) ; v2(136.23,132.86) 136.23,133.45 v2(136.27,133.48) 136.27,134.12 v2(136.3,134.15) ; v1(255.15,122.47) 255.15,119.38 v1(255.36,119.16) 255.6,118.92 257.03,118.92 257.41,118.54 v1(257.65,118.54) 257.68,118.57 259.42,118.57 259.75,118.9 259.75,120.67 259.69,120.73 259.69,122.01 259.39,122.3 259.39,122.41 v1(258.97,122.84) 258.75,123.06 v1(258.3,123.06) ; v1(255.15,122.47) 255.38,122.47 255.51,122.34 CG519.2 ; v1(201.07,184.54) 201.07,184.27 201.02,184.21 C612.2 ; U36.37 272,212.49 v1(272.25,212.24) ; v1(12.68,97.5) R138.1 ; R138.1 v1(11.46,97.5) ; R138.1 v2(12.07,97.94) ; U42.CM18 130.69,139.74 130.23,139.74 U42.CN18 130.13,139.61 v2(129.81,139.28) 129.8,139.26 U42.CN17 U42.CN16 ; U42.G17 172.03,138.88 v2(172.03,139.01) ; v1(12.17,87.77) 11.81,88.13 R194.1 ; v1(229.91,65.97) 229.45,65.51 R984.2 229.24,65.61 229.24,66.13 R982.1 ; R776.2 168.29,158.18 168.54,157.93 168.54,156.48 167.72,155.66 167.72,154.44 v2(167.71,154.43) 167.73,154.41 U42.P41 ; R776.2 v1(168.05,158.69) ; R776.2 167.8,158.18 167.59,157.97 167.59,156.66 166.85,155.91 166.85,154.33 166.58,154.06 v2(166.58,152.96) ; v2(142.88,156.27) 143.54,156.27 143.9,156.64 R784.1 ; v2(170.07,137.75) 170.07,137.69 U42.L15 ; v2(135.01,144.42) U42.CE24 ; C706.1 36.19,93.78 35.61,93.21 v2(35.61,93.21) ; U42.AW33 v2(152.42,148.42) ; C828.1 218.1,50.48 217.76,50.48 217.31,50.03 v1(217.31,49.87) v1(216.63,49.87) 215.85,49.87 215.27,49.29 215.27,47.33 215.48,47.13 219.04,47.13 219.25,47.33 219.25,48.61 v1(219.46,48.82) 219.46,49.16 219.19,49.43 219.19,49.44 v1(219.18,49.45) 219.19,49.46 219.19,49.73 219.83,50.37 C829.1 ; v1(113.49,133.13) 113.52,133.13 113.97,132.68 R809.1 ; v2(145.48,132.89) 145.8,132.56 U42.BH7 ; v1(11.2,90.21) 11.41,90.01 R183.1 ; U42.AM39 156.1,152.64 155.82,152.92 v2(155.82,152.97) 155.77,152.97 U42.AN40 ; v1(24.34,16.38) 24.38,16.42 D79.1 24.38,17.56 v1(24.35,17.59) ; U42.BL39 v2(143.44,152.97) U42.BN39 ; U42.CN1 130.15,128.56 v2(129.66,128.08) ; 147.06,133.55 U42.BF8 147.07,132.89 v2(147.01,132.89) 146.69,132.56 U42.BG7 146.47,132.41 146.01,132.41 U42.BH7 ; 147.06,133.55 147.06,133.55 147.38,133.86 U42.BF9 147.39,133.88 147.09,134.19 v2(147.01,134.19) 147.34,134.51 U42.BF10 ; 147.06,133.55 v2(146.99,133.55) ; R1107.2 215.32,50.38 215.05,50.1 214.72,50.1 214.42,49.8 v1(214.18,49.8) 214.25,49.87 R1099.2 ; CN9.4 7.68,82.31 8.03,81.96 8.39,81.96 8.5,81.85 CN9.A12 ; v2(172.57,132.3) 172.55,132.3 U42.G6 ; U42.CG13 134.03,136.37 v2(134.36,136.69) ; CN5.A12 8.48,95.85 8.4,95.94 7.95,95.94 7.61,95.6 CN5.B1 7.41,96.48 CN5.4 ; v1(231.48,57.01) 233.1,55.4 233.1,54.32 232.89,54.11 R1064.1 ; v2(205.3,57.25) 205.49,57.44 U49.K45 ; v1(271.83,134.25) 271.68,134.41 RG123.1 ; v2(130.58,130.82) 130.56,130.82 130.25,130.51 U42.CN4 ; v2(130.58,130.82) 130.92,131.16 U42.CM5 131.04,131.16 v2(131.36,130.84) 131.69,131.16 U42.CK5 ; C840.2 220.67,45.56 221.01,45.9 221.44,45.9 v1(221.92,46.38) ; v1(269.6,47.69) 269.49,47.59 R1142.1 ; U42.CL20 131.43,140.6 v2(131.1,140.93) ; R183.1 11.81,90.48 v1(11.87,90.53) ; R183.1 12.17,90.01 12.35,90.19 v1(12.37,90.19) ; v2(236.16,163.33) 236.45,163.63 UG6.D30 ; v2(172.56,133.55) 172.56,133.37 U42.F8 173.38,132.55 v2(173.38,132.47) 173.71,132.15 U42.E6 ; v1(164.01,157.8) 163.79,157.58 R783.2 ; v1(252.35,215.3) 252.2,215.45 251.91,215.45 PC281.2 251.85,215.03 252.12,214.76 PC289.2 252.93,214.76 PR367.1 253.13,214.75 253.28,214.9 PC285.2 ; v1(276.12,212.25) 276.36,212.49 U36.18 ; U42.CT16 128.13,137.86 127.82,137.55 v2(127.82,137.48) 127.82,137.42 U42.CU14 ; U42.AE36 160.5,150.36 v2(160.44,150.36) 160.11,150.04 U42.AF35 ; v1(213.36,50.43) 213.36,50.84 213.53,51 R1081.2 ; U42.CL24 v2(131.76,144.42) U42.CL25 v2(131.76,145.19) ; U49.C24 202.68,68.03 U49.D24 ; v1(35.66,38.06) 35.71,38.06 36.41,38.75 PR657.1 ; U42.BL2 144.37,129.21 144.04,128.89 ; v2(162.74,149.71) U42.AA35 ; v2(141.11,133.54) 141.16,133.54 ; 141.16,133.54 U42.BR9 ; v2(152.96,136.28) 152.96,136.16 U42.AU12 ; v2(166.81,140.23) U42.R18 ; v2(129.12,148.59) U42.CP32 ; v2(223.5,142.38) 223.16,142.72 UG6.AP49 UG6.AR50 UG6.AT51 ; v1(167.09,157.04) 166.64,157.04 C657.2 ; v2(127.82,145.64) U42.CT27 ; U49.F8 203.54,75.73 U49.E9 ; U42.CE17 v2(135.01,139.26) ; C619.2 200.53,181.2 200.23,181.5 v1(200.23,181.86) ; v1(203.98,72.37) 203.98,72.12 203.73,71.87 203.73,71.59 203.91,71.4 203.91,70.86 203.34,70.29 U49.E19 ; R1106.2 216.95,50.61 217.19,50.86 v1(217.19,50.98) 217.28,51.07 R1079.1 ; v1(311.48,87.09) 311.35,86.96 R865.1 ; U42.CR27 128.67,145.41 v2(128.47,145.64) ; U42.CF2 134.64,128.89 v2(134.7,128.89) 134.76,128.89 U42.CE1 ; U42.AV39 152.26,152.64 U42.AW38 151.29,151.66 v2(151.23,151.66) ; v1(177.55,124.97) 177.76,125.18 R815.1 ; CG520.2 258.3,122.47 v1(258.3,123.06) ; U42.CL14 131.43,137.11 131.76,137.44 132.98,137.44 v2(133.07,137.53) ; U42.AL12 157.15,135.97 v2(156.82,136.31) ; U42.P7 U42.R7 166.97,132.56 166.71,132.82 166.7,132.82 v2(166.68,132.84) 166.68,132.84 166.66,132.82 166.52,132.82 U42.U7 166.21,132.56 v2(165.89,132.88) ; UG6.B56 218.18,165.12 v2(217.8,165.5) ; v1(266.93,121.32) 266.93,121.71 266.72,121.91 RG149.2 ; R899.2 219.04,82.78 v1(219.21,82.61) 219.58,82.99 R901.2 ; U42.AU4 153.19,130.51 152.91,130.23 v2(152.91,130.17) 153.22,129.86 U42.AU3 ; U42.R10 167.49,134.84 v2(167.55,134.84) 167.87,135.16 U42.P11 ; U42.BA7 150.29,132.56 v2(149.96,132.89) 150.02,132.89 U42.BA8 150.31,133.21 v2(149.98,133.55) 150.03,133.55 U42.BA9 150.02,134.19 ; R775.2 v1(180.11,159.47) ; v2(149.7,153.61) 149.37,153.94 U42.BC41 ; v1(206.28,83.09) 206.07,83.31 R891.1 ; 144.04,128.89 v2(144.04,128.89) ; 144.04,128.89 144.37,128.56 U42.BL1 ; U42.E36 174.11,150.83 v2(174.11,150.94) ; v2(149.19,134.19) 149.08,134.19 148.81,133.92 U42.BD9 148.87,133.86 v2(149.2,133.54) ; v1(266.02,60.82) 265.4,61.44 PC484.2 ; R1057.2 v1(26,55.72) ; C720.2 314.55,89.6 v1(314.66,89.5) ; v2(162.54,133.54) 162.21,133.21 U42.AC8 162.1,133.21 v2(161.77,132.89) 161.45,132.56 U42.AD7 ; v2(128.79,154.5) U42.CR41 ; RG109.2 266.82,169.18 v2(266.8,169.2) ; U45.3 266.09,123.92 v1(266.05,123.96) ; U42.B39 175.66,152.52 v2(175.98,152.85) ; PR368.1 229.51,215.26 v2(228.93,215.26) ; v2(161.77,154.49) 161.59,154.31 U42.AD41 ; U42.CH17 133.38,138.94 v2(133.71,139.26) ; CN9.3 7.41,75.47 CN9.B12 7.84,76.1 7.93,76 8.39,76 8.74,76.35 CN9.A1 9.43,76.35 9.63,76.15 v1(9.63,75.73) ; R797.2 181.31,148.32 181,148.63 v1(179.89,148.63) ; v1(11.12,88.48) R194.1 ; R194.1 v1(12.37,88.48) ; v1(244.69,58.79) 244.69,58.3 244.81,58.18 244.81,57.64 245.02,57.44 C795.2 ; U42.BP12 v2(141.82,136.19) ; v1(12.07,81.47) R266.1 ; R266.1 12.53,81.97 v1(12.68,82.13) ; R266.1 11.49,81.97 v1(11.45,82.02) ; U42.A36 176.31,150.62 v2(175.98,150.94) 175.66,150.61 U42.B36 ; v2(254.17,126.7) 254.17,126.23 256.24,124.17 256.58,124.17 256.89,123.86 257.24,123.86 258.05,123.06 v1(258.3,123.06) ; v2(168.89,153.63) 168.92,153.63 U42.M40 ; U42.CN12 129.99,135.68 129.99,136.17 U42.CN13 130.2,136.37 130.72,136.37 ; U42.AG33 v2(160.09,148.42) ; v2(207.29,67.79) 207.58,68.08 U49.P24 ; D54.2 269.68,196.13 C602.2 ; v2(148.93,150.36) U42.BD35 ; v2(151.38,134.84) 151.32,134.84 U42.AY10 ; C858.2 16.46,24.56 v1(16.46,25.09) ; U42.CK1 131.7,128.56 v2(131.36,128.9) 131.05,129.21 U42.CM2 ; U42.CA13 v2(138.26,136.69) ; v2(176.24,128.33) 175.87,128.33 175.64,128.56 U42.C1 ; v1(25.82,16.35) 25.82,16.36 D80.1 25.82,17.56 v2(25.82,17.57) ; v2(129.12,151.45) 129.12,151.37 U42.CP36 ; v1(24.74,49.58) 24.58,49.75 R1115.2 ; v2(149.22,130.19) 148.9,130.51 U42.BD4 ; RG151.2 260.4,122.5 v1(260.17,122.73) ; R1170.2 209.66,43.65 v1(209.79,43.78) ; v2(164.86,142.38) 164.53,142.06 U42.W22 ; v1(18.22,16.36) 18.13,16.44 D73.1 18.13,17.54 v1(18.17,17.58) ; VRAM7.B14 273.38,151.1 v2(273.08,151.39) ; U42.CT20 U42.CU20 ; C792.1 228.25,58.76 v1(228.55,58.46) 228.14,58.05 R1031.2 ; R1182.1 25.62,25.19 v1(25.23,25.19) ; U42.CR20 128.79,140.67 v2(129.14,141.01) 129.14,140.85 U42.CP20 ; U42.AC39 162.27,152.64 v2(161.97,152.34) 161.94,152.34 U42.AD38 ; v1(167.09,158.53) 166.79,158.53 C655.2 ; U42.CD13 v2(135.66,136.69) ; v2(136.31,139.26) 136.07,138.98 U42.CD17 ; v2(176.29,128.94) 176.27,128.94 176.25,128.95 176.21,128.93 176.18,128.95 176.17,128.94 U42.B2 ; v2(172.03,137.8) 171.69,137.45 U42.H15 ; PR600.1 256.92,86.69 v1(256.53,86.3) ; v1(20.23,16.38) 20.21,16.4 D75.1 20.21,17.55 v1(20.19,17.58) ; U42.CH18 133.38,139.7 v2(133.71,140.03) 133.71,140.09 133.38,140.42 U42.CH20 133.38,140.6 v2(133.71,140.93) 133.38,141.25 U42.CH21 133.71,141.77 v2(133.71,141.86) 133.38,142.18 U42.CH22 133.38,142.42 v2(133.71,142.74) ; R735.1 210.86,192.89 v1(210.8,192.96) ; v1(167.99,165.13) 168.16,165.29 R1205.2 ; U42.CA17 137.97,138.93 v2(138.26,139.26) ; U42.F31 173.38,147.1 v2(173.39,147.1) ; v2(133.07,137.53) 133.38,137.84 U42.CH16 133.38,138.03 v2(133.71,138.36) ; v2(133.07,137.53) 133.16,137.44 v2(133.71,137.44) 133.38,137.11 U42.CH14 133.38,137.02 v2(133.06,136.69) U42.CJ13 132.62,136.2 132.19,136.2 U42.CK13 ; v2(129.14,131.95) 128.79,131.61 U42.CR5 ; v2(129.14,131.95) 129.22,131.95 129.44,131.73 U42.CP5 ; v2(173.36,142.22) 173.05,141.91 U42.F22 172.49,141.77 U42.G22 172.26,142 172.26,142.23 v2(171.99,142.5) 171.69,142.2 U42.H22 ; UG6.AE31 UG6.AE32 ; U42.P18 167.57,140.03 v2(167.46,140.23) ; v1(286.26,72.73) 286.26,71.72 286.39,71.59 C757.1 ; U42.H5 171.45,131.12 172.12,131.12 U42.G5 U42.G4 172.23,130.51 v2(172.55,130.19) 172.49,130.19 U42.G3 172.23,129.86 172.54,129.55 v2(172.55,129.54) ; v2(145.42,148.42) U42.BK33 ; CG512.2 203.76,125.6 203.5,125.86 v2(203.5,127.25) ; 150.02,134.19 v2(149.96,134.19) ; UG6.B55 UG6.A55 ; U42.G1 171.84,128.89 v2(171.78,128.89) 171.72,128.89 U42.H2 ; R1096.1 205.67,51.28 v1(205.95,51.55) 206.4,51.09 R1097.1 ; U42.BE2 148.08,129.21 v2(148.43,128.86) 148.78,129.21 U42.BD2 ; v2(166.64,130.84) 166.59,130.84 U42.U5 ; v1(208.02,169.53) 207.82,169.33 RG112.2 ; v2(127.17,145.64) 127.37,145.41 127.4,145.37 U42.CU27 ; R732.2 283.09,193.79 282.93,193.64 282.4,193.64 v1(282.29,193.75) ; v1(228.62,57.22) 228.6,57.22 228.5,57.11 R1048.2 ; R965.1 v1(229.95,69.31) ; v2(256.45,127.59) 256.05,127.99 UG6.BR2 ; v2(236.9,134.89) 236.9,135.27 UG6.BD30 v2(236.1,136.07) ; R780.2 174.89,158.39 v1(175.07,158.58) ; v1(106.95,106) 106.77,105.82 C690.2 ; v2(133.06,146.72) U42.CH30 ; v2(136.31,141.06) U42.CD21 ; v1(273.98,216.93) 273.98,216.4 R688.1 ; R771.2 v1(178.16,159.47) ; U42.CT18 128.14,139.59 v2(127.83,139.27) 128.14,138.96 U42.CT17 ; U42.AC10 162.21,134.51 v2(162.54,134.84) ; U42.AC10 162.1,134.51 v2(161.77,134.84) 161.45,134.51 U42.AD10 ; U42.H18 171.69,139.9 v2(171.36,140.22) ; R1095.1 203.05,50.15 v1(203.16,50.04) ; v1(308.57,60.54) 308.14,60.54 C782.2 ; U42.CA5 137.98,130.84 v2(138.01,130.84) 138.01,130.23 v2(138.04,130.19) 138.36,130.51 U42.BY4 138.74,130.19 v2(138.82,130.19) ; R770.2 v1(170.71,160.48) ; v2(148.43,134.84) 148.31,134.84 148.04,134.58 U42.BE10 148.1,134.51 v2(148.44,134.18) ; v1(203.98,55.91) 204.2,55.69 U49.G49 ; U42.BH7 146.2,132.9 v2(146.24,132.9) 146.23,132.92 v2(146.23,133.55) 146.24,133.57 v2(146.24,134.19) ; R725.2 278.27,197.42 v1(278.71,197.86) ; U42.CH13 133.38,136.37 v2(133.71,136.69) ; R737.2 204.62,186.74 205.42,185.94 v1(205.91,185.94) ; v1(22.31,16.38) 22.29,16.4 D77.1 v1(22.29,17.58) ; v2(176.62,145.08) 176.62,144.9 U42.A27 ; v1(206.32,55.47) 206.59,55.47 U49.M49 ; v1(260.45,118.18) 260.43,118.19 260.43,118.24 260.09,118.58 RG167.2 ; v2(166.64,134.84) U42.U10 ; RG137.1 219.84,124.17 v1(219.2,124.17) ; U42.AR38 154.99,152.3 v2(155.08,152.3) ; 150.67,130.19 U42.AY4 ; 150.67,130.19 U42.BA3 ; v2(136.31,144.42) U42.CD24 ; U42.CT12 127.82,135.88 v2(127.82,135.93) 127.82,136 U42.CT13 128.79,136.98 U42.CR14 128.89,137 129.35,137 U42.CP14 130.11,137.09 U42.CN14 130.13,136.96 130.72,136.37 ; v2(158.9,150.36) U42.AJ35 ; R758.2 164.73,164.11 164.53,164.32 v1(164.53,164.55) ; 130.72,136.37 U42.CM13 131.09,136 v2(131.09,135.93) 131.43,135.59 U42.CL12 ; v1(122.74,140.83) 122.98,140.59 R807.2 ; C827.1 98,50.68 v1(98,50.43) 98.51,50.43 C830.1 ; U42.CL23 131.11,142.95 v2(131.11,142.74) v2(131.76,142.74) 131.76,142.68 U42.CL22 131.79,142 v2(131.79,141.94) 131.79,141.8 U42.CL21 ; U42.BL8 144.38,133.21 v2(144.06,132.89) 144.38,132.56 U42.BL7 144.51,132.5 144.51,131.98 U42.BL6 ; CN5.3 7.41,89.47 CN5.B12 7.94,90.1 8.02,90.02 8.43,90.02 8.76,90.35 CN5.A1 9.43,90.35 9.58,90.21 v1(9.58,89.8) ; v2(152.91,135.49) 152.98,135.49 153.3,135.17 U42.AU11 153.29,135.16 152.97,134.84 v2(152.91,134.84) 153.24,134.51 U42.AU10 153.37,134.44 153.37,133.94 U42.AU9 153.36,133.8 153.36,133.27 U42.AU8 153.24,133.21 v2(152.91,132.89) 153.24,132.56 ; R693.2 262.34,214.9 261.58,214.14 v1(261.58,214.08) ; 154.66,133.21 154.33,133.54 v2(154.31,133.54) v2(154.31,134.19) 154.31,134.81 v2(154.33,134.84) 154.27,134.84 U42.AT10 ; U49.D25 U49.E25 ; U49.Y32 210.97,64.3 211.26,64.3 U49.AA32 ; RG134.2 274.74,124.98 275.05,125.29 v1(275.05,126.63) ; U42.CL30 131.35,147.21 v2(131.11,147.49) 131.11,147.5 U42.CL31 ; UG6.BR1 256.89,128.02 257.24,127.67 v2(257.26,127.67) ; RG143.2 270.35,122.9 270.08,122.62 269.45,122.62 v1(269.41,122.66) ; v2(170.41,152.31) U42.L38 ; R722.2 279.09,202.02 v1(279.2,201.92) ; v2(243.8,147.97) 243.8,147.97 UG6.AG20 243.46,147.62 v2(243.81,147.27) ; R734.2 274.93,192 v1(274.6,191.67) ; 138.36,133.21 138.04,133.53 v2(138.04,133.53) ; PR426.1 195.83,203.97 195.91,204.05 v1(196.35,204.05) ; R1180.1 24.61,26.28 v1(24.58,26.25) ; U42.CE33 v2(135.66,148.26) U42.CD33 ; U42.AJ38 158.92,152.39 159.04,152.39 U42.AG39 159.52,152.83 v2(159.67,152.96) ; v2(150.36,156.29) 150.78,156.7 R787.2 150.78,157.08 150.64,157.21 R781.2 ; U42.CA21 138.18,141.74 v2(138.17,141.87) ; U42.CT5 U42.CU5 127.3,131.54 v2(127.3,131.91) ; v1(219.13,79.9) 219.05,79.82 219.05,79.37 U49.AT1 ; v1(268.91,187.91) 268.76,187.76 R736.2 268.76,186.52 C606.1 ; U42.AH4 159.15,130.84 v2(159.2,130.84) 159.53,131.16 U42.AG5 159.65,131.16 v2(159.97,130.84) ; v2(169.41,140.22) 169.73,139.9 U42.L18 ; v2(144.2,151.01) U42.BL36 v2(143.44,151.01) U42.BN36 ; v2(148.93,151.66) U42.BD38 ; v2(148.43,132.89) 148.1,132.56 U42.BE7 148.37,132.24 v2(148.45,132.24) 148.77,131.91 U42.BD6 ; R1101.2 v1(194.51,50.15) ; R896.1 310.62,83.93 v1(310.4,84.14) ; v2(133.06,140.03) 132.73,139.7 U42.CJ18 132.68,139.7 132.14,139.7 U42.CK18 131.43,138.99 U42.CL17 131.81,138.5 v2(131.81,138.39) ; U42.BT40 U42.BT41 140.67,154.55 v2(140.19,155.03) ; v1(62.64,91.93) 62.08,91.37 R846.2 ; D72.3 20.78,47.18 v1(20.76,47.2) ; C793.2 C789.2 235.33,58.81 236.83,57.32 v1(236.86,57.32) ; U42.CJ25 v2(133.06,145.19) U42.CH25 ; U42.CU31 v2(127.08,147.85) U42.CU32 ; v1(222.04,69.64) 222.13,69.73 222.13,69.95 U49.BC19 ; v2(135.58,152.31) U42.CE39 ; v2(135.58,152.31) U42.CE38 ; v2(234.1,164.7) 234.35,164.95 UG6.B33 ; 153.24,132.56 v2(152.91,132.24) 152.59,132.56 U42.AV7 152.22,132.25 v2(152.16,132.25) 151.82,131.91 U42.AW6 ; 153.24,132.56 U42.AU7 ; U49.BA49 221.54,55.37 v1(221.64,55.37) ; U42.CM41 v2(130.9,154.44) ; v1(204.77,184.71) 205.02,184.71 205.35,184.38 Q88.4 ; v2(151.23,151.01) U42.BA36 ; PR384.2 252.97,212.21 PC298.2 253.05,213.01 253.34,213.01 v1(253.47,212.88) ; v1(268.06,117.59) 268.13,117.52 UG10.3 268.13,116.74 268.47,116.4 270.34,116.4 270.55,116.61 UG11.3 ; C610.2 270.48,185.26 C608.2 269.24,185.26 v1(268.97,185) ; U42.CH7 133.05,132.2 v2(132.98,132.2) 132.88,132.2 U42.CJ7 132.51,132.68 132.31,132.88 v2(132.13,132.88) v2(132.13,132.22) 132.05,132.22 U42.CK6 ; RG114.2 152.65,163.6 v1(152.72,163.54) ; U42.BP10 v2(142.52,134.84) ; RS2.1 246.5,59.45 v1(246.21,59.73) ; UG6.BT2 v2(256.48,126.89) ; v2(156.92,154.52) 156.99,154.46 U42.AL41 ; 170.72,134.94 170.5,135.13 U42.K11 v2(170.07,135.77) ; PR595.1 v1(247.15,86.2) ; U42.CP3 U42.CP2 U42.CP1 129.45,128.29 v2(129.66,128.08) ; 158.44,132.89 v2(158.44,132.89) 158.11,132.56 U42.AJ7 ; R948.2 228.07,73.8 227.93,73.66 v1(227.93,73.66) ; U42.CU4 127.25,130.58 v1(126.97,130.3) ; C656.2 166.96,157.86 v1(167.09,157.73) ; v1(285.77,86.49) 285.8,86.53 285.93,86.53 PR576.1 ; U42.AF12 v2(160.16,136.2) ; U49.AM1 216.78,80.06 v1(216.93,80.21) ; v2(125.16,212.63) 125.1,212.69 PC299.1 ; v1(270.92,70.6) 270.82,70.5 R960.1 ; U42.AC33 v2(162.4,148.42) ; U42.AM1 156.21,128.56 v2(155.87,128.9) 155.56,129.21 U42.AN2 ; v2(136.31,145.96) U42.CD28 ; v2(199.19,50.15) 199.3,50.26 R1089.2 ; U42.C34 U42.B34 175.66,149 v2(175.6,148.95) 175.11,148.45 U42.C32 ; v2(165.81,150.38) 165.87,150.33 165.9,150.33 U42.U35 ; v1(222.34,84.21) 222.39,84.16 R909.2 ; R786.2 v1(149.4,156.38) ; Q96.4 121.83,144.89 122.41,145.47 v1(122.41,145.5) ; R936.1 228.23,76.26 v2(228.6,75.89) 228.94,75.55 R941.1 ; v2(141.1,134.2) 141.17,134.2 U42.BR10 ; v2(163.51,152.31) U42.AA38 ; v2(129.12,150.01) 129.12,150.07 U42.CP35 ; v2(143.29,132.91) 143.26,132.91 142.95,133.21 U42.BN8 ; v1(270.36,48.58) 270.02,48.58 269.82,48.78 269.23,48.78 269.09,48.64 R1136.1 ; U42.AR35 155.21,150.56 155.32,150.56 U42.AN36 155.78,151.01 v2(155.83,151.01) 155.51,151.34 U42.AN37 ; PR585.1 v1(227.59,86.36) ; U42.K10 v2(169.98,134.84) U42.L10 ; v2(133.01,151.51) 133.01,151.42 U42.CH36 ; C705.2 v1(78.33,94.61) ; 132.07,130.19 v2(132.13,130.19) ; 132.07,130.19 U42.CK3 131.81,129.86 v2(132.13,129.54) 132.46,129.21 U42.CJ2 ; v1(100.83,83.05) 100.56,83.32 R895.1 ; R768.2 v1(168.04,160.49) ; U42.CA12 v2(138.26,135.92) ; R931.1 228.56,77.05 228.58,77.03 v1(228.59,77.03) ; U42.P33 U42.R33 166.92,148.74 v2(166.58,149.07) 166.59,149.07 166.9,149.39 U42.R34 167.08,149.39 U42.P35 167.88,150.19 168.35,150.19 U42.N35 ; UG6.K7 UG6.J6 ; U49.AY5 220.73,77.36 v1(220.6,77.48) 220.53,77.56 U49.AV5 ; v2(157.37,150.36) U42.AL35 ; v2(135.01,141.83) U42.CE21 ; v2(158.14,151.01) U42.AK36 ; v2(143.06,148.42) U42.BN33 ; v2(131.28,153.61) U42.CM40 ; U42.P2 168.12,129.21 v2(168.45,128.89) 168.77,128.56 U42.N1 ; PR605.1 v1(266.7,86.19) ; U42.V11 v2(165.88,134.84) U42.V10 v2(165.11,134.84) U42.V11
  BOTTOM w0.229: U49.AU25 219.48,67.5 U49.AT26 ; U49.E22 203.56,69.09 203.56,68.29 U49.E24 ; U49.AT22 219.04,68.71 219.04,68.22 U49.AT24 ; U49.AW25 U49.AW24 ; v2(218.52,67.21) 218.81,67.5 U49.AT25 ; U49.AY25 U49.BB25 221.4,67.88 221.4,68.37 v2(221.49,68.47) ; U49.AV39 220.06,60.24 U49.AW39 ; U49.AP25 218.03,67.5 v2(217.74,67.21) ; U49.P28 207.77,66.05 208.35,66.05 U49.R28 ; U49.AN25 U49.AN24 ; U49.D24 202.84,68 U49.E25
  BOTTOM w0.24: UG6.BC52 221.05,136.41 v2(221.4,136.06) ; VRAM7.D12 271.5,149.82 ; v2(235.78,175.32) 235.77,175.33 235.77,175.34 235.41,175.7 VRAM2.H4 ; v2(233.49,170.82) 233.49,170.82 233.13,171.18 VRAM2.B1 ; v2(228.95,180.68) 228.64,180.68 VRAM1.D1 ; v2(253.9,182.11) 254.31,181.7 VRAM3.C5 ; v2(243.41,178.66) 243.71,178.66 244.45,177.92 245.59,177.92 v2(245.84,178.17) 245.82,178.19 245.82,178.53 ; VRAM1.G3 VRAM1.F3 ; VRAM7.N3 264.76,142.33 v2(264.76,142.31) ; VRAM5.G3 265.91,163.95 266.27,163.58 v2(266.27,163.57) ; v2(270.76,143.08) 270.77,143.08 271.13,143.44 VRAM7.E4 ; v2(269.26,157.58) 268.89,157.95 VRAM5.L11 ; UG6.R49 223.33,155.84 223.58,155.84 v2(223.6,155.82) ; v2(262.5,143.08) 262.5,143.07 VRAM7.T3 ; 248.75,179.07 248.75,179.07 VRAM3.F12 249.13,179.46 249.49,179.82 v2(249.5,179.82) ; 237.84,163.02 v2(237.49,162.68) ; VRAM4.C12 212.12,164.95 211.75,164.58 211.75,164.57 211.75,164.57 v2(211.75,164.56) 211.74,164.57 211.74,164.57 211.38,164.93 VRAM4.D12 ; VRAM2.F12 241.38,174.2 241.74,174.56 ; VRAM1.F14 218.55,179.45 v2(218.18,179.07) 218.55,178.7 VRAM1.G14 ; VRAM7.N12 265.13,149.46 v2(265.49,149.82) 265.49,149.83 ; v2(240.98,174.56) 240.99,174.56 VRAM2.G12 ; v2(208.75,134.8) 208.75,134.82 VRAM8.H11 ; 228.41,178.7 v2(228.85,179.14) ; VRAM1.E4 226.13,180.21 v2(225.76,180.58)
  BOTTOM w0.245: v2(241.75,174.56) 241.74,174.56 241.38,174.92 VRAM2.G12 ; VRAM8.U14 201.23,137.84 v2(201.23,137.92) ; VRAM8.U14 201.63,137.41 201.3,137.08 v2(201.25,137.08) ; VRAM8.U14 201.67,137.45 202,137.78 202,137.87 v2(202.04,137.9) ; v2(222.12,181.96) 221.89,181.96 VRAM1.C10 ; VRAM1.T5 225.1,171.67 v2(224.87,171.67) ; v2(200.39,134.78) 200.81,135.2 VRAM8.V11 200.89,135.2 v2(201.25,135.56) ; VRAM8.D1 211.38,127.62 211.75,127.25 211.77,127.25 v2(211.8,127.22) 211.32,126.74 CG515.2 ; v2(212.34,162.94) 212.32,162.97 212.32,163.26 VRAM4.C10 ; v2(202.04,166.86) VRAM4.U14 ; VRAM4.U14 201.27,166.09 201.26,166.09 v2(201.23,166.06) ; VRAM4.U14 201.23,166.84 v2(201.23,166.92) ; v2(205,144.07) VRAM6.G12 205,143.32 v2(205,143.31) 204.63,143.68 VRAM6.F12 ; VRAM8.N1 204.63,127.62 204.72,127.52 v2(205,127.25) 205,127.32 VRAM8.M1 ; UG6.D6 253.25,163.46 v2(253.04,163.25) ; v2(234.25,171.56) 234.25,171.57 VRAM2.C3 234.63,171.95 235.02,172.33 ; UG6.D21 242.75,163.55 242.93,163.37 242.94,163.37 242.94,163.35 v2(243,163.29) ; v2(211.55,166.95) 211.55,166.62 VRAM4.D14 ; VRAM1.N12 220.47,173.85 220.49,173.85 v2(220.51,173.83) ; v2(225.68,164.72) 225.95,164.99 UG6.B45 ; v2(241.73,180.58) 241.71,180.58 241.38,180.91 VRAM2.R12 241.36,180.95 v2(240.99,181.32) ; v2(248.76,183.65) 248.38,183.26 VRAM3.A13 248.34,183.2 v2(247.99,182.84) 247.63,182.48 VRAM3.B14 v2(247.23,182.84) ; v2(264.73,149.06) 264.74,149.06 VRAM7.N12 ; UG6.U21 v2(243.1,154.27) UG6.U20 ; v2(218.98,173.83) 218.96,173.83 218.63,174.16 VRAM1.N14 218.51,174.2 v2(218.15,173.83) ; v2(243.33,182.05) 243.27,182.05 VRAM2.U14 242.95,182.45 v2(243.35,182.84) ; UG6.F21 242.75,162.45 v2(243.02,162.72) ; v2(255.49,182.82) 255.13,183.18 VRAM3.A4 254.7,183.62 v2(254.7,183.64) ; v2(209.49,157.81) VRAM4.F3 v2(210.26,158.58) ; UG6.E31 235.4,162.67 v2(235.39,162.67) ; v2(212.62,148.31) 212.62,148.45 VRAM6.T5 ; VRAM4.D1 211.38,156.69 v2(211.86,156.21) ; v2(219.36,138.94) 219.08,139.22 UG6.AW55 ; v2(236.19,160.49) 236.19,160.66 UG6.H30 ; UG6.AF8 v2(252.2,148.67) UG6.AE7 ; v2(221.79,163.18) 221.79,163.68 UG6.D51 ; VRAM7.R12 263.64,149.45 264.01,149.81 v2(264.01,149.82) ; VRAM6.T10 212.29,145.36 212.29,145.76 212.36,145.83 v2(212.36,145.84) ; v2(228.85,182.85) 228.45,182.45 VRAM1.B1 ; 271.5,149.82 v2(271.5,149.84) ; v2(248.74,182.07) 248.75,182.07 VRAM3.C12 249.14,181.7 v2(249.52,181.32) 249.5,181.32 VRAM3.D12 249.11,180.95 v2(248.74,180.57) ; v2(217.27,166.88) 217.24,166.84 v2(217.24,166.29) 217.29,166.24 217.82,166.24 ; UG6.AD8 251.67,149.72 v2(251.43,149.96) ; UG6.AP52 221.07,142.72 221.39,142.4 221.39,142.38 v2(221.4,142.37) ; v2(214.07,137.15) 214.03,137.15 213.63,136.75 VRAM8.A13 ; VRAM2.N1 233.15,179.45 233.51,179.81 v2(233.51,179.81) ; v2(241.75,179.06) 241.74,179.06 VRAM2.M12 241,178.32 v2(240.98,178.32) ; VRAM2.G14 242.97,174.95 v2(243.39,174.52) ; 235.02,172.33 234.65,172.7 VRAM2.D3 ; 235.02,172.33 v2(235.01,172.33) ; UG6.C31 235.74,164.42 v2(235.39,164.07) ; UG6.G20 v2(243.79,161.28) ; VRAM4.G1 209.13,156.68 209.54,156.26 v2(209.54,156.21) ; v2(235.76,177.56) VRAM2.L4 235,178.32 235,178.32 v2(234.99,178.33) ; VRAM3.F14 247.41,179.45 v2(247.07,179.79) 245.82,178.53 ; VRAM8.A11 213.98,135.55 v2(214.11,135.55) ; v2(257.05,170.05) 257.02,170.05 VRAM3.V2 256.63,170.47 256.28,170.82 v2(256.26,170.82) ; v2(233.49,182.83) 233.49,182.81 VRAM2.U1 233.01,182.33 232.81,182.13 v2(232.62,182.13) ; v2(222.1,162.66) 222.08,162.66 221.75,162.33 UG6.F51 ; VRAM5.G14 265.33,155.15 v2(265.12,155.15) ; v2(232.49,161.87) 232.25,162.11 UG6.F36 ; v2(245.91,162.68) 245.92,162.68 246.25,163 UG6.E16 UG6.D15 ; UG6.G52 221.05,161.62 221.4,161.27 v2(221.42,161.27) ; VRAM5.D14 263.25,155.32 v2(263.25,155.23) ; v2(200.49,159.34) 200.88,158.95 VRAM4.V4 201.26,158.56 v2(201.26,158.55) ; v2(226.07,163.24) 225.95,163.36 UG6.D45 ; v2(242.58,170.01) 242.14,170.45 VRAM2.A13 ; UG6.F6 253.58,161.99 v2(253.63,161.99) ; UG6.E37 231.54,163.02 v2(231.2,162.68) ; VRAM8.M3 205,128.82 v2(205,128.81) 204.63,129.18 VRAM8.N3 ; VRAM8.M3 205.75,129.57 v2(205.75,129.59) ; VRAM8.M3 205,129.57 v2(205,129.59) 204.63,129.21 VRAM8.N3 ; VRAM2.V13 242.54,183.61 242.54,183.67 v2(242.55,183.68) ; 217.82,166.24 218.32,166.24 v2(218.36,166.2) 218.58,166.2 UG6.A55 ; 217.82,166.24 217.82,165.52 v2(217.8,165.5) ; v2(219,181.33) 218.98,181.32 218.98,181.29 218.64,180.95 VRAM1.D14 ; UG6.AD49 223.4,149.48 v2(223.58,149.48) ; v2(249.52,178.32) 249.5,178.32 VRAM3.G12 248.75,179.07 v2(248.74,179.07) ; v2(221.39,148.67) 221.05,149.01 UG6.AE52 ; v2(202,143.31) 202,143.32 VRAM6.C12 202.38,143.71 202.72,144.06 v2(202.77,144.06) ; UG6.AE27 238.71,148.86 239.09,148.86 UG6.AE26 ; VRAM6.A11 200.89,144.45 v2(201.25,144.09) ; v2(236.59,171.56) 236.39,171.76 236.32,171.76 VRAM2.C5 ; v2(273.75,149.06) 274.11,148.7 VRAM7.A11 274.13,148.65 274.46,148.32 v2(274.6,148.32) ; v2(233.49,173.8) 233.49,173.8 233.13,174.17 VRAM2.F1 232.91,173.98 v2(232.65,173.98) ; UG6.U19 v2(244.5,154.27) UG6.U18 ; v2(269.26,149.06) 269.26,149.08 VRAM7.G12 269.99,149.81 269.99,149.84 v2(270,149.85) ; v2(221.39,138.17) 221.37,138.17 221.05,138.49 UG6.AY52 ; VRAM7.C12 272.67,149.45 273.03,149.81 v2(273.03,149.82) ; v2(213.26,165.33) 213.28,165.35 213.32,165.35 213.63,165.65 VRAM4.A13 v2(214.04,166.11) ; VRAM8.N3 204.25,129.57 v2(204.25,129.59) ; VRAM7.M3 265.88,142.68 266.25,142.31 v2(266.25,142.31) ; v2(221.25,183.67) 220.88,183.3 VRAM1.A11 220.88,183.18 v2(220.52,182.82) ; VRAM1.T10 221.97,171.95 v2(222.2,171.72) ; VRAM6.R1 211.38,152.15 v2(211.69,152.46) ; v2(273.75,157.59) 274.11,157.95 VRAM5.V11 274.19,157.95 v2(274.61,158.37) ; v2(272.78,147.44) 272.78,147.79 VRAM7.C10 ; 205,141.82 205,141.82 VRAM6.F14 ; 205,141.82 VRAM6.G14 ; 205,141.82 v2(205,141.75) ; VRAM5.G3 265.88,163.98 265.52,164.33 v2(265.52,164.33) ; v2(202.01,156.2) 202.01,156.31 201.63,156.69 VRAM4.U1 201.26,157.06 v2(201.24,157.06) ; UG6.U14 v2(247.3,154.27) UG6.U15 ; VRAM5.C10 262.73,158.84 262.64,158.84 262.39,159.09 v2(262.39,159.32) ; v2(227.27,183.62) 227.27,183.56 VRAM1.A2 ; UG6.AA51 222.06,151.82 v2(222.25,152.01) ; v2(235.01,175.31) 235.01,175.36 235.35,175.7 VRAM2.H4 ; UG6.U3 255.35,154.64 v2(255.01,154.98) ; v2(202.07,148.35) 202.07,148.64 VRAM6.C5 ; v2(266.99,143.08) VRAM7.L4 ; UG6.H15 UG6.H16 ; v2(212.39,160.39) 212.13,160.13 VRAM4.C5 ; VRAM3.N14 247.44,174.2 v2(247.1,173.86) ; v2(273,164.34) 273,164.32 VRAM5.T3 272.63,163.93 v2(272.25,163.56) ; VRAM1.R1 228.67,172.4 v2(228.88,172.4) ; v2(235.02,182.82) 235.38,183.18 VRAM2.V4 ; v2(211,134.79) 210.63,135.17 VRAM8.E11 ; v2(240.98,171.57) 241,171.57 VRAM2.C12 241.75,172.32 v2(241.75,172.32) 241.75,172.34 241.39,172.7 VRAM2.D12 ; CG516.2 212.97,126.97 v2(213.25,127.25) 213.92,126.57 CG517.2 ; VRAM4.C12 211.75,165.32 v2(211.75,165.34) 211.38,164.96 VRAM4.D12 211.01,165.31 v2(211.01,165.33) ; v2(200.39,165.34) 200.52,165.34 VRAM4.V13 200.46,166.11 v2(200.39,166.11) ; VRAM6.R14 211.38,142.14 v2(211.8,141.72) ; UG6.F48 223.58,162.59 v2(223.58,162.74) ; v2(202.14,162.9) 202.14,163.21 VRAM4.T10 ; VRAM1.R14 218.57,172.7 v2(218.15,172.27) ; v2(228.05,170.02) VRAM1.V2 ; v2(218.6,157.07) UG6.P55 ; UG6.F9 251.15,162.12 v2(251.41,161.86) ; VRAM4.T5 202.02,160.05 202.02,160.08 v2(201.96,160.13) ; v2(263.25,156.84) 262.9,157.2 VRAM5.C12 ; v2(249.5,175.31) 249.49,175.31 VRAM3.M12 249.5,174.57 v2(249.5,174.57) VRAM3.N12 ; v2(273.75,143.09) 274.11,143.45 VRAM7.A4 274.42,143.74 v2(274.57,143.74) ; v2(255.5,170.07) 255.49,170.07 255.13,170.43 VRAM3.V4 ; v2(217.26,164.94) 217.74,164.46 v2(217.77,164.46) 218.21,164.46 UG6.C56 ; v2(232.64,174.74) 232.92,174.74 VRAM2.G1 233.48,175.3 v2(233.5,175.3) ; v2(205.74,158.57) 205.74,158.56 VRAM4.M3 205.38,158.2 v2(205,158.58) ; v2(202.75,164.56) 202.38,164.93 VRAM4.T12 202.38,164.96 202.02,165.31 v2(201.98,165.31) ; v2(218.99,182.83) 218.98,182.81 218.63,182.46 VRAM1.B14 218.47,182.45 v2(218.18,182.15) ; v2(226.49,182.82) 226.13,183.18 VRAM1.A4 225.7,183.62 v2(225.7,183.64) ; VRAM6.D3 203.17,150.45 203.52,150.8 v2(203.52,150.82) ; v2(232.17,163.24) 232.17,163.64 UG6.D36 ; v2(221.39,154.98) 221.36,154.98 221.05,155.29 UG6.T52 ; v2(232.66,179.13) 232.7,179.13 VRAM2.M1 232.81,178.38 v2(232.65,178.38) ; v2(232.63,170.92) 232.85,170.92 VRAM2.B1 ; v2(219.74,182.08) VRAM1.C12 ; UG6.E13 v2(248,162.67) ; v2(201.25,128.06) 201.27,128.06 VRAM8.U1 201.63,127.69 201.79,127.52 v2(202.08,127.24) ; v2(202.08,141.74) 201.63,142.19 VRAM6.B14 v2(201.09,141.66) ; VRAM7.D1 271.9,141.2 v2(272.27,141.57) ; v2(202.03,150.82) 202.04,150.82 202.38,150.49 VRAM6.C3 ; UG6.E19 v2(243.8,162.67) ; v2(214.01,159.36) 214,159.35 214,159.31 213.64,158.95 VRAM4.A4 ; UG6.B42 227.85,164.92 v2(227.85,164.67) ; v2(224.79,182.01) 225.03,182.01 225.35,181.7 VRAM1.C5 ; VRAM1.V11 220.91,170.45 221.3,170.06 v2(221.3,170.04) ; v2(205,156.25) 205.06,156.25 205.38,156.56 VRAM4.M1 ; v2(235.01,170.8) 235.01,170.79 235.36,170.45 VRAM2.A4 v2(235.79,170.03) ; v2(210.24,141.72) 209.88,142.08 VRAM6.N14 ; UG6.H24 240.65,160.91 v2(240.3,160.56) 240.01,160.85 239.95,160.91 UG6.H25 ; v2(273.76,165.08) 274.13,164.71 VRAM5.V2 274.19,164.7 v2(274.58,164.31) ; v2(240.98,174.56) 241.35,174.2 VRAM2.F12 241.38,174.19 241.01,173.83 v2(240.98,173.83) 240.98,173.8 240.63,173.45 VRAM2.E11 ; VRAM6.U14 212.88,142.09 213.26,141.71 v2(213.26,141.68) ; v2(211,128.81) 211.38,129.18 VRAM8.D3 ; VRAM3.G1 257.52,178.7 257.9,179.08 v2(257.9,179.26) ; UG6.E28 237.84,163.02 ; VRAM2.D1 233.05,172.7 232.79,172.44 v2(232.66,172.44) ; v2(219,179.82) VRAM1.F14 ; VRAM8.G14 209.13,137.54 v2(209.5,137.92) 209.5,137.82 VRAM8.F14 ; UG6.C28 v2(237.5,164.07) ; VRAM5.R1 271.88,165.48 v2(271.45,165.91) ; v2(270.77,157.58) 270.77,157.6 271.11,157.95 VRAM5.P11 ; v2(243.34,180.63) 243.02,180.95 VRAM2.R14 ; UG6.G38 v2(231.2,161.27) ; v2(271.53,151.43) 271.53,151.29 VRAM7.D14 271.88,150.94 v2(272.24,150.58) ; v2(271.51,156.83) VRAM5.R12 v2(272.26,157.58) 272.63,157.22 VRAM5.T12 ; v2(239.36,171.7) 239.59,171.7 239.83,171.95 VRAM2.C10 ; UG6.E34 v2(233.29,162.66) ; UG6.AD55 v2(219.43,149.72) ; VRAM7.F3 270.38,142.7 270.76,143.07 v2(270.76,143.08) ; v2(200.44,149.27) 200.45,149.27 VRAM6.A4 200.89,149.7 v2(201.25,150.06) ; UG6.BT3 255.35,126.88 v2(255.51,126.71) ; UG6.AV3 v2(255,140.27) ; UG6.AM5 v2(253.6,144.47) ; v2(235.01,173.84) 235.01,173.83 235.38,173.47 VRAM2.E4 ; VRAM1.G1 228.41,178.7 ; UG6.BG55 v2(218.61,133.96) ; 247.98,173.07 v2(247.98,173.08) ; v2(201.98,128.82) 202,128.82 VRAM8.T3 202.38,129.21 202.49,129.33 202.73,129.56 v2(202.75,129.56)
  BOTTOM w0.25: UG6.A19 244.15,165.81 v2(243.81,165.47) ; UG6.BR30 236.6,128.17 236.6,128.17 v2(236.6,128.5) 236.6,128.58 v2(236.15,129.04) ; v2(227.69,129.08) 228.04,129.42 UG6.BN42 ; v2(227.69,129.08) UG6.BN43 ; v2(227.69,129.08) UG6.BP42 ; v2(221.4,140.26) 221.05,140.61 UG6.AU52 ; VRAM6.F1 204.45,152.13 v2(204.45,152.5) ; v2(225.12,139.01) 224.76,139.01 UG6.AW47 ; v2(256.41,150.78) UG6.AB1 ; v2(205,156.25) 204.79,156.45 204.79,156.53 VRAM4.N1 ; UG6.BP32 v2(234.71,129.06) ; UG6.BN44 226.63,129.42 v2(226.29,129.08) ; UG6.AE28 237.85,149.03 v2(238.2,149.38) 238.55,149.03 UG6.AE27 ; v2(245.9,164.07) UG6.C16 ; VRAM3.F12 249.5,179.07 v2(249.5,179.07) 249.5,179.06 249.14,178.7 VRAM3.G12 ; v2(230.5,129.07) UG6.BP38 ; v2(230.5,129.07) UG6.BN39 ; v2(230.5,129.07) 230.84,129.42 UG6.BN38 ; UG6.BN45 v2(226.29,129.08) ; v2(226.29,129.08) UG6.BP44 ; v2(227.97,133.14) 227.97,133.54 UG6.BG42 ; v2(229.09,129.08) UG6.BP40
  BOTTOM w0.254: UG6.AU54 219.66,140.62 v2(220.01,140.27) ; JDIM2.103 146.78,88.04 147.22,87.59 v1(147.3,87.59) ; U49.AA35 211.91,62.1 v1(211.91,62.08) 211.55,61.71 U49.AA37 ; U49.AP26 218.23,66.92 v2(218.52,67.21) 218.61,67.21 U49.AT26 218.5,66.52 v1(218.5,66.51) 218.54,66.51 U49.AT28 ; v2(230.3,133.16) 230.3,133.18 230.15,133.33 UG6.BG39 ; JDIM2.5 122.28,87.85 123.09,87.03 123.16,87.03 v1(123.24,86.95) ; UG6.H16 246.25,160.92 v2(245.89,160.56) ; v2(266.24,148.3) 266.24,148.3 266.63,148.68 VRAM7.L11 ; U49.BA41 221.67,59.76 v1(222.02,60.11) 222.24,60.33 U49.BC39 ; VRAM8.D12 211.38,135.96 v2(211.01,136.33) ; v1(132.94,97.58) 132.94,97.57 133.08,97.43 JDIM1.48 ; JDIM2.65 137.28,87.69 v1(138.2,86.77) ; JDIM2.172 166.03,82.98 v1(166.44,83.39) ; UG6.AT47 224.8,141.07 v2(225,141.07) ; UG6.BN46 225.25,129.42 v2(224.9,129.07) ; UG6.BN46 225.36,129.53 225.36,130.01 UG6.BM46 v2(225.6,130.47) UG6.BL46 ; UG6.BN46 UG6.BN45 ; U42.BE39 147.68,152.64 v2(147.35,152.31) ; JDIM2.222 178.53,83.01 178.11,83.43 v1(177.95,83.43) 177.53,83.01 JDIM2.218 ; UG6.U42 228.05,154.61 v2(227.7,154.27) UG6.U43 ; CN13.39 v1(110.87,59.68) ; v1(138.15,101.78) 138.13,101.78 137.33,102.58 JDIM1.65 ; v2(253.77,160.28) 253.31,160.28 UG6.J6 ; v2(220.51,181.34) 220.51,181.33 VRAM1.D12 220.11,180.95 v2(219.73,180.57) ; v1(173.17,97.58) 173.58,97.17 JDIM1.202 ; v2(168.11,152.31) 168.05,152.31 U42.P38 ; UG6.AW6 252.97,139.22 v2(252.8,139.04) ; v2(219.69,183.63) 219.69,183.51 VRAM1.A13 219.36,183.2 v2(218.99,182.83) ; v1(257.9,115.65) 257.23,116.32 QG21.1 ; U49.AP12 217.56,74.23 217.05,74.23 U49.AM12 216.58,73.77 v1(216.41,73.77) 216.1,74.08 U49.AK12 ; v2(254.16,147.6) 254.3,147.6 254.32,147.62 UG6.AG4 ; 254.65,135.02 v2(254.31,134.67) ; U49.W27 U49.W28 210.76,65.77 v1(211.08,65.77) ; v2(272.92,165.91) 273.38,165.45 VRAM5.U1 273.39,165.45 v2(273.76,165.08) ; U49.AG12 214.41,74.08 214.66,73.83 v1(214.66,73.78) ; U49.Y18 210.73,70.98 v2(211.13,71.39) 210.77,71.76 U49.Y17 ; UG6.AD47 224.55,149.72 v2(224.9,150.06) ; UG6.BA55 218.95,137.83 v2(218.61,138.17) ; UG6.AJ13 v2(248,145.87) ; UG6.AK2 255.78,145.79 v2(255.63,145.79) 255.63,145.94 UG6.AJ3 ; 220.8,135.02 v2(220.84,135.07) ; 220.8,135.02 220.8,134.55 221.03,134.32 UG6.BF52 ; 220.8,135.02 UG6.BE53 ; VRAM3.V11 249.88,170.45 249.74,170.58 v2(249.5,170.82) ; U49.Y38 210.68,60.81 210.37,60.5 210.37,60.47 ; v2(208.75,142.54) 209.1,142.2 VRAM6.M14 ; U49.AA25 211.35,67.51 v1(211.74,67.9) ; UG6.BH55 219.05,132.92 v2(219.34,132.63) ; v2(223.6,164.7) 223.6,164.87 UG6.B48 ; UG6.AA47 224.3,152.07 v2(224.09,152.07) 224.09,152.28 UG6.Y48 ; v2(149.94,129.53) 150.01,129.53 U42.BA3 ; CN12.1 282.51,60.99 282.26,60.74 CN12.76 280.61,59.89 v1(280.44,59.71) ; v2(228.4,149.37) 228.75,149.02 UG6.AE41 228.86,148.91 229.34,148.91 UG6.AE40 UG6.AE39 UG6.AE38 UG6.AE37 UG6.AE36 UG6.AE35 UG6.AE34 UG6.AE33 234.35,149.04 v2(234.69,149.37) 235.04,149.02 UG6.AE32 ; v2(274.63,162.87) 274.45,162.87 VRAM5.V4 273.75,163.57 v2(273.75,163.59) ; v2(234,160.57) UG6.H33 UG6.H32 ; v2(200.39,136.34) 200.75,136.7 VRAM8.V13 ; v1(166.28,87.46) 165.78,87.96 JDIM2.171 ; v2(219.74,171.56) 220.13,171.94 VRAM1.T12 v2(220.52,172.34) 220.49,172.34 220.13,172.7 ; VRAM5.C5 262.68,162.25 v2(262.68,161.92) ; VRAM6.P4 v2(211.02,149.3) ; UG6.AN8 251.5,143.42 v2(251.34,143.58) 251.85,144.09 UG6.AM8 251.85,144.14 v2(252.2,144.48) 252.21,144.48 UG6.AL7 ; UG6.A51 221.73,165.82 v2(221.39,165.48) ; VRAM4.F1 209.88,156.67 v2(210.34,156.2) ; v2(202.73,135.57) 202.38,135.92 VRAM8.T12 202.37,135.95 v2(202.01,136.31) ; VRAM5.M3 270,164.32 VRAM5.N3 270.38,163.93 270.74,163.57 v2(270.74,163.57) 270.74,163.56 271.11,163.2 VRAM5.P4 271.13,163.17 271.5,162.79 v2(271.5,162.79) ; VRAM5.M3 269.61,163.95 269.25,163.58 v2(269.25,163.57) 269.25,163.57 VRAM5.L4 ; VRAM5.M3 269.63,163.94 269.99,163.58 v2(269.99,163.57) ; JDIM2.85 142.28,88.13 v1(142.88,87.53) ; JDIM1.248 185.08,97.58 v1(185.06,97.59) ; U42.AW6 151.72,131.91 v2(151.39,132.25) ; R1052.1 v1(231.48,57.01) ; U49.AK30 215.53,64.79 v1(215.45,64.71) ; UG6.AJ17 245.54,146.22 v2(245.19,146.57) 244.85,146.22 UG6.AJ18 UG6.AJ19 ; U49.AA13 211.55,73.3 v2(211.98,72.87) ; VRAM4.A11 213.67,164.2 214,164.53 v2(214,164.56) ; v2(221.39,165.48) 221.05,165.82 UG6.A52 ; v2(221.39,165.48) 221.05,165.14 UG6.B52 ; v1(180.04,98.23) 179.58,97.77 JDIM1.226 ; UG6.AK6 252.79,145.52 v2(252.74,145.47) ; UG9.3 242.15,117.07 241.62,116.54 v1(241.62,116.49) ; v1(219.33,74.33) 219.58,74.58 U49.AV11 ; v2(267.01,163.57) 267,163.56 266.99,163.56 VRAM5.H4 ; UG6.U41 228.75,154.62 v2(229.1,154.96) 229.44,154.62 UG6.U40 ; UG6.H45 225.99,160.92 226.22,160.69 v2(226.22,160.52) ; U49.Y13 210.67,73.31 v2(210.2,73.78) 210.19,73.78 210.18,73.8 210.08,73.8 209.82,74.06 U49.V12 U49.T12 ; v2(274.6,141.59) 274.59,141.6 v2(274.59,142.31) 274.49,142.31 VRAM7.A2 274.13,141.92 v2(273.77,141.57) 273.75,141.57 VRAM7.B1 273.38,141.17 273.78,140.77 v2(273.78,140.72) ; U49.M17 206.9,71.44 207.19,71.15 v1(207.19,71) ; v1(131.73,86.88) 131.68,86.88 130.94,87.62 130.94,88.36 130.78,88.52 JDIM2.39 ; v1(208.84,68.44) 208.86,68.44 U49.U24 ; v2(245.89,165.47) 245.55,165.13 UG6.B17 ; v1(147.3,86.95) 147.46,87.11 147.5,87.11 147.88,87.49 147.88,88.11 147.78,88.22 JDIM2.107 ; VRAM7.H4 268.51,143.08 v2(268.51,143.08) ; UG6.B38 230.85,165.13 v2(231.19,165.47) ; v2(234.38,163.23) 234.37,163.25 234.37,163.7 UG6.D33 ; v1(181.98,83.42) 181.53,82.96 JDIM2.234 ; v1(219.81,59.79) 219.61,59.59 U49.AU41 ; UG6.K36 232.27,159.52 v2(232.6,159.19) ; VRAM3.T10 250.85,171.72 v2(251.25,171.72) ; v2(222.81,157.06) 222.47,156.72 UG6.P50 UG6.R51 ; U49.AA23 211.37,68.27 v1(211.74,68.65) ; v2(202.77,128.07) 203.13,127.71 VRAM8.R1 203.5,127.32 v2(203.5,127.25) ; v2(213.18,160.39) 212.4,160.39 v2(212.39,160.39) ; v2(203.49,165.35) 203.49,165.31 VRAM4.R12 ; v2(240.22,171.57) 240.2,171.6 240.2,171.6 239.88,171.92 VRAM2.C10 ; v2(264.75,156.05) 265.1,155.7 VRAM5.F14 ; VRAM4.R3 203.13,158.18 v2(203.5,157.81) ; v2(171.93,149.06) 171.6,148.74 U42.H33 U42.J33 170.74,148.74 v2(170.42,149.06) 170.74,149.39 U42.J34 ; v2(171.93,149.06) 172.25,149.39 U42.G34 ; v2(171.93,149.06) 172.26,148.74 U42.G33 ; v2(218.6,144.47) 218.95,144.13 UG6.AM55 ; VRAM6.B1 201.63,152.07 v2(201.25,152.44) ; v2(177.05,135.15) 177.02,135.15 176.93,135.24 U42.A11 ; v1(215.55,73.81) 215.28,74.08 U49.AH12 ; UG6.AR5 254.14,141.83 254.14,141.33 v2(254.14,141.33) 254.64,141.33 UG6.AT4 ; VRAM4.G14 209.27,166.59 209.27,166.95 v2(209.27,166.96) ; JDIM1.184 169.08,97.94 169.9,98.77 v1(169.93,98.77) ; v2(239.61,164.07) 239.95,164.41 UG6.C25 239.95,164.45 240.22,164.72 v2(240.38,164.72) 240.39,164.73 240.39,164.86 UG6.B24 ; v2(252.2,161.27) UG6.G8 UG6.H9 ; v1(172.63,100.91) 172.88,100.91 173.33,101.35 JDIM1.201 ; v2(226.49,170.02) 226.13,170.39 VRAM1.V4 ; CN17.4 202.25,45.1 202.09,44.94 v1(202.09,44.48) ; UG6.D18 244.85,163.53 v2(245.09,163.29) ; U49.BC25 222.56,67.5 v2(222.85,67.79) 222.56,68.08 U49.BC24 ; v2(243,164.7) 242.75,164.96 UG6.B21 UG6.A21 UG6.A20 243.46,165.82 v2(243.81,165.47) ; v2(203.39,156.19) 203.23,156.35 203.23,156.59 VRAM4.R1 203.11,156.7 202.77,157.04 v2(202.75,157.04) ; v1(208.05,70.09) 207.83,69.87 207.82,69.87 U49.P21 ; v2(251.49,138.88) 251.83,139.22 UG6.AW8 ; v1(168.01,88.19) 168.28,88.45 JDIM2.181 ; v2(248.77,163.33) 249.05,163.61 UG6.D12 ; v2(213.25,128.04) 212.9,127.7 VRAM8.B1 ; v1(221.89,57.39) 222.15,57.65 U49.BB44 ; PU29.5 277.92,91.44 v3(278.03,91.33) ; UG6.L3 255.35,158.7 v2(255.65,158.4) 255.93,158.12 UG6.M2 ; v2(242.5,181.34) 242.5,181.34 242.88,180.97 VRAM2.R14 ; JDIM2.73 139.28,88.62 139.12,88.47 139.12,88.04 139.6,87.56 v1(139.64,87.56) ; v2(256.53,139.1) 256.41,139.22 UG6.AW2 ; UG6.N54 219.44,157.63 v2(219.44,158.12) 219.43,158.12 UG6.M55 ; U49.BC35 222.44,62.53 222.13,62.22 v2(222.12,62.22) ; v2(213.69,63.04) 213.69,62.67 U49.AE35 ; VRAM8.G12 209.5,136.32 v2(209.5,136.33) ; v2(201.25,164.56) 200.89,164.2 VRAM4.V11 200.81,164.2 v2(200.39,163.78) ; v2(220,136.06) 219.65,136.41 UG6.BC54 ; UG6.H4 255.21,160.36 v2(255.21,160.29) 254.72,160.29 UG6.J4 ; UG6.AJ40 229.35,146.32 228.85,146.32 UG6.AJ41 228.64,146.33 228.16,146.33 UG6.AJ42 v2(227.7,145.87) ; VRAM2.P4 235.74,180.56 v2(235.74,180.58) ; U42.AR41 154.72,153.97 154.72,154.45 v2(154.75,154.48) ; U46.5 213.45,101.6 212.96,102.1 v1(212.08,102.1) 211.03,102.1 C693.2 ; v1(219.56,63.4) 219.41,63.55 U49.AT33 ; v2(219.99,133.96) 219.65,134.31 UG6.BF54 ; v1(165.48,102.33) 164.83,102.99 JDIM1.167 ; v2(176.58,154.01) 176.36,153.79 175.83,153.79 U42.B41 ; U42.A17 177.09,138.8 v2(177.12,138.82) ; v2(233.46,169.97) 234.24,169.97 ; 234.24,169.97 233.88,170.33 VRAM2.A2 233.86,170.45 233.49,170.81 v2(233.49,170.82) ; 234.24,169.97 v2(234.25,169.97) ; v2(205.74,134.8) 206.13,135.18 VRAM8.L11 206.13,135.2 v2(205.76,135.56) 205.76,135.56 VRAM8.M12 205.38,135.95 205.02,136.31 205.02,136.32 v2(205,136.33) ; v2(211.73,144.08) 212.11,143.7 VRAM6.T12 ; VRAM4.M12 205.38,164.94 v2(205.76,164.56) ; VRAM5.C12 262.88,157.23 v2(262.53,157.57) ; v1(245.42,114.95) 245.82,115.34 RG179.1 246.97,115.34 CG528.2 ; CN13.21 v1(111.02,55.18) ; U49.AM38 216.83,60.92 216.51,61.23 v1(216.46,61.23) ; U49.AD9 213.1,75.55 213.1,75.91 U49.AD8 U49.AD6 U49.AD5 U49.AC5 212.21,77.67 U49.AC4 ; U49.AD9 U49.AC9 ; U49.AD9 U49.AD11 U49.AD12 213.19,73.79 v2(213.19,73.7) ; U49.K11 206.27,74.23 v1(206.35,74.23) ; v2(221.27,175.32) 221.25,175.32 VRAM1.L11 221.25,176.07 v2(221.28,176.07) ; JDIM2.184 169.03,82.84 v1(169.52,83.33) ; JDIM2.14 124.53,83.67 v1(124.9,84.04) ; UG6.BB53 220.54,137.12 v2(220.78,137.36) ; UG6.AG15 246.82,147.49 246.38,147.49 UG6.AG16 246.24,147.62 v2(245.9,147.96) 245.89,147.96 UG6.AG17 ; UG6.H27 238.36,160.73 238.36,160.51 v2(238.33,160.48) 238.29,160.48 UG6.H28 ; UG6.BG49 223.63,133.14 v2(223.63,132.94) ; U49.J9 205.49,75.32 205.8,75.63 v1(205.8,75.68) 205.51,75.68 205.48,75.71 205.33,75.71 U49.H8 ; VRAM8.N12 204.62,135.95 v2(204.25,135.57) 204.25,135.57 VRAM8.P11 ; CN12.7 281.15,62.49 279.83,61.17 v1(279.61,61.17) ; v1(285.31,206.23) 284.91,206.23 R713.1 ; CN6.33 v1(110.88,83.23) ; v2(266.25,158.34) 266.63,157.97 VRAM5.H11 ; v1(126.32,102.4) 126.29,102.4 125.83,102.87 JDIM1.19 ; v2(250.09,140.99) 250.12,140.99 UG6.AT10 ; v2(257,181.34) 257.38,180.97 VRAM3.D1 257.64,180.68 v2(257.95,180.68) ; VRAM7.A13 274.26,150.2 v2(274.55,149.9) ; UG6.B44 226.65,165.13 v2(226.99,165.47) ; v1(136.79,87.54) 136.28,88.06 JDIM2.61 ; UG6.B11 249.75,165.12 v2(250.09,165.47) ; VRAM5.G12 v2(265.5,156.82) ; v1(171.33,101.72) 171.18,101.72 170.49,102.41 170.49,103.26 170.33,103.42 JDIM1.189 ; v2(204.25,128.08) 204.63,127.71 VRAM8.N1 ; U49.AH15 215.12,72.46 v2(215.53,72.05) ; v2(227.22,180.57) 227.22,180.59 226.88,180.94 VRAM1.D3 ; U49.AE17 213.49,71.76 213.83,71.42 v1(213.87,71.42) 213.92,71.42 U49.AG17 ; JDIM2.77 140.28,87.77 v1(141.21,86.83) ; U42.A9 176.63,133.66 176.65,133.64 v2(176.86,133.64) ; v2(234.09,159.11) 234.09,159.26 UG6.K33 ; UG6.K42 v2(227.7,159.17) 228.04,158.82 v2(228.04,158.64) ; VRAM7.D1 271.48,140.8 v2(271.48,140.74) ; UG6.G17 245.55,161.65 245.3,161.9 v2(245.1,161.9) 244.85,162.16 UG6.F18 ; v1(146.4,97.55) 146.58,97.37 JDIM1.102 ; v2(252.19,165.47) 252.19,165.46 UG6.B8 ; JDIM2.175 166.78,87.08 167.64,86.21 167.76,86.21 v1(168,85.97) ; JDIM1.230 180.58,99.05 v1(180.06,99.56) ; PU30.2 287.99,90.09 ; v2(210.26,164.56) 210.26,164.55 210.61,164.2 VRAM4.E11 210.63,164.17 v2(211,163.79) ; C599.2 267.6,200.87 v1(267.47,201) ; UG6.M49 223.44,157.83 v2(224.15,157.83) 224.26,157.83 UG6.M47 ; U42.L36 170.12,150.69 v2(170.43,150.38) 170.42,150.38 170.08,150.04 U42.L35 ; v2(228.34,160.5) 228.34,160.63 UG6.H42 227.97,161 227.43,161 UG6.H43 ; JDIM2.43 v1(131.78,88.22) ; v2(205.75,163.79) 206.13,164.17 VRAM4.L11 ; v2(164.21,146.89) 163.88,147.22 U42.Y31 163.88,147.72 v2(163.38,148.22) ; JDIM1.31 128.83,103.35 128.72,103.25 128.72,102.82 v1(129.19,102.36) ; UG6.BE55 219.06,135.02 v2(219.34,134.74) ; U49.AM33 216.71,63.24 v1(216.39,62.92) ; UG6.AE54 219.66,149.02 v2(220.01,148.67) ; UG6.BK45 v2(226.3,131.17) UG6.BL44 226.77,130.7 226.77,130.24 UG6.BM44 226.76,130.01 226.76,129.53 UG6.BN44 UG6.BN43 ; UG6.BK45 v2(225.6,131.87) ; UG6.BK45 v2(225.59,131.16) UG6.BL46 ; v2(248.77,164.71) 249.05,164.99 UG6.B12 ; v1(138.2,103.07) 138.33,103.19 JDIM1.69 ; v1(207.67,79.11) 207.67,79.1 207.67,78.21 U49.P4 207.93,77.95 U49.P5 ; U42.BA1 150.29,128.56 v2(149.96,128.89) 150.14,129.07 150.2,129.07 U42.BA2 ; v2(252.82,155.78) 253.07,156.02 UG6.R6 ; 213.65,128.45 VRAM8.A2 ; 213.65,128.45 v2(214.05,128.04) ; 213.65,128.45 214.01,128.81 v2(214.05,128.81) ; VRAM6.V13 213.99,143.31 v2(213.99,143.31) ; v2(255.25,166.32) 255.35,166.22 UG6.A3 v2(255,165.47) ; v1(214.84,65.22) 214.84,65.56 U49.AJ28 ; CN12.33 282.13,68.99 281.82,69.3 v1(281.82,69.46) ; v2(210.24,127.22) 209.88,127.58 VRAM8.F1 ; v2(219.99,146.56) 219.99,146.58 219.65,146.92 UG6.AH54 UG6.AG55 ; v2(209.49,150.84) 209.13,150.47 VRAM6.M3 ; VRAM1.U1 228.77,170.8 v2(228.91,170.8) ; JDIM1.15 124.83,102.43 125.39,101.86 v1(126.27,100.98) ; v2(272.26,165.06) VRAM5.R1 ; v1(146.35,102.42) 146.83,102.9 JDIM1.103 ; v1(128.39,97.5) 128.58,97.32 JDIM1.30 ; UG6.BJ39 230.03,132.1 230.03,131.64 UG6.BK39 v2(230.5,131.17) UG6.BL38 230.97,130.71 230.97,130.24 UG6.BM38 230.97,130.01 230.97,129.54 UG6.BN38 ; JDIM1.238 182.58,97.17 182.42,97.33 182.42,99.2 v1(181.35,100.26) ; v2(226.49,173.07) 226.87,172.7 VRAM1.R3 226.89,172.7 v2(227.26,172.33) ; VRAM6.R3 211.37,150.45 v2(211,150.07) ; VRAM8.R3 203.13,129.18 v2(203.5,128.81) ; U42.M33 169.32,148.74 v2(169.65,149.06) 169.97,148.74 U42.L33 ; U49.AK35 215.99,62.47 216.39,62.07 ; VRAM6.E11 203.88,144.43 v2(204.26,144.05) ; v3(248.54,89.75) 248.46,89.83 PU34.2 ; v2(256.39,157.07) 256.05,157.42 UG6.N2 ; v3(219.21,89.75) 219.13,89.83 PU31.2 ; v2(149.96,130.2) 150.03,130.2 U42.BA4 ; v1(133.28,86.04) 133.78,86.53 JDIM2.51 ; v2(250,155.73) 250.16,155.73 UG6.R10 ; UG6.AK47 224.55,145.46 224.84,145.17 v2(224.92,145.17) 225.22,145.48 v2(225.41,145.48) ; v1(212.43,70.39) 212.35,70.47 ; 212.35,70.47 211.99,70.47 U49.AA20 ; 212.35,70.47 212.32,70.5 U49.AC18 ; UG6.K18 244.85,159.52 244.52,159.19 244.52,159.19 v2(244.49,159.17) 244.49,159.18 UG6.K19 ; U42.AD35 161.53,150.04 v2(161.21,149.71) 160.88,149.39 U42.AE34 ; v2(201.25,134) 201.28,133.97 v2(202.06,133.97) 202.06,134.13 VRAM8.T10 202.39,134.45 202.75,134.8 v2(202.76,134.8) ; v2(262.49,141.55) 262.14,141.2 VRAM7.U1 261.73,140.8 v2(261.73,140.59) ; UG6.B9 251.15,164.98 v2(250.88,164.71) ; U49.R28 208.45,66.11 208.83,65.73 v1(208.9,65.73) ; CN18.17 v1(279.36,39.95) ; UG6.AD2 255.91,149.72 v2(255.64,149.99) ; UG6.BL55 219.12,130.82 v2(219.37,131.08) ; U49.AN22 217.41,68.85 v1(217.76,69.2) 218.13,69.57 U49.AP21 ; VRAM1.N3 226.77,174.3 226.77,174.84 VRAM1.M3 227.26,175.33 v2(227.27,175.33) ; JDIM2.244 v1(184.03,82.72) ; U49.G9 204.15,75.52 204.51,75.17 v1(204.54,75.17) ; U49.L14 205.9,73.25 205.65,72.99 v1(205.65,72.98) ; UG6.AT53 UG6.AU52 ; v1(217.75,66.52) U49.AP28 ; v1(176.25,99.76) 175.58,99.08 JDIM1.210 ; UG6.B41 228.75,165.12 v2(229.1,165.47) ; UG6.AM50 222.46,144.12 v2(222.8,144.46) 223.15,144.81 UG6.AL49 ; v1(143.25,103.02) 143.33,103.09 JDIM1.89 ; UG6.BN6 253.51,129.16 v1(253.51,128.47) 253.51,128.32 253.25,128.06 UG6.BR6 ; VRAM3.T5 253.96,171.53 v2(253.83,171.53) ; U49.AD28 213.09,65.76 v1(213.09,65.21) 212.86,65.21 U49.AB28 ; UG6.B27 UG6.C28 ; 300.93,80.75 v1(302.1,80.75) ; CN12.63 281.95,76.49 v1(281.61,76.82) ; U49.V38 209.94,60.92 210.35,60.51 210.35,60.49 210.37,60.47 ; v1(209.96,58.84) 210.31,58.49 U49.W44 ; JDIM1.93 144.33,103.42 144,103.1 144,102.53 144.18,102.35 v1(144.55,102.35) ; 235.75,154.61 v2(235.4,154.27) UG6.U32 v2(234.7,154.27) UG6.U33 234.35,154.61 v2(234,154.26) 233.71,154.55 233.65,154.61 UG6.U34 v2(233.3,154.27) 232.95,154.61 ; v2(239.34,181.88) 239.69,181.88 VRAM2.T10 ; U42.R39 166.9,152.64 v2(166.58,152.96) ; VRAM7.F1 270.74,141.56 v2(270.74,141.57) ; v2(272.86,144.83) 272.86,144.43 VRAM7.C5 272.6,144.2 v2(272.25,143.85) ; v2(251.45,157.85) 251.58,157.85 UG6.M8 ; v1(268.37,185.24) 268.25,185.24 268.15,185.14 C609.1 ; UG6.J53 UG6.K52 221.06,159.52 v2(221.4,159.18) ; v2(263.2,151.43) 263.63,151 VRAM7.R14 ; UG6.AF50 222.45,148.34 222.77,148.66 v2(222.8,148.66) 222.8,148.68 223.13,149.02 UG6.AE49 ; 220.13,172.7 VRAM1.R12 ; 220.13,172.7 219.77,173.06 v2(219.74,173.06) ; UG6.AJ32 235.04,146.22 v2(234.7,146.56) 234.35,146.22 UG6.AJ33 ; CN7.27 v1(302.11,86.75) ; UG6.BH53 UG6.BJ53 220.34,132.22 v2(220,131.88) ; U49.AV45 220.17,57.34 220.42,57.34 220.49,57.27 v2(220.49,57.27) ; v1(180.17,84.82) 180.67,84.32 180.67,82.54 180.53,82.4 JDIM2.230 ; UG6.V53 220.48,153.92 v2(220.75,154.19) ; U49.M31 206.9,64.24 207.15,63.98 v1(207.18,63.98) ; v1(131.3,101.64) 131.83,102.17 JDIM1.43 ; v2(220.51,175.31) 220.14,174.95 220.13,174.95 ; UG6.AH49 UG6.AG49 222.64,147.62 v2(222.63,147.62) 222.63,147.62 UG6.AG51 ; UG6.L5 253.95,158.83 v2(253.61,159.17) ; v2(257.03,173.07) 257.03,173.04 VRAM3.R1 257.65,172.42 v2(257.87,172.42) ; v2(271.63,155.23) 271.88,155.48 VRAM5.R14 271.9,155.7 v2(272.25,156.05) ; v1(168.22,102.88) 168.33,102.99 JDIM1.181 ; v2(243.4,172.43) 243.14,172.43 VRAM2.D14 242.85,172.7 242.51,173.04 v2(242.51,173.05) ; v2(249.15,128.72) 249.17,128.7 249.17,128.14 UG6.BR12 ; v2(252.77,141.31) 252.78,141.32 UG6.AT6 ; JDIM1.90 143.58,97.22 143.32,97.48 v1(143.23,97.48) ; VRAM3.L4 255.13,175.71 255.49,176.08 v2(255.5,176.08) ; JDIM1.1 121.33,103.09 121.24,103.01 121.24,102.61 v1(121.7,102.15) ; UG6.AB4 254.99,150.78 v2(255,150.78) 255,150.77 UG6.AC3 ; VRAM7.D3 271.87,142.7 v2(271.5,142.33) ; UG6.BG36 232.25,133.16 232.22,133.12 v2(232.22,133.08) ; UG6.K21 242.75,159.56 243,159.81 v2(243,160) 243.19,160 243.41,160.22 UG6.J20 ; UG6.F53 220.44,162.32 220.72,162.6 v2(220.75,162.6) ; U49.U31 209.22,64.58 209.59,64.95 v1(209.61,64.95) ; v2(222.03,164.71) 222.03,164.84 UG6.B51 ; v2(227.99,182.82) 228.37,182.45 VRAM1.B1 ; U49.AC13 U49.AD13 213.19,73.02 v2(213.19,72.92) ; v1(134.54,99.5) 135.03,99.02 135.03,97.13 135.08,97.08 JDIM1.56 ; v1(142.92,86.88) 142.92,86.89 143.36,87.33 143.36,88.39 143.28,88.48 JDIM2.89 ; VRAM2.N14 242.88,179.48 v2(242.51,179.84) ; v2(234.25,173.06) 234.25,173.05 234.61,172.7 VRAM2.D3 ; VRAM8.N14 204.59,137.45 v2(204.24,137.09) ; VRAM2.V4 235.74,183.56 v2(235.74,183.58) ; v2(248.01,179.82) 247.63,179.45 VRAM3.F14 ; U42.D31 174.69,147.09 v2(174.69,147.09) ; JDIM1.217 177.33,103.34 177.17,103.19 177.17,101.66 178.18,100.65 v1(178.39,100.65) ; UG6.V55 UG6.W54 219.65,153.22 v2(220,152.87) ; v1(209.62,69.38) 210,69 U49.V22 ; v2(220.01,154.96) 219.65,155.32 UG6.T54 ; UG6.V2 UG6.U3 ; v2(233.48,181.33) 233.45,181.33 233.13,181 VRAM2.R1 232.79,180.61 v2(232.65,180.61) ; UG6.AK49 223.32,145.35 v2(223.63,145.35) ; JDIM2.231 180.78,87.95 181.75,86.97 v1(181.77,86.97) ; U49.AP17 218.13,71.9 v1(218.02,72) 217.47,71.45 U49.AN17 ; v2(175.32,147.1) 175.36,147.11 U42.B31 ; UG6.AA55 219,151.77 v2(219.45,151.77) 219.45,151.32 UG6.AB54 ; v2(266.25,165.1) 266.22,165.1 VRAM5.G1 ; U49.AA32 212.18,64.02 v1(212.3,63.9) ; v2(248.01,181.32) 248,181.32 VRAM3.D14 247.3,181.27 v2(247.2,181.27) ; VRAM3.E4 255.14,180.2 v2(255.52,179.82) 255.88,179.46 VRAM3.F3 ; U49.AT12 219.13,73.72 v1(219.13,73.67) ; v2(262.5,149.82) 262.88,149.45 VRAM7.T12 ; UG6.K15 v2(246.6,159.17) ; UG6.H3 v2(255.01,161.26) ; 255.86,172.7 255.5,172.33 v2(255.5,172.3) ; 255.86,172.7 VRAM3.R3 ; 255.86,172.7 255.5,173.06 v2(255.5,173.07) 255.48,173.07 255.13,173.42 VRAM3.P4 ; v2(205.76,144.08) 206.13,144.44 VRAM6.H11 206.13,144.47 v2(206.5,144.84) ; U49.U26 209.22,66.9 v1(209.59,66.54) 209.98,66.92 U49.V26 ; v1(166.86,101.68) 166.8,101.68 165.99,102.49 165.99,103.21 165.83,103.38 JDIM1.171 ; U49.M24 U49.M22 206.62,68.85 206.48,68.99 v2(206.24,68.99) ; UG6.AG47 224.58,147.62 224.87,147.33 v2(224.97,147.33) 224.56,146.92 UG6.AH47 ; JDIM1.6 122.58,97.36 v1(122.43,97.51) ; UG6.BC49 223.14,136.42 v2(222.73,136.83) ; v1(138.47,83.4) 138.03,82.95 JDIM2.68 ; UG6.AE31 UG6.AE30 UG6.AE29 ; VRAM3.A2 256.63,183.26 v2(256.27,183.62) ; VRAM3.A2 257,182.82 v2(257,182.82) 257,182.82 VRAM3.B1 257.45,182.45 v2(257.83,182.83) ; VRAM3.A2 256.98,183.55 v2(256.98,183.67) ; CN13.27 110.8,56.68 v1(110.85,56.74) ; v2(213.36,156.21) VRAM4.B1 ; v2(203.5,149.33) 203.87,149.7 VRAM6.E4 ; v1(169.28,88.27) JDIM2.185 ; UG6.AG21 UG6.AG20 ; v2(270.75,165.05) 270.38,165.43 VRAM5.N1 ; UG6.D49 v2(223.5,163.37) 223.85,163.71 UG6.D48 ; U49.AP45 217.87,57.78 217.87,57.79 v2(217.87,57.9) ; v2(260.99,162.79) 261.38,163.17 VRAM5.A4 261.39,163.2 261.75,163.56 v2(261.75,163.57) ; v2(163.42,145.29) v2(163.42,144.69) 163.42,144.1 ; v2(214.05,130.39) 214.05,130.37 VRAM8.A4 ; JDIM1.61 136.33,103.28 136.11,103.06 136.11,102.54 136.44,102.21 v1(136.59,102.21) ; UG6.V49 223.16,153.92 v2(223.51,153.57) ; v1(220.86,68.57) 220.74,68.57 U49.AW24 ; v1(210.37,60.44) 210.37,60.47 ; UG6.BJ35 232.84,132.11 232.84,131.63 UG6.BK35 v2(233.3,131.17) UG6.BL34 233.76,130.71 233.76,130.23 UG6.BM34 233.76,130.01 233.76,129.53 UG6.BN34 233.65,129.42 v2(233.3,129.07) ; UG6.C34 233.65,164.44 233.91,164.7 v2(234.1,164.7) ; UG6.AF5 253.94,148.32 v2(253.59,148.67) ; v2(211.84,57.25) 212.03,57.44 U49.AC45 ; v1(176.23,98.24) 176.67,97.79 176.67,97.31 176.58,97.21 JDIM1.214 ; 98.86,116.83 98.89,116.86 C873.2 ; UG6.B29 237.15,165.13 v2(237.5,165.48) ; v2(213.25,136.3) 213.27,136.32 213.27,136.34 213.63,136.69 VRAM8.A13 ; v1(216.21,70.22) 216.57,70.58 U49.AL19 ; UG6.BD48 223.85,135.58 v2(223.57,135.3) ; 216.39,62.07 216.42,62.07 216.82,62.47 U49.AM35 ; 216.39,62.07 v1(216.39,62.04) ; v2(251.5,139.57) UG6.AV8 UG6.AU7 ; UG6.AA6 253.2,151.77 v2(252.77,151.77) 251.9,151.77 UG6.AA8 251.6,151.57 250.7,151.57 250.45,151.82 UG6.AA10 ; UG6.AJ21 v2(243.1,145.87) UG6.AJ20 ; v2(224.2,129.78) 224.2,129.77 UG6.BN47 224.56,129.42 v2(224.9,129.07) ; v2(224.2,129.78) 224.19,129.78 UG6.BM48 v2(224.19,130.46) ; v2(224.2,129.78) 223.85,129.43 UG6.BN48 v2(224.2,129.07) 223.85,128.72 UG6.BP48 ; JDIM2.36 v1(130.03,82.7) ; v2(250.24,177.59) 249.88,177.95 VRAM3.H11 ; U40.3 272.85,200.5 272.65,200.7 272.24,200.7 v1(271.55,200.01) ; UG6.AC5 253.6,150.77 v2(253.6,150.78) ; CN18.14 279.44,41.45 v1(279.3,41.31) ; v2(270.78,149.07) 270.78,149.05 271.13,148.7 VRAM7.E11 271.48,148.34 v2(271.48,148.32) ; CN12.57 281.51,74.99 v1(281.5,74.98) ; v1(220.89,74.59) 220.71,74.76 U49.AW11 ; U49.AK18 215.61,71.36 v1(215.61,71.42) ; UG6.AG14 UG6.AG13 248.35,147.66 248.69,148 v2(248.72,148) ; v2(256.26,180.58) 255.9,180.95 VRAM3.D3 v2(255.5,181.32) 255.88,181.69 VRAM3.C3 255.88,181.72 v2(256.22,182.07) ; v2(174.69,147.09) 174.96,147.55 U42.C31 ; v2(174.69,147.09) 174.7,147.05 U42.D29 ; v2(200.47,144.83) 200.49,144.83 VRAM6.A11 ; v2(248,140.97) 247.65,140.62 UG6.AU14 ; UG6.H22 v2(241.71,161.26) UG6.G23 ; v1(132.93,98.99) 132.57,98.99 132.08,98.5 JDIM1.44 ; UG6.AM48 223.85,144.12 224.1,143.87 v2(224.1,143.64) 224.33,143.64 UG6.AN47 ; v1(125.01,83.4) 125.53,82.89 JDIM2.18 ; VRAM2.M14 243.37,178.7 v2(243.41,178.66) ; v2(213.26,157.81) 213.26,157.81 VRAM4.A2 213.63,157.45 v2(213.99,157.81) ; UG6.AJ35 232.96,146.22 v2(233.3,145.87) 233.65,146.22 UG6.AJ34 ; v1(133.27,87.48) 132.78,87.98 JDIM2.47 ; UG6.AJ39 230.32,146.39 230.68,146.39 UG6.AJ38 230.97,146.34 231.43,146.34 UG6.AJ37 v2(231.91,145.86) 232.25,146.21 UG6.AJ36 ; 212.9,77.67 v2(213.19,77.96) 213.48,77.67 U49.AE5 ; v2(253.61,152.86) UG6.Y5 UG6.AA4 ; v2(204.91,137.99) 205.38,137.52 VRAM8.M14 ; UG6.F2 255.99,162.32 255.87,162.44 255.81,162.44 255.73,162.52 v2(255.55,162.52) ; UG6.G11 UG6.F12 249.05,162.24 v2(248.74,161.93) ; VRAM8.F12 209.87,135.95 v2(209.49,135.56) ; JDIM2.27 127.78,88.32 v1(127.98,88.12) ; v2(224.9,129.07) 225.25,128.73 UG6.BP46 ; U49.E33 203.54,64.05 v1(203.76,64.26) 203.69,64.26 203.34,64.62 U49.E31 ; UG6.BG30 236.45,133.34 v2(236.25,133.13) ; JDIM1.235 v1(181.83,102.95) ; v2(35.89,87.48) 35.89,87.82 36.07,87.99 C724.1 ; v2(236.2,161.91) 236.45,162.16 UG6.F30 ; UG6.F4 254.93,162.05 v2(255.11,162.05) 254.68,161.62 UG6.G4 ; UG6.AE14 247.65,149.01 v2(247.3,148.67) UG6.AE15 UG6.AE16 ; v1(176.53,82.66) JDIM2.214 ; U49.M38 206.77,60.65 v1(206.4,60.65) 206.17,60.42 U49.K39 ; VRAM8.V13 200.46,137.11 v2(200.39,137.11) ; VRAM8.V13 201.25,137.07 v2(201.25,137.08) ; v1(286.12,202.9) 286.12,202.87 286.51,202.48 C597.1 ; v2(205.34,152.48) 205.38,152.44 VRAM6.G1 ; JDIM2.86 142.53,83.42 141.86,84.09 141.59,84.09 v1(141.5,84.17) ; v1(289.56,76.16) 290.15,75.57 C748.1 ; UG6.B1 257.1,165.47 v2(257.1,165.62) ; 163.42,144.1 163.53,144.21 U42.Y26 ; 163.42,144.1 v2(163.41,144.09) ; UG6.H46 225.25,160.93 v2(224.9,161.28) 224.55,160.94 UG6.H47 UG6.H48 ; v2(241.75,179.06) 241.75,179.07 VRAM2.N12 241.38,179.47 v2(241.02,179.82) 240.65,180.2 VRAM2.P11 ; v2(233.3,129.07) UG6.BN35 ; v2(233.3,129.07) UG6.BP34 v2(234,128.37) ; U49.F8 204.27,76.09 v1(204.41,75.94) ; UG6.AG10 250.2,147.37 v2(250.01,147.37) 250.01,147.89 v2(250.1,147.97) 250.44,148.32 UG6.AF10 250.79,148.66 v2(250.8,148.66) 251.15,149.01 UG6.AE9 ; JDIM1.26 127.58,97.14 127.59,97.16 127.59,97.79 v1(127.09,98.29) ; v2(262.7,147.28) 262.7,147.77 VRAM7.T10 ; VRAM1.F3 226.87,179.45 v2(226.49,179.82) 226.13,180.19 VRAM1.E4 ; U49.U29 209.22,65.31 v1(209.67,65.75) 209.27,66.15 U49.U28 ; UG6.AP54 219.44,142.93 v2(219.44,143.42) UG6.AN55 ; v2(227.73,164.11) 227.8,164.04 227.8,163.97 UG6.D42 ; v2(169.42,147.16) 169.73,146.84 U42.L29 ; JDIM2.78 140.53,82.66 v1(140.39,82.8) ; EC1.1 265.76,191.91 265.56,191.71 v1(264.75,191.71) ; UG6.E10 250.12,162.69 v2(250.12,162.67) ; v2(227.26,170.82) 227.63,170.46 VRAM1.V2 ; UG6.D53 220.35,163.72 v2(220.69,164.07) ; v2(204.23,150.07) 204.61,150.45 VRAM6.F3 ; UG6.D39 230.15,163.26 v2(230.1,163.21) 229.91,163.02 UG6.E40 ; UG6.E22 v2(241.7,162.67) ; U49.AL25 216.68,67.5 v2(216.97,67.21) 216.68,66.92 U49.AL26 ; v2(177.23,136.96) 177.14,136.87 U42.A14 ; JDIM2.90 143.53,82.96 v1(143.06,83.43) ; VRAM2.F3 234.25,174.57 v2(234.25,174.59) 234.25,174.6 234.6,174.95 VRAM2.G3 234.63,174.97 234.96,175.31 v2(235.01,175.31) ; UG6.BL6 253.23,130.82 v2(252.89,131.16) ; U49.K5 206.07,77.22 206.12,77.17 206.16,77.17 v1(206.22,77.12) 206.54,77.12 206.78,77.36 U49.M5 ; VRAM5.L4 268.87,163.2 268.51,162.83 268.51,162.79 v2(268.5,162.79) ; VRAM5.L4 268.51,163.56 v2(268.51,163.57) ; U49.AD35 213.05,62.61 v1(213.05,63.04) ; UG6.AJ50 222.45,146.03 v2(222.21,145.8) 221.94,145.52 UG6.AK51 ; v2(225.68,164.72) 225.6,164.72 225.3,164.42 UG6.C46 ; JDIM2.48 133.03,83.05 v1(133.47,83.5) ; U49.AK17 215.98,71.75 216.35,71.38 v1(216.38,71.38) 216.47,71.38 U49.AM17 ; U49.F42 204.4,58.91 v1(204.42,58.93) 204.42,59.19 U49.G41 ; v1(127.92,86.79) 127.8,86.79 126.78,87.81 JDIM2.23 ; U42.CD36 135.62,151.01 v2(135.56,151.01) 135.24,151.34 U42.CE37 ; VRAM5.E4 264.4,163.2 264.76,163.56 v2(264.76,163.57) 264.76,163.58 VRAM5.F3 265.51,164.33 v2(265.52,164.33) ; v2(220,142.37) 220,142.37 UG6.AR53 ; U49.AL31 216.41,64.25 v1(216.41,63.74) 216.4,63.76 216.24,63.76 U49.AK32 215.82,64.02 v1(215.54,63.74) ; v2(219.44,156) 219.42,156 219.4,156.02 UG6.R55 ; v1(207.24,65.7) 206.9,66.04 U49.M28 206.9,66.15 206.9,66.92 U49.M26 U49.M25 ; U49.AD18 212.9,70.7 213.15,70.45 v1(213.26,70.45) 213.48,70.67 U49.AE18 ; v2(240.98,178.32) 240.98,178.3 VRAM2.L11 240.61,177.95 v2(240.23,178.33) ; v2(224.2,138.17) 224.55,138.52 UG6.AY47 ; v1(215.51,65.36) 215.72,65.57 U49.AK29 216.3,65.57 U49.AL29 ; v1(110.88,62.87) 110.69,62.68 CN13.51 ; v2(254.25,157.85) 254.52,158.12 UG6.M4 ; U49.T15 208.9,72.53 v2(208.3,71.93) ; U42.J36 171.12,151.01 v2(171.17,151.01) ; CN13.15 v1(111.08,53.68) ; v2(260.94,165.12) 260.94,164.4 v2(261,164.34) 261.01,164.34 261.36,164.7 VRAM5.A2 261.38,164.71 261.75,165.08 v2(261.75,165.1) 261.78,165.1 VRAM5.B1 262.13,165.52 261.77,165.88 v2(261.77,165.91) ; UG6.AG32 235.04,147.62 v2(234.7,147.96) 234.36,147.62 UG6.AG33 UG6.AG34 UG6.AG35 UG6.AG36 UG6.AG37 231.43,147.74 230.97,147.74 UG6.AG38 230.84,147.62 v2(230.49,147.27) 230.15,147.61 UG6.AG39 UG6.AG40 UG6.AG41 228.75,147.61 v2(228.41,147.27) 228.06,147.62 UG6.AG42 v2(227.7,147.27) UG6.AG43 ; v1(174.58,97.47) JDIM1.206 ; U49.AE37 213.84,62.05 v1(213.9,62.05) 213.9,62.05 214.25,61.7 U49.AG37 ; v2(273,156.83) 272.99,156.83 VRAM5.T12 ; v2(254.17,145.5) 254.19,145.52 UG6.AK4 ; v2(225.73,175.32) 226.1,175.7 VRAM1.L4 226.49,176.06 v2(226.49,176.07) ; U49.AA5 211.07,77.13 v1(211.07,76.93) ; UG6.AE2 v2(256.4,148.67) ; UG6.BD50 222.46,135.72 v2(222.8,135.38) ; v2(222.75,137.39) 222.88,137.39 UG6.BB49 ; U49.AG25 214.48,67.5 v1(214.85,67.13) U49.AG27 ; VRAM3.H4 255.13,177.92 255.47,177.57 v2(255.5,177.57) ; v1(147.7,103.01) 147.7,103.24 147.83,103.36 JDIM1.107 ; UG6.C10 v2(250.1,164.07) ; UG6.U19 243.8,154.27 v2(243.79,154.27) 243.79,154.28 UG6.U20 ; v2(203.45,137.91) 203.45,137.77 VRAM8.R14 202.78,137.1 v2(202.75,137.1) ; JDIM1.222 178.58,97.24 178.7,97.36 178.7,97.82 178.26,98.26 178.24,98.26 v1(178.21,98.29) ; JDIM2.189 170.28,87.84 169.54,87.11 169.54,87.11 v1(169.38,86.95) ; v2(240.99,182.82) 240.63,183.18 VRAM2.V11 240.63,183.26 v2(240.21,183.68) ; UG6.BP40 v2(229.8,128.37) ; v2(264.73,149.06) 264.73,149.05 VRAM7.P11 ; VRAM3.G14 247.63,178.68 247.97,178.33 v2(247.97,178.32) ; UG6.B30 236.45,165.02 v2(236.16,164.73) ; JDIM2.98 145.53,83.03 v1(145.97,83.47) ; v2(253.04,163.25) 252.78,163.25 UG6.E7 ; VRAM4.H11 208.38,164.18 v2(208.75,163.8) ; v1(174.79,87.52) 174.28,88.04 JDIM2.205 ; v2(202.37,145.71) 202.37,145.2 VRAM6.C10 ; UG6.U5 254.12,154.45 254.12,154.06 v2(254.11,154.05) 254.24,153.92 UG6.V4 ; v1(217,66.52) 216.63,66.15 U49.AL28 ; CN6.15 v1(111.02,78.73) ; JDIM2.188 170.03,84.19 v1(169.45,84.77) ; VRAM3.N1 257.48,174.2 257.86,173.81 v2(257.87,173.81) ; UG6.R47 224.8,155.77 v2(225.02,155.77) ; UG6.BN42 228.16,129.53 228.16,130.01 UG6.BM42 228.18,130.25 228.18,130.69 UG6.BL42 v2(227.7,131.17) UG6.BK43 227.24,131.63 227.24,132.11 UG6.BJ43 ; v1(215.56,62.92) 215.57,62.92 215.89,63.24 U49.AK33 ; v2(221.27,180.57) 221.25,180.57 VRAM1.E11 220.88,180.19 v2(220.51,179.82) ; VRAM7.V4 261.36,143.45 261,143.09 v2(261,143.08) ; UG6.BH13 248.48,132.92 v2(248.78,132.62) ; v2(256.26,175.32) 256.26,175.32 255.88,174.95 VRAM3.M3 255.87,174.95 255.5,174.57 v2(255.5,174.56) 255.5,174.55 255.85,174.2 VRAM3.N3 255.88,174.2 256.26,173.82 v2(256.26,173.8) ; JDIM2.209 175.28,86.64 v1(174.81,86.18) ; U49.G48 204.26,56.18 v1(203.98,55.91) ; v2(273,142.3) 272.63,142.68 VRAM7.C3 272.25,143.07 v2(272.24,143.07) ; v2(213.26,150.84) 213.62,151.2 VRAM6.V2 213.7,151.2 214.08,151.58 v2(214.08,151.66) ; VRAM6.R12 211.39,143.7 211.75,143.34 211.75,143.32 v2(211.76,143.31) ; VRAM6.G14 205.72,142.54 v2(205.75,142.54) ; VRAM2.D12 241.74,173.06 v2(241.75,173.06) ; v1(136.2,98.42) 135.7,97.91 135.7,97.5 136.08,97.12 JDIM1.60 ; v2(210.31,166.99) 210.25,166.99 209.88,166.61 VRAM4.F14 ; JDIM1.218 177.58,98.34 178.18,98.95 v1(178.23,98.95) ; v2(222.8,152.87) 222.45,152.52 UG6.Y50 ; UG6.BP1 v2(257.12,129.09) ; v2(256.26,172.33) 255.88,171.95 VRAM3.T3 255.86,171.95 255.5,171.58 v2(255.5,171.57) ; U49.V24 209.66,68.42 v1(209.6,68.42) ; PU32.2 228.9,89.83 v3(228.98,89.75) ; U49.U19 209.22,70.47 208.84,70.09 v1(208.82,70.09) 208.45,69.72 U49.R21 ; v2(270.77,150.56) 270.38,150.95 VRAM7.F14 269.99,151.34 v2(269.99,151.42) ; UG6.D27 UG6.E28 ; U42.E31 174.05,147.1 v2(174.07,147.1) ; v2(247.97,170.04) VRAM3.V13 ; VRAM3.V13 248.38,170.42 v2(248.74,170.05) ; VRAM3.V13 248.33,170.45 247.97,170.81 v2(247.97,170.82) 247.63,171.17 VRAM3.U14 247.52,171.2 v2(247.11,170.78) ; U49.U22 209.22,69 v1(208.84,69.38) ; VRAM1.H4 225.75,178.32 v2(225.72,178.32) ; JDIM1.196 172.08,99.06 171.46,99.68 v1(171.26,99.68) ; UG6.AD51 221.88,149.72 v2(222.15,149.45) ; UG6.AF3 255.01,148.66 v2(255.01,148.67) ; v2(206.08,125.76) 206.11,125.76 206.43,125.44 RG131.2 ; PR627.1 114.71,49.16 v1(114.35,49.52) ; VRAM8.D14 211.38,137.54 v2(211.75,137.92) ; UG6.AC50 222.46,150.42 v2(222.8,150.76) 223.15,151.11 UG6.AB49 ; U49.E35 203.5,62.37 v1(203.9,62.37) ; JDIM1.192 171.08,97.08 170.91,97.24 170.91,97.87 v1(171.15,98.12) ; v2(231.96,160.51) 232.25,160.79 UG6.H36 ; v1(168.23,98.49) 168.2,98.49 167.8,98.08 167.8,97.57 168.06,97.3 168.08,97.29 JDIM1.180 ; U49.AK28 215.82,66.15 v1(216.22,66.54) ; JDIM2.206 174.53,82.97 v1(174.98,83.43) ; PU35.5 258.24,91.18 v3(258.37,91.05) ; v1(213.87,72.89) 213.48,73.28 U49.AE13 ; v1(217.03,63.95) 217.03,63.83 217.31,63.55 U49.AN33 ; JDIM1.176 167.08,97.3 v1(166.88,97.5) ; v2(266.25,141.54) 266.25,141.54 265.9,141.2 VRAM7.M1 VRAM7.N1 ; v2(200.43,128.83) 200.49,128.83 VRAM8.V2 200.88,128.43 201.22,128.08 201.22,128.08 v2(201.25,128.06) ; U49.AF28 213.67,65.31 v1(213.77,65.22) ; U49.BC15 222.23,72.71 v1(222.23,72.96) ; U42.G29 172.34,146.39 v2(172.01,146.07) 172.01,146.17 U42.H29 ; UG6.L55 v2(218.6,159.17) ; v1(206.48,70.24) 206.82,70.58 U49.M19 ; JDIM1.52 134.08,97.08 134.03,97.12 134.03,97.62 134.49,98.08 v1(134.54,98.08) ; JDIM1.72 139.08,97.24 138.91,97.41 138.91,98.69 139.94,99.72 v1(140.18,99.72) ; v2(223.6,151.59) 223.38,151.59 UG6.AA49 ; VRAM4.P4 203.88,158.96 v2(203.5,159.33) ; JDIM1.168 165.08,97.91 v1(165.49,98.32) ; v1(206.3,64.81) 206.77,65.28 U49.M29 ; CN6.9 v1(110.9,77.23) ; 265.49,149.83 VRAM7.M12 265.88,149.44 v2(266.26,149.06) ; VRAM8.E4 210.61,129.95 v2(210.24,129.58) 210.23,129.56 210.23,129.55 VRAM8.F3 209.88,129.19 v2(209.49,128.81) 209.13,129.18 VRAM8.G3 208.75,129.57 v2(208.75,129.58) 208.74,129.58 VRAM8.H4 208.38,129.98 v2(208,130.35) ; JDIM2.56 135.03,82.88 v1(135.47,83.33) ; UG6.C43 227.6,164.67 v2(227.85,164.67) ; U49.P12 208.09,73.88 207.79,73.58 v1(207.53,73.58) U49.M12 ; UG6.H6 253.26,160.92 v2(253.61,161.27) ; U49.AP31 218.13,64.42 v1(218.49,64.06) 218.49,64.05 218.13,63.69 U49.AP33 ; UG6.BN33 v2(234.71,129.06) 235.05,129.41 UG6.BN32 235.18,129.55 235.18,129.99 UG6.BM32 235.18,130.25 235.18,130.69 UG6.BL32 v2(234.7,131.17) UG6.BK33 234.24,131.63 234.24,132.11 UG6.BJ33 ; v2(233.31,159.86) 232.95,160.22 UG6.J35 ; R731.1 267.16,194.02 267.39,193.79 v1(267.44,193.79) ; JDIM1.234 181.58,97.37 v1(181.38,97.57) ; UG6.AN2 255.95,143.42 255.67,143.7 v2(255.66,143.7) ; v1(147.7,97.53) 147.58,97.41 JDIM1.106 ; VRAM1.G12 219.77,179.05 v2(219.74,179.05) ; v2(227.25,182.06) 226.88,181.7 VRAM1.C3 ; UG6.C22 242.05,164.42 v2(241.7,164.07) ; JDIM2.64 v1(137.03,82.8) ; 220.13,174.95 v2(220.51,174.57) ; 220.13,174.95 VRAM1.M12 ; UG6.U18 245.2,154.27 245.2,154.27 UG6.U17 v2(245.9,154.27) 246.25,154.62 UG6.U16 246.59,154.28 v2(246.6,154.28) 246.93,154.62 UG6.U15 ; CN12.45 281.93,71.99 v1(281.72,72.2) ; UG6.AD6 253.15,149.72 v2(252.86,150.01) ; v2(264.76,151.43) 265.13,151.06 VRAM7.N14 265.1,150.95 v2(264.75,150.59) ; v1(126.24,87.62) 126.22,87.62 125.78,88.07 JDIM2.19 ; U42.BE41 147.7,153.94 v2(147.37,153.61) 147.7,153.29 U42.BE40 ; UG6.H34 233.65,160.92 v2(233.3,161.27) 232.95,161.62 UG6.G35 ; VRAM5.F12 265.13,157.2 v2(264.75,157.58) ; JDIM2.167 v1(164.78,88.19) ; JDIM1.39 130.83,102.77 131.24,102.35 v1(131.32,102.35) ; C601.2 268.59,198.65 268.85,198.9 v1(268.85,199.18) ; U49.AT29 218.9,65.14 v1(218.55,64.78) ; v1(274.53,195.81) 274.53,195.85 274.97,196.29 Q81.4 ; v2(234.09,161.9) 234.09,162.06 UG6.F33 UG6.G32 ; v2(270,165.9) 269.63,165.52 VRAM5.M1 ; UG6.AG8 251.74,147.62 v2(251.44,147.92) 251.85,148.32 UG6.AF8 ; v2(250.02,143.18) 250.21,143.18 UG6.AN10 ; v2(243,163.29) 243.42,163.72 UG6.D20 ; v2(220.75,145.25) 220.69,145.25 220.41,145.52 UG6.AK53 ; JDIM1.185 169.33,102.92 v1(169.91,102.33) ; UG6.U55 v2(218.6,154.97) ; v1(189.39,168.14) 189.39,168.12 189.49,168.02 C632.2 ; v1(139.8,102.34) 139.77,102.34 139.24,102.87 139.24,103.28 139.33,103.37 JDIM1.73 ; v2(213.19,62.08) 213.19,62.08 213.19,61.98 U49.AD37 U49.AC37 ; v2(218.6,162.68) 218.95,162.33 UG6.F55 ; v2(249.5,175.31) 249.5,175.32 VRAM3.L11 ; U49.Y12 210.83,74.08 v1(211.19,73.73) 211.2,73.73 211.55,74.07 U49.AA12 ; v2(274.61,156.81) 274.25,156.45 VRAM5.V13 ; U49.AT22 219.03,68.98 v1(219.47,68.98) ; UG6.AM10 v2(250.1,143.77) ; JDIM2.217 177.28,86.67 v1(176.81,86.21) ; CN13.9 110.68,52.18 v1(110.79,52.3) ; UG6.M51 221.88,158.12 v2(222.15,158.39) 222.15,158.52 UG6.L50 UG6.K49 ; v2(203.5,136.31) 203.49,136.31 VRAM8.R12 ; UG6.H55 218.94,160.92 v2(218.59,161.27) ; v2(260.95,157.64) 261.07,157.64 VRAM5.A11 ; PU33.2 238.68,89.83 v3(238.76,89.75) ; v1(218.52,70.92) 218.57,70.92 U49.AT19 ; v2(218.16,180.6) 218.51,180.95 VRAM1.D14 ; U49.P25 207.96,67.79 v2(208.06,67.79) 207.77,68.08 U49.P24 ; v1(278.01,197.94) 277.83,197.94 277.49,197.59 Q81.1 ; v1(204.27,57.89) 204.27,57.94 U49.H43 ; v1(281.84,70.74) 282.09,70.49 CN12.39 ; v1(222.05,64.45) 222.19,64.45 U49.BC31 ; v2(218.11,170.78) 218.52,171.2 VRAM1.U14 218.63,171.17 v2(218.97,170.82) ; UG6.AT55 218.94,141.32 v2(218.6,140.98) 218.95,140.63 UG6.AU55 ; v2(131.46,134.9) 131.37,134.9 U42.CM10 U42.CN10 129.93,134.51 U42.CP9 ; v2(231.2,164.07) UG6.C37 UG6.B36 ; CN12.19 283.89,65.49 284.21,65.81 v1(284.21,65.95) ; v2(263.26,143.08) 263.26,143.06 VRAM7.R3 ; v2(226.49,172.31) 226.86,171.95 226.87,171.95 v2(226.49,171.57) ; v2(203.51,163.84) 203.87,164.2 VRAM4.P11 204.24,164.56 v2(204.25,164.56) 204.63,164.93 VRAM4.N12 204.63,164.95 v2(205.01,165.34) ; v1(214.06,66.34) 214.06,66.34 U49.AG28 ; UG6.U39 230.15,154.62 v2(230.5,154.27) UG6.U38 ; UG6.J55 UG6.K54 219.65,159.51 v2(219.99,159.17) ; U49.AJ23 215.22,68.3 v1(214.85,68.67) 214.48,69.05 U49.AG22 ; UG6.N48 223.85,157.41 v2(223.5,157.06) ; UG6.AH7 UG6.AG6 252.96,147.91 v2(252.86,147.91) ; PU29.2 277.9,90.09 v3(278.03,89.96) ; v1(183.57,97.73) 183.63,97.73 184.08,97.28 JDIM1.244 ; v2(168.88,149.06) 168.82,149.06 U42.N33 ; UG6.H40 UG6.H39 229.87,160.64 v2(229.87,160.46) ; U49.AL24 216.59,68.08 v1(216.95,68.44) 216.58,68.82 U49.AL22 ; v1(217.75,68.46) 217.37,68.08 U49.AN24 ; VRAM4.M14 205.4,166.45 v2(205.75,166.1) ; UG6.AB52 220.83,151.34 v2(220.83,152.01) 220.54,152.01 UG6.AA53 ; UG6.B26 239.25,165.13 v2(239.59,165.47) ; VRAM6.L4 208.01,150.06 v2(208.01,150.07) ; v2(262.52,164.34) 262.52,164.32 262.88,163.96 VRAM5.C3 262.88,163.94 263.24,163.57 v2(263.26,163.57) 263.28,163.57 263.63,163.92 VRAM5.D3 263.64,163.95 264,164.31 v2(264,164.33) ; U49.AH13 215.25,73.31 v2(215.55,73) ; UG6.AF55 218.95,148.32 v2(218.6,148.67) ; v1(183.8,86.88) 183.52,86.88 182.78,87.62 JDIM2.239 ; JDIM2.93 v1(144.28,88.13) ; VRAM1.R14 218.63,172.67 v2(218.98,172.31) ; v2(170.06,143.73) 170.06,143.89 U42.L26 169.73,144.57 v2(170.06,144.9) 170.06,145.11 U42.K28 170.38,145.74 v2(170.06,146.07) ; v2(243.81,147.27) 243.81,147.28 UG6.AG19 ; v1(219.34,60.24) 219.53,60.42 U49.AV39 ; U49.BC26 v2(222.13,66.59) ; UG6.V47 224.42,153.92 v2(224.15,154.2) 224.15,154.33 UG6.U48 ; U39.3 275.34,199.13 v1(275.92,198.54) ; U49.AE45 213.48,57.37 v2(213.19,57.08) 212.9,57.37 U49.AD45 ; UG6.F1 256.86,162.43 v2(257.23,162.43) ; JDIM2.197 172.28,87.98 v1(172.75,87.51) ; JDIM2.202 v1(173.53,82.68) ; v2(269.99,156.81) VRAM5.N12 270.75,157.57 270.76,157.57 v2(270.77,157.58) ; UG6.F47 UG6.F48 ; UG6.AP2 256.06,142.72 v2(256.41,142.38) ; VRAM5.M14 269.6,155.7 v2(269.25,156.05) ; v2(261.75,142.31) 261.75,142.3 261.39,141.95 VRAM7.V2 261.38,141.94 v2(260.95,141.51) ; v2(218.93,170.02) 219.35,170.45 VRAM1.V13 219.75,170.07 v2(219.75,170.06) ; UG6.BE49 v2(223.51,134.67) ; v1(141.47,103.06) 141.33,103.21 JDIM1.81 ; JDIM2.2 v1(121.53,82.7) ; RG132.2 207.57,125.24 207.26,125.55 v2(207.26,125.76) ; v2(207.29,67.79) 207.28,67.79 206.99,67.5 U49.M25 ; JDIM1.14 124.58,97.42 124.58,97.43 v1(124.58,97.45) ; v2(241.77,182.06) 241.4,181.7 VRAM2.T12 ; UG6.BN37 231.9,129.07 v2(231.9,129.07) ; v2(243.79,164.07) UG6.C19 UG6.B18 ; v1(172.73,86.77) 173.09,87.13 173.28,87.32 JDIM2.201 ; v2(248.02,148.67) 248.35,149.01 UG6.AE13 ; UG6.BJ31 235.64,132.11 235.64,131.63 UG6.BK31 v2(236.1,131.17) UG6.BL30 236.55,130.72 236.55,130.22 UG6.BM30 236.58,129.99 236.58,129.55 UG6.BN30 236.45,129.34 v2(236.15,129.04) 235.76,129.42 UG6.BN31 ; UG6.D9 251.15,163.52 v2(251.39,163.29) ; VRAM4.G3 209.13,158.17 v2(209.49,157.81) ; VRAM8.C10 212.17,134.45 212.64,133.97 v2(212.64,133.96) ; v2(212.41,131.17) 212.13,130.89 VRAM8.C5 212.13,130.69 211.79,130.35 v2(211.75,130.35) ; U49.BC41 222.26,59.44 v1(222.59,59.77) ; UG6.AR8 251.85,142.02 v2(251.5,141.66) 251.84,141.32 UG6.AT8 ; U42.AW2 151.44,128.89 v2(151.38,128.89) ; UG6.BN4 v2(254.99,129.08) ; UG6.AB47 224.55,151.11 v2(224.9,150.76) ; U49.AT31 219.07,64.42 219.42,64.76 v1(219.47,64.76) ; v2(220.51,179.07) 220.5,179.07 VRAM1.F12 ; CN13.3 110.53,50.68 v1(110.79,50.42) ; VRAM6.F14 204.63,142.21 v2(204.26,142.58) ; UG6.B53 220.35,165.12 v2(220,165.46) ; JDIM2.57 v1(135.28,88.17) ; CG514.2 209.54,126.41 209.48,126.48 v2(209.48,127.21) ; UG6.AC8 v2(252.19,150.76) UG6.AB7 ; UG6.U28 237.85,154.6 v2(238.2,154.26) ; v2(209.1,71.29) 208.95,71.43 U49.T17 ; U49.AC35 212.4,62.55 v1(212.4,63.01) 212.17,63.24 U49.AA33 ; VRAM3.M14 247.53,174.85 v2(247.01,174.85) ; U49.AN19 217.01,70.24 v1(217.01,70.21) ; v2(255.71,163.37) 256.05,163.04 UG6.E2 ; v2(220.75,143.15) 220.49,143.42 UG6.AN53 ; v2(273.77,155.23) 273.05,155.23 v2(273.01,155.27) 273.01,155.33 VRAM5.U14 273.42,155.7 273.78,156.06 v2(273.78,156.07) 274.13,156.42 VRAM5.V13 ; v2(214.07,150.07) 213.88,150.07 213.63,149.81 VRAM6.V4 213.63,149.55 213.88,149.3 v2(213.99,149.3) ; JDIM1.172 166.08,98.09 v1(166.81,98.82) ; v2(250.27,183.63) 249.88,183.24 VRAM3.A11 249.86,183.2 v2(249.48,182.82) ; UG6.F15 246.95,161.85 v2(247,161.79) ; v2(233.49,182.83) 233.86,183.2 VRAM2.V2 234.17,183.49 v2(234.17,183.72) ; v1(182.05,84.79) 182.53,84.31 JDIM2.238 ; v2(270,149.85) 270.38,149.48 VRAM7.F12 269.99,149.06 v2(269.99,149.06) ; U49.D37 203.31,61.5 U49.E37 203.88,61.5 v1(204.19,61.2) 204.13,61.2 203.69,60.75 203.69,60.68 U49.E39 ; U55.3 272.8,49.59 272.49,49.9 272.49,50.09 v1(272.49,50.09) ; v2(221.41,152.87) 221.05,153.22 UG6.W52 ; VRAM6.D12 203.13,143.68 v2(203.5,143.31) ; UG6.AV5 254.01,139.92 254.65,139.28 UG6.AW4 254.51,139.08 v2(254.18,139.08) ; UG6.AU49 223.15,140.62 v2(223.57,141.04) 223.43,141.04 UG6.AT49 ; v2(222.18,154.18) 221.92,153.92 UG6.V51 ; JDIM1.98 145.58,97.87 145.08,98.36 144.68,98.77 144.63,98.77 v1(144.58,98.82) ; v2(150.04,148.45) 150.04,148.52 U42.BB33 149.31,149.25 U42.BC34 ; v2(127.55,127.42) 127.54,127.44 v2(127.54,128.03) ; PU35.2 258.24,89.83 v3(258.32,89.75) ; VRAM5.E11 264.38,157.96 264,158.34 v2(264,158.34) ; UG6.G29 v2(236.8,161.27) ; v2(200.43,157.83) 200.81,157.45 VRAM4.V2 ; CN6.21 v1(110.97,80.23) ; UG6.AD4 254.45,149.72 v2(254.2,149.98) ; v2(240.77,158.83) 240.77,159.4 UG6.K24 ; UG6.AD10 250.2,149.47 v2(249.98,149.47) ; v1(178.43,102.9) 178.66,103.14 178.66,103.22 178.83,103.39 JDIM1.223 ; UG6.M10 250.37,158.12 250.29,158.04 v2(249.95,158.04) ; VRAM7.G3 269.63,142.67 v2(269.27,142.31) ; JDIM2.22 126.53,82.95 127.5,83.93 v1(127.53,83.93) ; UG6.T49 223.15,155.32 v2(222.81,154.97) 222.45,154.62 UG6.U50 ; v1(209.33,62.89) 209.46,62.89 U49.V33 ; v2(243.8,147.97) UG6.AG19 ; UG6.AG19 244.18,147.65 244.83,147.65 UG6.AG18 ; UG6.AD53 220.47,149.72 v2(220.75,149.44) ; UG6.AJ44 226.65,146.22 v2(227,146.56) 227.34,146.22 UG6.AJ43 ; JDIM1.209 175.33,103.36 175.43,103.26 175.43,101.34 v1(174.93,100.85) ; v2(243.43,170.96) 243.11,170.96 VRAM2.B14 242.88,171.2 v2(242.51,171.57) ; CN13.57 110.7,64.18 v1(110.84,64.04) ; JDIM2.235 v1(181.78,88.27) ; v2(254.31,163.37) 254.65,163.71 UG6.D4 254.78,163.85 254.78,164.29 UG6.C4 ; v2(170.06,139.01) 170.06,138.9 U42.K17 ; UG6.AW53 v2(220.84,139.22) 221.03,139.42 221.55,139.42 UG6.AW51 UG6.AV50 ; v1(217.72,63.95) 217.72,64.05 U49.AN31 ; v1(212.83,167) 212.83,166.96 212.87,166.93 212.87,166.45 VRAM4.B14 ; v2(214.05,144.85) 213.65,144.45 VRAM6.V11 213.63,144.44 v2(213.26,144.08) ; v2(255,134.67) 255.37,135.04 ; v2(211.74,136.33) VRAM8.C12 212.5,135.57 v2(212.5,135.56) ; UG6.Y2 256.07,152.52 v2(256.42,152.17) 256.07,151.82 UG6.AA2 ; v1(129.16,101.71) 129.29,101.71 129.83,102.24 JDIM1.35 ; VRAM8.D1 211.4,127.7 v2(211.75,128.04) ; v2(213.25,158.57) 213.62,158.95 VRAM4.A4 ; v2(255,142.37) UG6.AR3 255.86,141.51 UG6.AT2 ; VRAM5.D1 263.63,165.5 v2(263.18,165.95) ; U49.AE12 213.51,74.08 213.83,73.75 v1(213.87,73.75) ; VRAM5.F1 265.1,165.45 264.76,165.1 v2(264.75,165.1) ; PQ61.1 180.97,175.76 v1(181.04,175.84) ; JDIM2.226 179.53,82.85 180.12,83.44 v1(180.16,83.44) ; UG6.Y3 255.34,152.52 v2(254.99,152.87) ; PQ54.1 201.98,193.56 v1(201.82,193.72) ; v1(129.95,86.59) 128.78,87.77 JDIM2.31 ; UG6.E5 UG6.F6 ; JDIM1.99 145.83,103.42 145.66,103.25 145.66,102.08 v1(144.55,100.98) ; VRAM1.M1 VRAM1.N1 228.54,174.03 v2(228.86,174.03) ; U49.AK45 215.92,57.44 216.21,57.73 v1(216.21,57.76) ; v2(208.75,128.04) 208.78,128.04 VRAM8.G1 ; v3(268.15,91.05) 268.02,91.18 PU36.5 ; UG6.K45 v2(225.6,159.17) ; v2(231.9,129.07) 232.25,128.72 UG6.BP36 v2(232.6,128.38) ; v2(231.9,129.07) UG6.BN36 232.36,129.53 232.36,130.01 UG6.BM36 232.36,130.23 232.36,130.71 UG6.BL36 v2(231.9,131.17) UG6.BK37 231.45,131.62 231.45,132.12 UG6.BJ37 ; JDIM2.1 121.28,88.09 v1(121.77,87.59) ; v2(223.72,139.22) UG6.AW49 ; v2(233.29,165.46) UG6.B35 ; v1(180.04,87.59) 179.59,88.04 179.59,88.43 179.78,88.62 JDIM2.227 ; UG6.T7 252.54,155.32 v2(252.2,154.98) 252.2,154.97 UG6.U8 ; v2(204.22,166.07) 204.24,166.08 204.26,166.08 VRAM4.N14 205,166.82 v2(205,166.89) ; v2(228.01,179.81) 228.37,179.45 VRAM1.F1 ; v2(262.49,156.05) 262.13,155.7 VRAM5.B14 261.84,155.41 v2(261.84,155.14) ; v2(202.75,142.59) 203.13,142.22 VRAM6.D14 ; v1(216.05,77.12) 216.05,77.18 U49.AK5 ; UG6.AJ8 251.85,146.22 v2(251.46,145.84) 251.78,145.52 UG6.AK8 ; U49.AK24 215.81,68.08 v1(216.17,68.44) ; JDIM2.247 184.78,88.57 184.61,88.41 184.61,87.92 185,87.53 v1(185.07,87.53) ; v2(204.27,158.57) 204.28,158.56 204.28,158.51 204.6,158.2 VRAM4.N3 205,157.82 v2(205,157.81) ; UG6.AN49 223.11,143.42 v2(222.77,143.09) 222.77,143.19 222.38,143.59 221.92,143.59 UG6.AN51 ; U49.M25 U49.L25 U49.J25 U49.H25 U49.F25 203.92,67.5 U49.E26 ; v1(138.11,98.73) 138.07,98.73 138.04,98.69 138,98.69 137.17,97.86 137.17,97.18 137.08,97.08 JDIM1.64 ; UG6.G26 238.72,161.62 v2(238.51,161.83) 238.55,161.87 UG6.F27 ; UG6.G44 226.48,161.79 226.01,161.79 v2(225.98,161.81) ; v2(203,152.46) 203,152.07 VRAM6.D1 203.12,151.95 202.79,151.61 202.76,151.61 v2(202.75,151.6) ; UG6.AK10 250.21,145.28 v2(249.97,145.28) ; VRAM4.D3 211.38,158.22 211.73,158.57 v2(211.75,158.57) 211.75,158.57 VRAM4.C3 212.13,158.17 v2(212.49,157.81) ; JDIM2.252 186.03,83.57 186.54,84.08 v1(186.97,84.08) ; v2(236.53,182.02) 236.51,182 236.43,182 VRAM2.T5 ; v1(181.81,101.57) 181.76,101.57 180.83,102.5 JDIM1.231 ; VRAM5.T10 272.9,158.97 v2(272.9,159.27) ; v2(227.27,183.62) 227.31,183.66 v2(228.09,183.66) ; JDIM2.82 v1(141.53,82.88) ; v2(234.26,180.56) 234.63,180.93 VRAM2.R3 ; JDIM1.47 132.83,102.91 133.39,102.35 v1(133.42,102.35) 133.49,102.35 133.9,102.77 133.9,103.21 133.83,103.29 JDIM1.51 ; VRAM7.P4 264.36,143.45 264,143.09 v2(264,143.08) 264,143.07 VRAM7.R3 ; v2(235.03,179.82) 235.03,179.8 234.68,179.45 VRAM2.N3 234.6,179.45 v2(234.23,179.81) ; JDIM2.196 v1(172.03,82.69) ; CN10.4 315.98,84.91 315.73,85.16 v1(315.73,85.18) ; U49.AT21 v1(219.35,70.16) ; 300.93,85.25 v1(302.11,85.25) ; VRAM7.R3 263.63,142.68 263.26,142.31 v2(263.25,142.31) 263.24,142.31 262.88,142.68 VRAM7.T3 ; UG6.H21 242.47,160.64 v2(242.47,160.48) ; v1(121.16,97.43) 121.58,97.02 JDIM1.2 ; VRAM6.R14 211.4,142.2 v2(211.75,142.54) ; v2(206.51,150.07) 206.14,149.7 VRAM6.H4 206.13,149.68 v2(205.75,149.3) ; UG6.AJ55 v2(218.6,146.57) ; v2(261,149.82) 261,149.84 261.36,150.2 VRAM7.V13 261.38,150.23 v2(261.75,150.6) 261.78,150.6 VRAM7.U14 262.13,151.05 v2(261.71,151.47) ; v1(113.59,197.85) 113.67,197.77 PU21.4 ; VRAM1.D1 228.37,180.95 v2(227.99,181.32) ; v1(127.82,101.61) 126.83,102.6 JDIM1.23 ; U49.M33 206.94,63.55 v1(207.29,63.2) ; v2(202,157.81) 202.38,158.18 VRAM4.T3 202.38,158.2 v2(202.74,158.57) ; JDIM2.251 185.78,87.12 v1(186.76,86.14) ; U42.BJ41 145.47,153.94 v2(145.8,153.61) 145.47,153.29 U42.BJ40 ; v2(266.25,143.85) 266.25,143.84 266.63,143.47 VRAM7.L4 ; VRAM5.V13 v2(274.65,155.92) ; VRAM6.G3 205.76,150.83 v2(205.76,150.84) ; v1(212.81,64.56) 212.75,64.5 212.3,64.5 212.01,64.79 U49.AA30 ; v2(237.52,159.87) 237.5,159.87 UG6.J29 UG6.K30 ; VRAM2.M3 234.61,178.7 v2(234.26,178.35) ; U49.W30 211.05,65.18 v1(211.11,65.12) 211.18,65.12 211.55,65.49 U49.AA29 ; v1(185.29,102.36) 185.29,102.37 184.8,102.86 184.8,103.4 184.83,103.42 JDIM1.247 ; v1(130.04,97.6) 130.04,97.55 130.08,97.51 JDIM1.36 ; UG6.AN44 226.32,143.42 226.05,143.69 v2(226.05,144.28) ; v2(257.03,174.57) 257.38,174.92 VRAM3.M1 ; JDIM2.52 134.03,84.42 v1(133.41,85.04) ; v2(266.25,150.59) 266.24,150.59 265.89,150.95 VRAM7.M14 ; v1(186.34,98.18) 185.93,97.78 185.93,97.27 186.08,97.13 JDIM1.252 ; v2(239.59,162.67) 239.95,163.02 UG6.E25 ; v2(218.6,150.78) 218.6,150.77 UG6.AC55 ; UG6.T9 v2(250.8,154.97) ; v2(257.02,171.58) 257.04,171.56 257.04,171.53 VRAM3.U1 257.72,170.85 v2(257.86,170.85) ; v2(203.11,68.91) 203.11,68.46 U49.D24 ; v1(281.86,78.16) 282.03,77.99 CN12.69 ; UG6.BE8 v2(252.2,135.37) ; v2(210.27,137.9) 210.25,137.92 v2(209.5,137.92) ; v2(208.01,158.57) 208.38,158.94 VRAM4.H4 208.38,158.97 v2(208.75,159.35) ; UG6.AG53 UG6.AH52 ; U49.AJ25 215.2,67.5 v1(214.81,67.89) 214.45,68.25 U49.AG23 ; UG6.U30 236.45,154.62 v2(236.8,154.27) 237.15,154.62 UG6.U29 ; VRAM8.B14 212.88,137.57 213.28,137.98 v2(213.35,137.98) ; v2(168.11,151.66) 168.17,151.66 U42.N38 ; UG6.A54 219.65,166.27 v2(219.61,166.31) ; v1(127.1,99.02) 126.58,98.49 JDIM1.22 ; v2(219.35,136.83) 219.32,136.83 219.03,137.12 UG6.BB55 ; U49.BA9 222.09,75.52 U49.BC9 222.26,75.73 U49.BB8 v1(221.34,76.09) ; UG6.E52 221.63,163.02 v2(221.79,163.18) ; VRAM7.G14 269.61,150.95 v2(269.25,150.59) ; v3(238.76,91.05) 238.63,91.18 PU33.5 ; v2(210.26,150.83) VRAM6.N3 ; U49.V17 209.48,72.1 v2(209.48,72.18) ; UG6.BE51 222.06,134.71 v2(222.14,134.71) ; UG6.R4 UG6.P5 253.94,156.72 253.63,157.04 253.63,157.06 v2(253.61,157.08) ; CN6.57 v1(110.81,89.23) ; UG6.U27 238.57,154.62 v2(238.91,154.28) UG6.U26 239.6,154.27 v2(239.6,154.27) UG6.U25 ; VRAM8.C3 211.99,129.33 211.51,129.33 VRAM8.D3 ; VRAM7.V11 261.4,148.7 261.76,149.05 v2(261.76,149.06) ; v2(253.6,134.67) 253.98,135.05 v2(253.98,135.14) ; UG6.J51 221.8,160.27 v2(222.25,160.27) 222.46,160.48 222.89,160.48 UG6.J49 ; v2(218.98,175.32) 218.98,175.3 VRAM1.M14 ; Q128.1 284.34,182.73 284.61,182.46 v1(284.64,182.46) ; 213.63,142.93 213.25,142.56 v2(213.25,142.54) ; v2(254.14,143.37) 254.6,143.37 UG6.AN4 ; v2(212.5,151.6) 212.84,151.95 VRAM6.U1 212.88,152.07 213.11,152.3 v2(213.11,152.47) ; v1(172.82,102.38) 172.33,102.88 JDIM1.197 ; UG6.B47 224.56,165.12 v2(224.9,165.46) ; v2(176.74,147.08) 176.74,146.98 176.31,146.54 U42.A29 ; v2(210.25,135.56) 210.62,135.2 VRAM8.E11 ; U42.N37 168.18,151.02 v2(168.11,151.02) ; 247.98,173.07 247.63,172.72 VRAM3.R14 ; CG510.2 201.29,125.99 200.97,126.3 v2(200.97,126.34) ; v2(268.5,148.29) 268.5,148.29 268.88,148.67 VRAM7.H11 269.24,149.06 v2(269.26,149.06) ; JDIM2.15 124.78,88.34 v1(124.54,88.11) ; U42.N35 168.56,150.04 v2(168.88,150.36) 169.21,150.69 U42.M36 ; UG6.K28 237.85,159.52 v2(238.22,159.15) 238.55,159.48 UG6.K27 ; v1(128.81,82.75) 128.53,82.47 JDIM2.30 ; U42.G37 172.01,151.66 v2(171.95,151.66) 171.89,151.66 U42.H38 ; v1(171.33,88.27) 171.3,88.3 171.3,88.3 171.28,88.33 JDIM2.193 ; v2(270.08,140.76) 269.65,141.2 VRAM7.G1 ; UG6.AE44 226.45,149.02 v2(226.21,148.79) ; UG6.K12 249.3,159.27 v2(249.3,159.03) ; VRAM4.N1 204.6,156.7 v2(204.25,157.04) ; PU32.5 228.85,91.18 v3(229.03,91) ; U49.AT17 218.68,71.67 v1(218.68,71.93) ; JDIM1.193 v1(171.33,103.07) ; U49.AY43 221.1,58.31 v1(221.5,57.91) 221.61,58.01 U49.BA43 ; v2(229.1,164.07) 229.45,164.42 UG6.C40 UG6.B39 ; VRAM2.M1 233.16,178.7 233.51,179.04 v2(233.51,179.05) 233.49,179.05 233.13,179.41 VRAM2.N1 ; v2(228.07,162.85) 228.05,162.83 UG6.F42 UG6.G41 ; UG6.F45 226.22,162.59 226.22,163.09 v2(226.07,163.24) ; v2(256.4,144.46) 256.4,144.47 UG6.AL2 ; U49.J11 205.39,74.35 v1(205.63,74.11) ; v2(251.38,181.64) 251.33,181.7 VRAM3.C10 250.63,181.67 v2(250.27,181.32) ; v1(143.09,215.04) 142.75,214.7 C575.1 ; JDIM2.10 v1(123.53,82.66) ; v2(218.97,178.32) 218.97,178.35 VRAM1.G14 ; U49.V25 209.9,67.5 v2(209.61,67.79) 209.51,67.79 U49.U25 ; v2(206.5,158.58) 206.48,158.58 206.13,158.93 VRAM4.L4 206.14,158.95 206.49,159.29 206.49,159.32 v2(206.51,159.34) ; UG6.BB47 224.62,137.12 224.89,136.85 v2(224.96,136.85) ; v2(220,144.46) 219.65,144.82 UG6.AL54 ; v2(177.07,141.02) 177.07,140.98 176.81,140.73 U42.A20 ; JDIM2.94 144.53,83.13 v1(144.07,83.59) ; UG6.AL9 251.15,144.81 v2(250.8,144.46) ; PU36.2 268.02,89.83 v3(268.1,89.75) ; VRAM2.A11 240.63,170.32 v2(240.98,169.97) ; v2(247.12,172.19) 247.62,172.7 VRAM3.R14 ; v2(217.55,141.1) 218.03,141.1 UG6.AT56 ; VRAM7.C12 272.27,149.09 v2(272.24,149.09) 271.88,149.45 VRAM7.D12 ; v1(123.33,103.06) JDIM1.9 ; JDIM2.81 141.28,88.25 v1(141.24,88.22) ; UG6.P8 UG6.R8 252.11,155.76 v2(252.26,155.76) ; v1(302.75,80.75) 302.75,80.23 301.77,79.25 CN7.57 ; v1(147.53,82.65) JDIM2.106 ; UG6.B6 252.97,164.84 v2(252.97,164.72) 252.85,164.72 UG6.C7 ; UG6.H10 250.96,160.41 v2(250.96,160.3) 250.88,160.22 UG6.J10 ; JDIM1.85 142.33,101.13 v1(141.53,100.34) ; v2(202.08,127.24) 202.36,126.95 CG511.2 ; UG6.AE42 228.05,149.02 v2(227.71,148.67) 227.36,149.02 UG6.AE43 ; v2(241.77,183.68) 241.77,183.56 VRAM2.V13 242.15,183.2 v2(242.51,182.83) 242.88,182.47 VRAM2.U14 ; v2(221.28,177.57) 220.91,177.95 VRAM1.H11 220.88,177.95 v2(220.51,178.32) ; v1(219.34,62.15) 219.33,62.14 219.26,62.14 218.81,61.69 U49.AT37 ; v2(205.75,129.59) 206.11,129.95 VRAM8.L4 ; U49.U21 209.22,69.79 209.5,70.07 v1(209.6,70.07) 209.71,70.07 210,69.78 U49.V21 ; UG6.AF48 224.19,147.98 v2(224.21,147.98) ; VRAM3.R14 247.63,172.66 247.97,172.31 v2(247.97,172.31) ; U42.F31 172.9,147.72 U42.G31 ; CN6.45 v1(110.83,86.23) ; v2(200.5,130.34) 200.88,129.96 VRAM8.V4 200.89,129.95 v2(201.25,129.59) ; JDIM1.251 185.83,101.28 186.66,100.44 v1(187.16,100.44) ; U49.R24 208.74,67.79 v2(208.83,67.79) 208.55,67.5 U49.R25 ; 232.95,154.61 UG6.U35 ; 232.95,154.61 232.95,154.61 v2(232.61,154.27) 232.26,154.62 UG6.U36 232.25,154.61 v2(231.91,154.26) 231.55,154.62 UG6.U37 ; JDIM1.175 v1(166.83,103.05) ; v1(130.01,87.97) 129.78,88.21 JDIM2.35 ; CN12.51 282.22,73.49 281.93,73.2 280.64,73.2 v1(280.49,73.35) ; v1(167.95,84.1) 167.03,83.18 JDIM2.176 ; UG6.D24 240.63,163.7 240.63,163.3 v2(240.71,163.22) 240.86,163.07 240.86,162.53 UG6.F24 ; JDIM2.213 176.28,87.96 176.66,87.58 v1(176.76,87.58) ; v2(202.73,166.06) 203.12,166.45 VRAM4.R14 203.13,166.54 203.47,166.88 v2(203.47,167.01) ; JDIM1.205 174.33,102.88 v1(174.92,102.29) ; 300.93,82.25 v1(302.11,82.25) ; UG6.BP42 228.2,128.57 v2(228.4,128.37) ; JDIM1.10 v1(123.58,97.44) ; JDIM2.60 136.03,83.27 136.89,84.13 v1(136.89,84.2) ; v2(211.75,144.85) 212.1,145.2 VRAM6.T10 ; v2(234.24,182.07) 234.61,181.7 VRAM2.T3 234.64,181.7 v2(235.02,181.32) ; VRAM6.N1 209.88,151.97 v2(210.36,152.46) ; JDIM1.77 140.33,102.79 141.42,101.69 v1(141.47,101.69) ; v1(122.01,84.07) 122.01,83.73 122.53,83.21 JDIM2.6 ; JDIM1.243 183.83,102.37 v1(185.25,100.95) ; UG6.BP44 v2(227,128.37) ; UG6.AW10 250.41,139.22 v2(250.07,139.56) 250.44,139.92 UG6.AV10 ; v2(220.51,170.83) 220.88,170.46 VRAM1.V11 ; v2(155.1,133.54) 155.04,133.54 U42.AR8 154.66,133.21 v2(154.33,132.89) ; v2(219.31,131.86) 219.65,131.52 UG6.BK54 ; v2(256.26,178.33) 256.24,178.33 VRAM3.G3 ; U49.AH35 215.07,62.47 v1(214.63,62.91) 214.25,62.54 U49.AG35 ; CN13.45 v1(110.83,61.18) ; v2(257.9,179.26) 257.57,179.26 VRAM3.F1 257.38,179.47 v2(257,179.85) ; VRAM1.P11 220.88,173.47 v2(220.51,173.83) ; UG6.B14 v2(248,165.47) ; v1(141.46,98.78) 141.77,98.78 142.41,98.14 142.41,97.24 142.58,97.08 JDIM1.86 ; JDIM2.69 v1(138.28,88.2) ; JDIM1.227 179.83,103.19 v1(179.66,103.02) ; U49.AK38 215.9,60.92 v1(215.55,61.28) 215.19,60.92 U49.AH38 ; UG6.G54 219.65,161.62 v2(219.99,161.27) ; UG6.J8 252.14,160.51 v2(252.24,160.51) 252.24,160.61 UG6.H7 ; v2(201.24,151.57) VRAM6.A2 200.82,151.2 v2(200.46,150.84) ; JDIM2.210 175.53,83.08 v1(176.48,84.03) ; v2(204.25,129.59) 203.89,129.95 VRAM8.P4 ; UG6.AG44 226.36,147.62 v2(226.15,147.83) ; UG6.AB1 UG6.AA1 ; UG6.H37 v2(231.2,161.27) ; JDIM1.18 v1(125.58,97.5) ; v2(170.18,148.22) 170.38,148.02 U42.K31 ; UG6.F39 UG6.G38 ; VRAM3.P11 249.86,173.45 249.51,173.8 v2(249.5,173.8) 249.5,173.82 VRAM3.N12 248.74,173.81 v2(248.74,173.81) ; v2(211.23,72.17) 210.87,72.53 U49.Y15 ; UG6.BJ45 v2(225.61,132.56) ; U49.AP38 217.66,60.92 217.33,61.24 217.33,61.24 217.29,61.24 v1(217.27,61.26) ; v1(131.36,98.42) 130.91,97.96 130.91,97.24 131.08,97.08 JDIM1.40 ; VRAM6.A13 200.49,143.33 v2(200.43,143.33) ; UG6.BH51 221.91,132.92 v2(222.18,132.65) ; JDIM2.26 v1(127.53,82.63) ; v2(254.98,157.07) 255.33,156.72 UG6.P3 UG6.R2 ; v2(263.99,141.55) 263.64,141.2 VRAM7.R1 ; VRAM2.F14 242.86,174.2 242.51,173.85 v2(242.51,173.83) ; PU31.5 219.05,91.18 v3(219.21,91.02) ; v2(270.74,156.07) 270.38,155.71 VRAM5.N14 ; v2(222.8,138.16) 223.15,138.51 UG6.AY49 ; v2(252.75,135.12) 252.67,135.12 v2(252.29,134.73) ; UG6.H13 248.35,160.91 v2(248.7,160.56) 249.05,160.91 UG6.H12 ; UG6.U13 UG6.U14 ; CN6.51 v1(110.83,87.73) ; U42.A23 176.69,143.04 v2(176.69,143.13) ; v2(270,157.58) 269.63,157.2 VRAM5.M12 ; UG6.H19 v2(243.79,161.28) ; UG6.BL4 254.76,130.71 254.91,130.71 255,130.61 v2(255.15,130.61) ; 236.44,154.62 v2(236.09,154.27) 235.75,154.61 ; v2(234.61,133.12) 234.35,133.38 UG6.BG33 ; v2(248,164.06) 248.35,164.41 UG6.C13 ; v1(170.08,97.47) JDIM1.188 ; UG6.V8 251.6,154.17 v2(251.4,154.17) ; UG6.AE25 UG6.AE24 240.65,149.02 v2(241,149.36) 241.34,149.02 UG6.AE23 UG6.AE22 UG6.AE21 UG6.AE20 243.57,148.9 244.03,148.9 UG6.AE19 UG6.AE18 244.97,148.9 245.43,148.9 UG6.AE17 ; v1(224.21,67.93) U49.BG25 ; UG6.H18 v2(244.5,160.57) ; UG6.BA50 222.17,137.54 v2(222.17,137.36) 221.99,137.36 UG6.BB51 ; U49.P38 207.67,61.34 v1(207.47,61.34) ; v1(211.77,69.42) 211.4,69.05 U49.AA22 ; JDIM1.78 140.58,97.19 v1(140.18,97.58) ; U42.H26 171.69,144.57 v2(172.01,144.9) 172.01,145.11 U42.G28 ; v2(241.75,170.8) 242.1,170.45 VRAM2.A13 ; v1(205.3,60.78) 205.39,60.69 U49.J39 ; v1(138.11,97.43) 138.08,97.4 JDIM1.68 ; v1(207.3,70.15) 206.9,69.74 U49.M21 ; v2(256.4,146.57) 256.05,146.92 UG6.AH2 ; v2(137.61,144.42) U42.CA24 ; v1(113.36,141.8) 113.4,141.76 U41.3 ; UG6.R53 220.49,156.02 v2(220.76,155.75) ; v1(21.9,53.89) 22.2,54.2 U52.14 ; v2(168.76,148.25) 168.43,147.93 U42.N31 ; UG6.AM3 v2(255,144.47) ; CN7.39 v1(302.14,83.75) ; JDIM2.99 v1(145.78,88.2) ; VRAM8.T5 202.06,131.02 v2(202.06,131.11) ; UG6.AP7 UG6.AN6 252.98,143.69 v2(252.82,143.69) ; JDIM2.9 v1(123.28,88.27) ; v1(140.18,85.15) 139.03,84 JDIM2.72 ; v1(141.47,97.44) 141.58,97.33 JDIM1.82 ; CN13.33 v1(110.85,58.18) ; UG6.Y55 v2(218.6,152.87) ; VRAM1.P4 226.1,173.45 v2(225.72,173.07) ; CN13.1 v1(108.43,50.18) ; VRAM3.E11 v2(249.5,179.82) ; UG6.C1 257.03,164.14 v2(257.2,164.14) ; VRAM4.E4 v2(210.26,158.58) ; PU34.5 248.41,91.18 v3(248.54,91.05) ; JDIM2.102 146.53,83.14 v1(147.46,84.08) ; UG6.H50 222.46,160.92 v2(222.8,161.27) 223.15,161.61 UG6.G49 ; VRAM1.N12 220.12,174.2 v2(219.74,174.57) ; VRAM6.M1 209.13,152.43 v2(209.28,152.58) ; JDIM1.94 v1(144.58,97.45) ; v2(253.6,146.57) 253.95,146.22 UG6.AJ5 ; U49.AG20 214.05,70.23 v1(214.05,70.42) ; VRAM6.P11 VRAM6.N12 209.87,143.7 v2(209.49,143.31) 209.13,143.67 VRAM6.M12 208.75,144.07 v2(208.75,144.08) 208.38,144.45 VRAM6.L11 208.38,144.47 v2(208,144.84) ; v1(214.85,66.35) U49.AJ27 ; v1(131.37,85.09) 132.03,84.44 JDIM2.44 ; VRAM8.F14 209.91,137.45 v2(210.25,137.1) ; v1(178.71,88.16) 178.78,88.22 JDIM2.223 ; UG6.Y8 UG6.W7 UG6.V6 253.07,153.92 v2(252.83,154.16) ; v1(183.78,88.23) JDIM2.243 ; v2(264,156.83) 264,156.83 263.64,157.2 VRAM5.D12 ; C691.2 108.04,105.15 v1(108.78,105.89) 109.31,105.36 C692.1 ; PU30.5 287.75,91.44 ; UG6.C16 246.7,164.87 UG6.B15 ; UG6.B2 255.97,165.2 255.97,165.74 UG6.A2 256.31,166.08 v2(256.69,166.08) ; v2(263.25,143.85) 263.24,143.86 263.21,143.86 VRAM7.T5 262.34,144.73 v2(262.34,144.86) ; v1(123.22,101.74) 123.16,101.74 122.33,102.58 JDIM1.5 ; JDIM1.213 176.33,103.42 176.16,103.26 176.16,102.8 v1(176.56,102.4) ; v2(235.39,128.38) UG6.BP32 ; v2(217.74,67.21) 217.45,66.92 U49.AN26 ; v1(183.09,102.27) 182.66,102.7 182.66,103.22 182.83,103.38 JDIM1.239 ; UG6.BH6 v2(253.6,133.27) ; JDIM2.180 v1(168.03,82.66) ; UG6.N52 v2(221.4,157.07) ; VRAM2.H11 240.62,175.7 240.27,176.04 240.26,176.04 240.23,176.07 v2(240.22,176.07) ; v1(134.96,102.93) 135.33,103.3 JDIM1.57 ; v1(185.48,83.37) 185.03,82.92 JDIM2.248 ; JDIM2.40 131.03,83.12 131.38,83.47 v1(131.43,83.47) ; UG6.BP38 v2(231.2,128.37) ; v2(261.75,156.82) VRAM5.A13 261.27,156.45 v2(260.88,156.05) ; v2(216.96,140.98) 217.32,140.62 UG6.AU56 ; UG6.N7 252.77,157.64 v2(252.77,157.88) 253.02,158.12 UG6.M6 ; UG6.AG2 255.91,147.62 v2(255.65,147.88) ; v2(255.7,130.45) 255.7,130.47 UG6.BL2 ; U49.AK25 215.9,67.5 v2(216.19,67.21) 215.9,66.92 U49.AK26 ; JDIM2.192 v1(171.03,82.64) ; UG6.BL46 v2(224.9,131.17) ; UG6.M53 220.52,158.12 220.79,158.39 v2(220.81,158.39) ; VRAM4.F12 209.88,164.96 v2(209.5,165.34) 209.13,164.96 VRAM4.G12 ; v2(219.38,145.28) 219.13,145.52 UG6.AK55 ; U42.AY6 151.06,131.91 v2(151.39,131.59) ; UG6.BD55 v2(218.6,136.07) ; UG6.B32 v2(235.39,165.46) ; UG6.K37 231.54,159.52 v2(231.19,159.17) ; v2(221.4,144.47) UG6.AL52 ; CN18.20 v1(279.49,38.45) ; CN6.27 v1(110.99,81.73) ; UG6.AY54 v2(220,138.17) ; CN6.39 v1(110.88,84.73) ; JDIM2.168 v1(165.03,82.69)
  BOTTOM w0.3: v2(242.93,128.55) 242.75,128.37 UG6.BR21 ; UG6.BR24 240.65,128.8 v2(240.8,128.94) ; UG6.BR15 246.95,128.62 v2(246.95,128.62) ; UG6.BR18 244.85,128.66 v2(244.89,128.7)
  BOTTOM w0.305: v1(158.37,194.27) PC370.2 159.1,195.03 159.22,194.9 PU26.28 160.2,194.9 v1(161.13,195.84) 161.93,196.64 PU26.4 161.93,197.74 161.55,198.13 PC346.2 ; CN10.7 315.67,83.41 v1(315.5,83.24) ; v2(250.09,153.58) 250.11,153.58 UG6.V10 v2(250.1,154.27) UG6.U10 v2(250.8,154.97) ; v1(317.16,71.03) 317.06,71.03 316.94,70.91 CN10.32 ; v1(317.17,73.91) CN10.26 ; U55.13 v1(272.8,43.57) ; v1(317.17,72.41) CN10.29 ; v1(317.16,76.9) 317.15,76.91 CN10.20 ; PC342.2 122.94,198.34 123.32,197.95 PU22.4 123.32,196.64 v1(122.52,195.84) 121.59,194.9 PU22.28 120.33,194.9 120.21,195.03 PC366.2 119.76,194.4 v1(119.71,194.35) ; v1(148.72,194.27) PC369.2 149.45,195.03 149.57,194.9 PU25.28 150.55,194.9 v1(151.48,195.84) 152.28,196.64 PU25.4 152.28,197.74 151.9,198.13 PC345.2 ; v1(139.07,194.27) PC368.2 139.8,195.03 139.92,194.9 PU24.28 140.89,194.9 v1(141.83,195.84) 142.63,196.64 PU24.4 142.63,197.74 142.24,198.13 PC344.2 ; CN10.23 317.08,75.41 v1(317.17,75.32) ; CN10.14 317.75,79.91 v1(317.99,79.91) ; U49.AE15 213.51,72.53 213.86,72.18 v1(213.86,72.12) ; v1(110.76,194.87) 110.27,194.87 PC365.2 ; v1(129.42,194.27) PC367.2 129.86,195.03 129.99,194.9 PU23.28 131.32,194.9 132.18,195.76 v1(132.18,195.84) 132.98,196.64 PU23.4 132.98,198.2 PC343.2 ; U49.AD15 212.9,72.44 v2(213.19,72.15) 212.9,71.86 U49.AD17 ; v1(317.27,78.32) 317.1,78.32 317.01,78.41 CN10.17 ; 213.63,142.93 VRAM6.V13 ; CN10.1 315.82,86.41 v1(315.73,86.5) ; U42.Y17 v2(163.56,139.05) ; U37.8 267.86,209.07 268.52,208.4 v1(268.52,208.35) ; U42.U17 v2(165.51,139.05) ; v2(166.16,141.39) U42.T20 ; UG4.3 174.41,162.89 173.94,162.42 v1(173.34,162.42)
  BOTTOM w0.35: v2(249.5,172.33) 249.49,172.33 VRAM3.R12 249.13,172.71 248.74,173.09 v2(248.74,173.09)
  BOTTOM w0.356: v1(201.07,184.54) 201.07,184.85 201.01,184.91 Q87.1
  BOTTOM w0.381: v1(239.73,56.96) 239.75,56.96 239.78,56.94 240.49,56.94 241.1,57.54 D65.2 ; v2(245.24,122.26) 244.99,122.51 244.54,122.51 244.16,122.9 UG8.3 ; v1(201.01,106.65) 200.76,106.89 200.76,107.28 200.26,107.78 PQ63.1 ; v1(278.82,204.31) 278.77,204.26 278.08,204.26 C596.1 ; PC420.1 v1(225.34,98.43) ; v1(298.57,105.82) 298.05,105.3 PC396.1 ; v1(34.97,78.73) 34.97,78.63 35.44,78.16 C742.1 C744.1 ; v1(168.4,164.05) 168.4,163.25 168.42,163.22 UG5.3 ; PC445.2 v1(256.04,93.39) ; CN24.13 13.95,16.06 CN24.14 16.52,16.06 v1(16.66,16.2) ; v1(309.76,94.67) 310.39,95.3 C699.2 ; PC468.2 216.7,88.31 216.29,88.31 v1(216.26,88.34) ; CN24.7 13.95,14.26 CN24.8 16.64,14.26 v1(16.66,14.28) ; v1(258.62,117.08) 258.62,117.43 QG20.1 ; Q88.1 206.65,182.48 v1(207.44,183.27) ; v1(294.27,98.66) 294.14,98.52 PC414.1 ; R1171.1 277.74,42.47 v1(277.85,42.58) ; YG1.4 258.69,122.03 258.8,122.14 258.8,122.67 v1(258.97,122.84) ; v1(312.07,90.59) 312.07,90.02 C714.2 ; D64.2 238.62,58.61 v1(238.47,58.76) 238.29,58.59 D63.2 ; v1(209.61,105.09) 209.84,105.32 PQ64.1 ; PC417.1 v1(253.98,98.52) ; PC448.2 v1(236.48,93.32) ; v2(249.5,172.33) 249.5,172.32 249.13,171.95 VRAM3.T12 ; PC415.1 v1(234.93,98.52) ; v1(281.11,53.84) 281.06,53.79 R1065.1 ; v1(255.36,119.16) 255.96,119.76 YG1.2 ; PC418.1 v1(263.5,98.52) ; PC444.2 v1(246.26,93.39) ; v1(39.54,95.97) 39.64,95.97 40.02,95.59 C701.1 C704.1 ; PC446.2 v1(226.7,93.41) ; v1(273.03,98.52) PC419.1 ; PC416.1 v1(244.45,98.52) ; PC413.1 v1(282.55,98.65) ; PC447.2 v1(265.81,93.36)
  BOTTOM w0.508: v1(251.01,216.27) 251.01,216 PC282.2 ; PD6.2 172.35,216.14 v1(171.43,216.14) ; v1(195.47,58.95) 195.36,59.07 SW1.3 ; C722.1 41.57,88.76 v2(42.01,88.32) ; v1(221.92,46.38) 221.85,46.46 CN16.3 ; CN18.22 v1(279.4,37.4) ; v1(147.46,196.54) PC357.2 PC350.2 ; v1(32.33,46.3) 32.02,46 PQ68.1 ; C654.1 137.65,159.9 137.65,160.11 v1(137.5,160.26) ; C751.2 34.09,73.44 v2(33.32,73.44) ; v1(127.65,214.59) PC288.2 ; v2(37.89,90.71) 38.8,90.71 C715.2 ; C752.1 35.12,73.32 v2(35.25,73.44) ; C845.2 268.59,44.91 267.71,44.91 v1(267.5,45.12) ; v1(34.93,95.68) 35.64,95.68 C700.1 ; v1(201.3,192.9) 200.98,192.57 PC379.2 ; PC324.1 122.22,206.88 v1(122.42,207.08) ; v2(31.07,72.9) 31.23,72.74 C753.1 ; Q80.1 v1(283.91,197.3) ; PC279.2 253.01,215.58 v1(253.01,215.33) ; v1(264.66,49.99) 264.65,50 CN14.6 ; v2(203.47,167.01) 203.47,167.9 203.62,168.04 CG459.1 ; Q86.1 272.28,191.42 v1(272.51,191.64) ; v1(212.65,192.85) 212.4,192.85 212.35,192.9 PQ53.1 ; D53.2 265.77,198.9 265.29,199.38 v1(265.29,199.5) ; Q76.1 164.3,212.54 v1(164.3,213.67) ; D54.2 268.96,196.17 267.7,196.17 v1(267.63,196.24) ; Q114.1 192.93,48.54 v1(193.71,48.54) ; PC387.2 177.98,179.41 v1(177.6,179.03) ; Q83.1 265.63,195.81 265.26,196.18 v1(265.08,196.18) ; v1(225.05,44.16) 225.65,44.76 CN16.2 ; C644.1 125.9,161.51 v1(125.55,161.16) ; PR511.2 108.72,134.06 PU27.2 108.72,133.11 108.21,132.6 v1(106.87,132.6) ; v3(305.84,101.73) 304.46,100.35 303.74,100.35 302.68,99.29 PQ72.1 ; PC358.2 157.52,197.19 v1(157.74,197.42) ; v1(157.76,198.41) 157.69,198.34 PC351.2 ; PC302.2 245.5,211.88 v1(245.75,212.13) ; v1(298.57,105.82) 298.28,106.1 PQ73.1 ; PR611.2 197.21,85.14 198.42,83.93 200.21,83.93 200.23,83.91 v1(200.43,83.91) ; PC341.2 113.68,199.36 v1(113.94,199.63) ; v1(204.07,102.72) 204.07,102.86 203.94,102.99 PC400.2 203.18,103.28 203.05,103.15 PU28.2 ; PC363.2 176.39,194.71 v1(176.18,194.71) ; v1(177.74,177.93) 177.32,178.34 PC388.2 ; CN18.24 v1(285.75,37.4) ; C662.1 120.87,146.47 C663.1 122.41,145.98 v1(122.41,145.5) ; PQ39.1 169.93,214.05 v1(169.62,214.05) ; C718.1 39.83,90.7 v2(39.82,90.72) ; PC393.2 109.67,130.32 PU27.4 109.67,131.33 110.17,131.84 v1(110.92,131.84) ; v1(207.12,44.5) 207.12,43.48 CN17.11 ; v2(37.37,72.88) 36.92,73.33 C750.1 ; PQ57.1 v1(195.01,193.45) ; PC392.2 v1(183.56,174.99) ; PQ51.1 v1(178.91,198.34) ; v1(195.6,56.73) 195.6,56.63 195.09,56.12 SW1.4 ; v2(37.44,71.97) 37.08,71.6 C754.1 ; PC348.2 PC355.2 v1(128.15,196.54) ; C576.1 v1(144.54,214.73) ; J1.5 236.83,62.22 v1(236.7,62.35) ; v1(266.02,60.82) 266.28,61.09 PC486.2 ; PC508.2 v1(117.94,41.38) ; PC321.2 250.45,207.35 251.18,208.09 251.95,208.09 v1(251.97,208.07) ; PC280.2 124.47,216.54 v1(124.08,216.93) 123.87,216.93 PR353.2 ; v2(263.55,135.19) 263.8,134.95 QG17.1 ; PC378.2 218.87,193.82 v1(218.8,193.89) ; CG457.1 200.9,167.83 v2(201.15,167.58) ; CN20.5 v1(269.7,38.2) ; v1(203.04,89.26) 202.92,89.14 PC467.2 ; SW2.2 248.88,49.79 v1(248.29,49.79) ; v2(31.16,70.86) 31.34,70.86 31.38,70.81 31.86,70.81 C756.1 ; v2(42.21,90.16) 42.19,90.16 41.67,90.68 C712.1 ; v2(35.64,90.17) 35.97,90.5 C717.1 ; v1(225.89,204.95) 225.68,204.74 PC334.2 ; v1(201.97,183.02) 201.97,183.14 202.27,183.44 C611.2 ; PC384.2 v1(189.22,187.82) ; v1(215.81,193.67) 215.47,193.33 PC380.2 ; v1(194.51,50.15) 195.3,49.36 Q115.1 ; v1(312.83,77.76) 312.83,77.26 312.11,76.53 D61.2 ; CG458.1 202.35,167.85 v2(202.01,167.51) ; v1(186.51,49.64) 186.51,49.64 186.76,49.38 U54.2 ; C741.1 30.77,78.4 v1(30.34,78.4) ; v1(34.94,94.43) 35.31,94.79 C702.1 ; v1(137.81,196.51) PC356.2 PC349.2 ; CN14.5 263.4,50.19 v1(263.21,50) ; v1(124.57,160.83) 124.57,160.5 125.08,159.99 C653.1 ; v1(179.11,39.47) 180.36,40.72 CN19.14 ; Q84.1 v1(284.6,192.49) ; C592.1 146.11,208.43 v1(146.52,208.84) ; PR625.1 v1(117.31,49.6) ; PR381.2 v1(127.96,212.79) ; C746.1 36.86,76.29 v1(36.62,76.54) ; v2(32.66,74.74) 32.26,75.14 C747.2 ; C633.1 v1(132.24,161.81) ; v1(138.43,160.16) 138.43,161.14 C645.1 ; v1(118.37,199.35) 118.5,199.22 PC347.2 PC354.2 ; PQ56.1 v1(207.41,193.45) ; v1(30.21,77.12) 30.27,77.05 31.1,77.05 C743.1 ; UG7.4 v1(273.65,134.14) ; 41.43,93.18 41.43,93.57 v1(41.19,93.81) ; CN20.6 v1(260.85,38.2) ; PC487.2 v1(262.43,59.93) ; JDIM1.262 192.45,90.89 v1(191.57,90.01) ; CG447.1 v1(204.92,170.54) ; CN16.4 228.2,46.86 v1(227.46,46.11) ; PQ62.1 177.36,175.39 v1(177.07,175.68) ; C710.2 36.64,92.88 37.27,92.24 v2(37.27,92.02) ; C648.1 131.45,160.81 131.17,161.09 131.17,161.96 v1(131.19,161.97) ; PC283.2 v1(222.13,215.02) ; v1(197.48,181.92) 197.62,181.92 C616.2 ; v1(199.03,191.17) PC381.2 ; v1(63.41,85.37) 63.64,85.14 R888.2 ; CG426.1 259.73,185.42 v2(259.77,185.38) ; v1(111.2,44.4) PC505.2 ; PC482.2 55.44,68.61 55.24,68.81 v1(55.15,68.81) ; R1066.1 v1(287.06,52.41)
  vias: v1(10.93,78.25) v1(11.81,69.69) v1(13.74,42.96) v1(13.97,39.72) v1(14.01,40.47) v1(14.7,93.49) v1(14.68,40.85) v1(14.76,94.51) v1(14.86,42.99) v1(15.23,77.92) v1(15.27,29.42) v1(15.55,34.46) v1(15.82,94.91) v1(16.65,17.59) v1(16.79,43.29) v1(17.75,53.16) v1(17.91,100.67) v1(17.94,45.15) v1(18.02,65.47) v1(18.06,64.38) v1(18.03,63.17) v1(18.04,59.18) v1(18.27,27.8) v1(18.49,47.05) v1(18.67,100.67) v1(19.19,65.47) v1(19.21,64.4) v1(19.22,63.15) v1(19.26,14.14) v1(19.35,100.68) v1(19.33,22.06) v1(19.56,79.25) v1(19.6,78.24) v1(19.64,27.83) v1(20,59.25) v1(20.02,100.68) v1(20.03,45.78) v1(20.14,77) v1(20.25,99.23) v1(20.28,65.43) v1(20.31,64.27) v1(20.29,63.16) v1(20.69,100.66) v1(20.83,77) v1(21.21,95.94) v1(21.25,94.92) v1(21.21,32.23) v1(21.3,30.04) v1(21.37,100.68) v1(21.49,29.2) v1(21.92,52.79) v1(22.1,93.21) v1(22.45,53.35) v1(22.53,93.71) v1(23.01,53.91) v1(23.01,52.79) v1(23.14,28.72) v1(23.47,62.4) v1(23.57,68.03) v1(23.63,69.36) v1(24.58,70.67) v1(24.59,51.45) v1(24.69,76.98) v1(24.65,72.85) v1(24.93,74.86) v1(26.77,52.57) v1(28.51,93.73) v1(29.16,90.13) v1(29.2,87.98) v1(29.15,81.66) v1(29.17,80.82) v1(29.24,92.02) v1(30.12,79.77) v1(30.46,83.5) v1(31.93,81.07) v1(32.03,83.66) v1(32.41,39.9) v1(32.87,79.77) v1(32.82,79.12) v1(32.92,43.78) v1(33.2,45.5) v1(33.73,99.75) v1(33.74,97.75) v1(33.8,40.49) v1(33.93,81.57) v1(34.37,36.03) v1(34.69,97.05) v1(34.68,81.61) v1(35.02,100.83) v1(35.09,54.6) v1(35.28,98.79) v1(36.07,76.19) v1(36.55,37.53) v1(36.68,100.83) v1(37.1,47.93) v1(37.38,43.73) v1(37.37,42.75) v1(37.38,41.84) v1(37.43,97.05) v1(37.54,48.42) v1(38.25,38.75) v1(38.41,63.06) v1(38.33,43.73) v1(38.36,42.76) v1(38.38,41.8) v1(38.5,98.49) v1(38.53,58.87) v1(38.53,57.67) v1(38.92,38.72) v1(39.17,48.5) v1(39.32,43.74) v1(39.35,42.73) v1(39.36,41.76) v1(39.46,80.87) v1(39.73,98.41) v1(39.93,58.88) v1(39.93,57.67) v1(40.11,80.88) v1(40.16,64.61) v1(40.13,39.86) v1(40.48,40.4) v1(40.64,93.46) v1(40.77,80.88) v1(40.74,63.08) v1(41.11,48.48) v1(41.44,80.88) v1(41.7,58.88) v1(41.71,57.67) v1(41.84,65.75) v1(41.92,75.58) v1(41.91,74.54) v1(41.91,73.88) v1(41.91,72.89) v1(41.91,72.18) v1(41.91,71.18) v1(41.91,70.52) v1(41.91,69.53) v1(42.41,38.21) v1(42.55,64.61) v1(42.52,38.86) v1(42.8,75.65) v1(43.22,58.89) v1(43.23,57.67) v1(43.69,66.74) v1(44.07,97.75) v1(44.17,65.77) v1(44.83,97.75) v1(44.88,58.89) v1(44.88,57.67) v1(45.05,77.68) v1(45.37,77.1) v1(45.6,97.75) v1(45.57,78.06) v1(45.9,77.48) v1(46,76.49) v1(46.08,66.76) v1(46.36,97.75) v1(46.49,92.77) v1(46.49,91.81) v1(46.49,91.15) v1(46.49,90.16) v1(46.49,89.45) v1(46.49,88.46) v1(46.49,87.8) v1(46.49,86.81) v1(46.53,36.59) v1(47.55,92.24) v1(47.58,91.3) v1(47.65,89.6) v1(48.06,94.48) v1(48.08,59.12) v1(48.11,57.63) v1(48.49,98.44) v1(48.49,50.59) v1(49.15,98.44) v1(49.23,51.78) v1(49.91,51.76) v1(50.61,51.74) v1(50.8,50.66) v1(51.28,51.77) v1(51.67,70.7) v1(53.09,60.91) v1(53.85,94.58) v1(54.15,55.58) v1(54.51,94.58) v1(54.82,38.82) v1(57.47,52.22) v1(58.27,48.54) v1(58.77,42.04) v1(58.79,41.22) v1(59.39,71.46) v1(60.75,54.79) v1(61.14,83.55) v1(61.18,55.5) v1(61.23,54.29) v1(61.73,82.89) v1(61.73,82.13) v1(61.73,81.37) v1(62.11,95.37) v1(62.11,94.6) v1(62.03,55.49) v1(62.4,82.89) v1(62.42,82.13) v1(62.44,81.37) v1(62.46,49.06) v1(62.87,95.37) v1(62.87,94.6) v1(63.15,96.64) v1(63.38,93.18) v1(63.63,95.37) v1(63.63,94.6) v1(64.39,93.18) v1(67.27,50.15) v1(69.3,60.13) v1(69.45,71.08) v1(69.98,60.13) v1(70.18,71.06) v1(70.89,71.03) v1(71.58,71.06) v1(74.35,41.92) v1(75.94,42.01) v1(76.41,52.59) v1(76.81,53.18) v1(77.7,42.05) v1(79.13,57.79) v1(79.38,41.62) v1(81.28,57.78) v1(81.88,91.84) v1(81.95,89.7) v1(82.96,46.83) v1(85.54,89.14) v1(85.75,42.69) v1(86.36,94.91) v1(87.35,83.83) v1(87.89,94.95) v1(87.93,84.62) v1(89.28,94.08) v1(90.12,84.65) v1(92.51,93.14) v1(92.56,93.99) v1(92.59,89.75) v1(92.73,84.79) v1(93.68,93.92) v1(94.22,84.69) v1(94.89,84.7) v1(95.76,83.94) v1(96.35,65.22) v1(97.11,65.22) v1(97.13,91.76) v1(97.4,88.72) v1(97.4,88.07) v1(97.8,91.76) v1(97.77,65.22) v1(97.79,55.84) v1(98.1,54.32) v1(98.13,57.52) v1(98.43,96.71) v1(99.16,89.29) v1(99.22,81.42) v1(99.68,72.1) v1(100,74.38) v1(100.29,57.54) v1(100.4,72.08) v1(100.75,75.21) v1(101.12,72.08) v1(101.88,99.09) v1(101.83,72.08) v1(102.26,74.92) v1(102.95,102.88) v1(104.46,79.76) v1(104.46,78.58) v1(107.5,72) v1(108.08,72.36) v1(108.08,71.69) v1(109.36,47.93) v1(110.44,173.78) v1(110.85,95.42) v1(110.85,94.76) v1(110.87,94.1) v1(110.9,93.43) v1(111.14,173.36) v1(111.14,172.7) v1(111.92,40.95) v1(112.02,186.91) v1(112.02,186.14) v1(112.02,185.38) v1(112.18,121.56) v1(112.3,101.64) v1(112.47,120.77) v1(112.6,190.69) v1(112.6,102.73) v1(112.89,121.52) v1(113.06,40.93) v1(113.14,57.09) v1(113.25,61.69) v1(113.4,55.61) v1(113.75,87.3) v1(113.71,84.03) v1(113.72,81) v1(114.07,40.91) v1(114.15,210.29) v1(114.17,209.63) v1(114.39,79.34) v1(114.59,85.46) v1(114.8,210.29) v1(115.29,83.3) v1(115.39,61.71) v1(115.36,59.87) v1(115.33,57.17) v1(115.43,88.55) v1(115.43,87.87) v1(115.58,55.6) v1(115.79,84.46) v1(115.9,80.95) v1(115.85,40.93) v1(116.03,77.19) v1(116.35,61.68) v1(116.5,63.42) v1(116.69,41.61) v1(116.76,216) v1(116.93,186.86) v1(116.93,186.09) v1(116.93,185.33) v1(116.98,181.46) v1(116.97,55.6) v1(117.28,82.86) v1(117.25,71.77) v1(117.6,59.87) v1(117.75,78.55) v1(117.88,181.52) v1(118.02,76.67) v1(118.52,61.69) v1(118.69,73.11) v1(118.66,63.43) v1(118.71,56.51) v1(119.3,42.07) v1(119.58,61.67) v1(120.07,190.95) v1(120.01,78.59) v1(120.15,181.48) v1(120.22,76.68) v1(120.26,58.08) v1(120.87,181.5) v1(121.67,186.91) v1(121.67,186.14) v1(121.67,185.38) v1(121.72,61.75) v1(122.49,58.15) v1(124.56,49.49) v1(125.61,186.91) v1(125.61,186.14) v1(125.61,185.38) v1(126.29,46.57) v1(127.38,181.48) v1(127.84,41.7) v1(128.06,58.12) v1(128.21,181.49) v1(128.4,40.68) v1(128.42,39.99) v1(128.7,84.95) v1(129.8,181.5) v1(130.05,99.58) v1(130.15,190.84) v1(130.31,58.08) v1(130.55,181.49) v1(130.8,69.56) v1(131.32,186.91) v1(131.32,186.14) v1(131.32,185.38) v1(132.88,127.19) v1(133.4,100.98) v1(133.61,215.66) v1(134.45,215.69) v1(134.52,38.85) v1(135.26,186.91) v1(135.26,186.14) v1(135.26,185.38) v1(136.34,52.67) v1(136.47,181.54) v1(137.11,214.49) v1(137.16,181.59) v1(138.85,215.07) v1(138.85,181.54) v1(139.45,216.84) v1(139.58,181.55) v1(139.75,190.89) v1(140,216.49) v1(140.26,215.84) v1(140.97,186.91) v1(140.97,186.14) v1(140.97,185.38) v1(140.97,41.16) v1(141.38,85.46) v1(141.99,203.21) v1(142.66,202.38) v1(142.65,201.73) v1(143.26,101.72) v1(144.21,86.83) v1(144.73,41.36) v1(144.91,186.91) v1(144.91,186.14) v1(144.91,185.38) v1(145.72,86.91) v1(146.28,205.19) v1(146.23,204.28) v1(146.82,181.51) v1(147.2,206.11) v1(147.2,205.17) v1(147.17,204.28) v1(147.54,181.48) v1(148.09,206.08) v1(148.09,205.19) v1(148.06,204.26) v1(148.38,181.46) v1(149.28,190.67) v1(149.23,181.49) v1(150.6,168.29) v1(150.6,167.58) v1(150.63,186.91) v1(150.63,186.14) v1(150.63,185.38) v1(150.9,166.69) v1(151.23,167.96) v1(152.21,161.15) v1(152.45,159.05) v1(153.79,163.52) v1(154,161.84) v1(154.56,186.91) v1(154.56,186.14) v1(154.56,185.38) v1(155.11,161.9) v1(155.12,99.48) v1(155.34,74.82) v1(155.91,167.22) v1(155.9,159.95) v1(156.03,74.82) v1(156.37,82.92) v1(156.47,181.47) v1(156.42,165.29) v1(156.52,97.76) v1(156.95,160.07) v1(157.18,181.47) v1(157.4,162.31) v1(157.99,167.25) v1(158.16,162.29) v1(158.88,181.48) v1(159.36,190.82) v1(159.55,181.46) v1(159.61,166.58) v1(160.03,158.18) v1(160.28,186.91) v1(160.28,186.14) v1(160.28,185.38) v1(160.33,165.24) v1(160.45,158.68) v1(160.76,68.47) v1(161.22,79.54) v1(161.31,156.98) v1(161.74,100.89) v1(162.03,166.59) v1(162.69,165.31) v1(163.34,72.2) v1(163.45,162.78) v1(164.21,186.91) v1(164.21,186.14) v1(164.21,185.38) v1(164.4,207.92) v1(164.43,206.83) v1(164.54,161.91) v1(165.4,207.87) v1(165.42,206.83) v1(165.87,181.5) v1(167.06,192.06) v1(167.31,92.11) v1(167.6,76.59) v1(168.05,41.62) v1(168.18,166.88) v1(168.28,100.62) v1(170.72,194.73) v1(171.34,86.97) v1(171.33,41.67) v1(171.54,78.47) v1(172.2,78.45) v1(173.21,99.71) v1(173.51,84.85) v1(173.92,210.02) v1(173.92,209.36) v1(173.92,208.7) v1(173.92,208.04) v1(174.55,98.95) v1(175.28,174.98) v1(178.26,197.73) v1(178.79,85.89) v1(179.4,197.88) v1(179.66,101.68) v1(181.38,98.87) v1(181.91,76.58) v1(183.54,99.91) v1(183.92,85.03) v1(184.56,46.26) v1(184.66,145.59) v1(184.7,143.36) v1(185.09,50.34) v1(185.21,46.25) v1(185.83,187.16) v1(186.29,93.59) v1(186.49,187.16) v1(187.15,101.1) v1(187.96,93.56) v1(187.96,92.8) v1(187.96,92.04) v1(187.96,91.28) v1(187.93,65.87) v1(188.27,58.02) v1(188.51,41.92) v1(188.53,41.27) v1(189.18,93.03) v1(189.59,101.99) v1(189.59,101.33) v1(189.56,99.05) v1(189.56,98.39) v1(189.74,79.65) v1(189.94,58.84) v1(190.21,80.1) v1(190.48,63.5) v1(190.6,70.92) v1(190.66,80.56) v1(192.23,157.27) v1(192.25,142.46) v1(192.56,156.68) v1(193.01,162.28) v1(193.07,157.39) v1(193.3,156.71) v1(193.78,192.8) v1(193.81,192.14) v1(193.78,157.6) v1(193.96,156.86) v1(194.54,163.49) v1(195.25,152.79) v1(195.25,146.29) v1(195.25,143.14) v1(195.33,149.7) v1(195.35,139.61) v1(195.43,136.23) v1(195.43,132.65) v1(195.46,129.76) v1(195.58,168.92) v1(195.54,166.88) v1(195.58,160.77) v1(195.53,157.77) v1(195.61,42.87) v1(195.7,54.13) v1(196.1,169.51) v1(196.05,152.4) v1(196.07,145.72) v1(196.22,150.88) v1(196.47,165.26) v1(196.54,171.03) v1(196.61,166.54) v1(196.79,170.38) v1(196.79,169.59) v1(196.77,156.37) v1(196.98,56.95) v1(197.03,162.99) v1(197.62,53.79) v1(197.71,95.68) v1(197.72,95.02) v1(198.13,96.85) v1(198.35,58.21) v1(198.4,57.06) v1(199.47,57.09) v1(199.54,78.51) v1(200,74.46) v1(200.46,80.09) v1(200.59,70.46) v1(200.93,56.77) v1(201.03,58.05) v1(201.05,57.41) v1(201.03,56.13) v1(201.6,210.58) v1(201.62,84.79) v1(201.67,82.67) v1(201.63,74.05) v1(202.08,77.51) v1(202.13,80.94) v1(202.16,79.83) v1(202.77,80.75) v1(202.76,80.1) v1(202.72,48.35) v1(202.97,83.7) v1(203.02,76.9) v1(204.89,81.56) v1(205.74,98.62) v1(206.12,81.26) v1(206.22,174.75) v1(206.36,79.33) v1(207.01,205.42) v1(207.06,100.09) v1(207.14,174.36) v1(207.4,175.65) v1(207.67,205.42) v1(207.63,81.05) v1(208.41,205.4) v1(211.18,181.25) v1(211.46,175.99) v1(211.67,40.61) v1(211.71,179.67) v1(212.09,176.95) v1(212.32,40.63) v1(212.87,183.87) v1(212.88,180.33) v1(212.87,179.32) v1(212.95,181.65) v1(213.11,175.99) v1(213.12,177.93) v1(213.13,176.95) v1(214.37,41.68) v1(214.73,42.38) v1(215.02,41.68) v1(215.38,42.28) v1(215.67,41.68) v1(216.18,94.68) v1(218.42,186.63) v1(219.1,186.6) v1(219.2,72.89) v1(219.36,96) v1(221.52,189) v1(222.19,188.99) v1(223.45,207.05) v1(223.45,206.34) v1(223.59,186.74) v1(224.11,206.31) v1(224.27,186.75) v1(224.38,79.44) v1(224.43,55.58) v1(224.56,212.41) v1(224.92,96.23) v1(225.08,55.58) v1(225.73,55.58) v1(225.94,88.86) v1(226.76,36.47) v1(226.9,69.2) v1(227.41,36.5) v1(228.04,79.53) v1(228.06,36.47) v1(228.68,79.41) v1(228.66,78.33) v1(228.7,36.5) v1(229.35,36.47) v1(230.08,71.32) v1(230.01,36.49) v1(230.72,36.47) v1(230.94,212.36) v1(230.91,114.77) v1(231.3,113.55) v1(231.33,69.89) v1(231.37,36.5) v1(232.02,36.47) v1(232.17,48.32) v1(232.39,200.33) v1(232.68,36.49) v1(232.77,75.48) v1(232.85,48.32) v1(232.95,66.66) v1(233.4,36.49) v1(233.51,119.77) v1(234.08,36.49) v1(234.45,96.64) v1(234.55,81.07) v1(234.55,40.32) v1(234.83,44.26) v1(235.03,88.27) v1(235.18,120.36) v1(235.18,119.7) v1(235.28,119.01) v1(235.26,40.3) v1(235.36,186.81) v1(235.41,117.92) v1(235.59,44.26) v1(235.68,88.91) v1(235.68,88.27) v1(235.84,120.38) v1(235.84,119.72) v1(235.94,119.06) v1(236.05,186.81) v1(236.02,40.3) v1(236.35,44.26) v1(236.76,204.65) v1(236.76,203.91) v1(237.49,204.65) v1(237.49,203.91) v1(237.5,70.22) v1(237.46,68.97) v1(237.58,186.77) v1(237.67,80.18) v1(238.23,204.65) v1(238.23,203.91) v1(238.23,203.18) v1(238.24,186.78) v1(238.71,46.26) v1(238.89,70.22) v1(238.9,68.94) v1(238.97,203.91) v1(238.97,203.18) v1(238.99,186.79) v1(238.93,67.67) v1(239.24,204.62) v1(239.32,201.99) v1(239.32,82.94) v1(239.7,203.91) v1(239.7,203.18) v1(239.65,186.8) v1(239.97,204.62) v1(240.31,70.26) v1(240.31,68.92) v1(240.34,67.65) v1(240.44,203.91) v1(240.44,203.18) v1(240.71,204.62) v1(240.85,62.9) v1(241.53,119.17) v1(241.94,63.19) v1(242.24,36.62) v1(243.01,204.74) v1(243.01,204.01) v1(243.69,113.42) v1(243.75,204.74) v1(243.75,204.01) v1(243.84,202.17) v1(244.02,41.49) v1(244.48,204.74) v1(244.48,204.01) v1(244.48,203.27) v1(244.45,96.79) v1(244.58,63.99) v1(244.85,88.22) v1(244.83,46.59) v1(245.18,75.61) v1(245.22,204.74) v1(245.22,204.01) v1(245.22,203.27) v1(245.49,88.86) v1(245.49,88.22) v1(245.57,214.64) v1(245.96,204.74) v1(245.96,204.01) v1(245.96,203.27) v1(246.69,204.74) v1(246.69,204.01) v1(246.69,203.27) v1(246.64,38.72) v1(246.73,57.92) v1(247.32,120.59) v1(248.44,118.38) v1(248.53,186.78) v1(248.76,216.91) v1(249.19,186.8) v1(249.44,212.16) v1(249.44,211.37) v1(249.51,121.22) v1(249.53,120.1) v1(250.22,212.16) v1(250.22,211.37) v1(250.32,203.98) v1(250.45,115.94) v1(251.07,121.21) v1(251.11,115.94) v1(251.82,186.81) v1(252.4,212.51) v1(252.48,186.81) v1(252.85,119.77) v1(253.21,120.31) v1(253.44,84.72) v1(254.03,57.11) v1(254.21,96.84) v1(254.49,202.2) v1(254.52,205.03) v1(254.52,204.29) v1(254.59,88.27) v1(254.95,117.97) v1(254.92,57.02) v1(255.07,50.21) v1(255.26,205.03) v1(255.26,204.29) v1(255.23,88.91) v1(255.23,88.27) v1(255.49,57.33) v1(255.67,84.72) v1(255.99,205.03) v1(255.99,204.29) v1(255.99,203.56) v1(256.09,57.02) v1(256.26,57.72) v1(256.35,209.77) v1(256.73,205.03) v1(256.73,204.29) v1(256.73,203.56) v1(256.92,185.89) v1(256.94,185.22) v1(256.92,84.72) v1(257.31,70.68) v1(257.47,205.03) v1(257.47,204.29) v1(257.47,203.56) v1(258.04,70.68) v1(258.2,205.03) v1(258.2,204.29) v1(258.2,203.56) v1(258.13,84.71) v1(258.4,209.78) v1(258.85,215.81) v1(258.85,70.65) v1(259.21,84.7) v1(259.36,205.45) v1(259.57,79.59) v1(259.59,78.19) v1(259.59,76.8) v1(259.59,70.6) v1(259.82,44.74) v1(260.35,84.7) v1(260.51,70.6) v1(260.66,204.99) v1(260.66,204.26) v1(260.99,79.59) v1(260.99,78.19) v1(260.99,76.8) v1(261.17,70.6) v1(261.39,204.99) v1(261.39,204.26) v1(261.5,84.72) v1(262.13,204.99) v1(262.13,204.26) v1(262.13,203.52) v1(262.18,84.7) v1(262.39,79.59) v1(262.39,78.19) v1(262.39,76.8) v1(262.51,44.74) v1(262.87,204.99) v1(262.87,84.7) v1(263.27,178.37) v1(263.28,177.71) v1(263.3,44.74) v1(263.35,180.76) v1(263.49,210.2) v1(263.6,204.99) v1(263.78,96.84) v1(263.91,173.67) v1(263.96,176.57) v1(263.97,175.91) v1(263.93,175.1) v1(263.94,174.44) v1(263.92,173.01) v1(264.19,184.27) v1(264.2,183.6) v1(264.14,182.87) v1(264.14,182.21) v1(264.14,181.37) v1(264.14,180.71) v1(264.14,179.95) v1(264.14,179.29) v1(264.25,210.29) v1(264.29,178.19) v1(264.34,204.99) v1(264.37,88.27) v1(264.54,185.76) v1(264.95,171.26) v1(265.01,88.91) v1(265.01,88.27) v1(265.25,213.37) v1(265.61,205.22) v1(265.83,50.18) v1(265.96,210.17) v1(265.95,44.66) v1(266.07,213.45) v1(266.8,51.59) v1(266.96,170.68) v1(267.06,169.96) v1(267.11,50.16) v1(267.42,51.78) v1(267.59,183.03) v1(267.6,50.61) v1(267.62,170.68) v1(267.78,216.11) v1(267.75,203.99) v1(267.72,169.97) v1(267.97,180.91) v1(268.37,212.12) v1(268.36,211.34) v1(268.33,170.63) v1(268.81,216.09) v1(268.9,183.7) v1(268.99,170.63) v1(269.19,51.49) v1(269.31,181.86) v1(269.27,181.1) v1(269.3,180.42) v1(269.65,170.57) v1(269.99,181.81) v1(269.95,181.09) v1(269.97,180.41) v1(269.95,78.78) v1(269.93,78.13) v1(270.15,206.52) v1(270.23,207.19) v1(270.31,170.58) v1(270.31,84.6) v1(270.65,207.69) v1(270.87,207.05) v1(271.16,84.53) v1(271.79,216.67) v1(271.93,202.98) v1(272.26,213.14) v1(272.39,207.51) v1(272.58,202.97) v1(273.1,59.21) v1(273.25,213.15) v1(273.23,212.25) v1(273.31,138.24) v1(273.31,137.48) v1(273.63,207.53) v1(273.64,96.74) v1(273.61,80.58) v1(273.75,59.2) v1(273.99,138.19) v1(273.99,137.43) v1(274.18,213.13) v1(274.2,212.27) v1(274.12,205.91) v1(274.15,88.27) v1(274.27,80.59) v1(274.66,208.36) v1(274.71,138.23) v1(274.72,137.55) v1(274.79,88.91) v1(274.79,88.27) v1(274.92,94.78) v1(274.92,94.13) v1(275.08,217.26) v1(275.18,213.1) v1(275.19,212.26) v1(275.37,206.05) v1(275.38,188.5) v1(275.54,169.51) v1(276,203.46) v1(276.09,213.09) v1(276.11,204.22) v1(276.05,137.43) v1(276.23,185.26) v1(276.39,129.81) v1(276.45,130.48) v1(276.66,207.46) v1(276.84,170.09) v1(276.91,185.74) v1(277.07,137.88) v1(277.11,130.42) v1(277.12,197.57) v1(277.13,129.73) v1(277.28,216.99) v1(277.34,170.56) v1(277.5,169.89) v1(277.54,140.75) v1(277.61,137.23) v1(277.71,156.67) v1(277.65,155.96) v1(277.72,217.61) v1(277.79,207.52) v1(277.8,158.67) v1(277.78,158.02) v1(277.76,130.41) v1(277.87,171.07) v1(277.85,161.41) v1(277.84,160.73) v1(277.83,159.32) v1(277.88,154.09) v1(277.87,152.46) v1(277.86,150.75) v1(277.88,146.11) v1(277.88,143.01) v1(277.88,142.37) v1(278,170.38) v1(277.91,149.29) v1(277.94,144.38) v1(278,140.28) v1(278.01,138.65) v1(278.03,141.2) v1(278.08,137.68) v1(278.05,66.15) v1(278.19,169.69) v1(278.2,168.78) v1(278.2,168.11) v1(278.2,167.38) v1(278.15,165.85) v1(278.15,64.79) v1(278.21,166.55) v1(278.37,171.52) v1(278.57,164.18) v1(278.63,172.12) v1(278.62,170.92) v1(278.63,170.23) v1(278.69,164.84) v1(278.74,217.61) v1(278.75,169.26) v1(278.85,168.45) v1(278.82,167.71) v1(278.81,166.95) v1(278.85,166.22) v1(278.84,165.56) v1(278.84,68.08) v1(279.3,44.21) v1(279.3,43.47) v1(279.43,81.04) v1(279.42,76.82) v1(279.64,215.64) v1(279.62,72.02) v1(279.73,203.32) v1(279.71,79.44) v1(279.71,78.15) v1(280.48,50.06) v1(280.57,215.77) v1(280.57,203.01) v1(280.82,50.66) v1(281.07,206.95) v1(281.12,50.08) v1(281.34,215.57) v1(281.41,211.64) v1(281.51,50.61) v1(281.86,79.54) v1(282.06,206.96) v1(282.81,113.17) v1(282.81,112.14) v1(282.93,192.19) v1(283.34,120.31) v1(283.47,203.04) v1(283.49,119.65) v1(283.67,170.4) v1(283.72,168.35) v1(283.77,47.92) v1(284,120.18) v1(284.03,96.74) v1(284.18,88.14) v1(284.42,47.94) v1(284.66,176.58) v1(284.68,175.92) v1(284.86,188.56) v1(284.86,186.48) v1(284.83,94.78) v1(284.83,94.13) v1(284.83,88.79) v1(284.83,88.14) v1(285.07,47.94) v1(285.59,67.18) v1(285.72,47.92) v1(285.96,68.53) v1(286.36,47.94) v1(287.01,47.92) v1(287.2,69.79) v1(287.66,47.94) v1(289.03,115.13) v1(289.03,86.68) v1(289.61,116.93) v1(289.84,113.25) v1(289.94,77.23) v1(290.6,77.23) v1(290.71,117.03) v1(290.68,86.45) v1(291.93,77.71) v1(292.13,120) v1(292.4,121.93) v1(292.81,121.14) v1(292.98,119.64) v1(293.88,87.59) v1(294.19,78.51) v1(294.37,94.08) v1(294.64,89.27) v1(294.64,88.61) v1(294.75,94.83) v1(295,87.29) v1(295,79.64) v1(295.3,89.27) v1(295.3,88.61) v1(295.67,87.34) v1(295.96,89.27) v1(295.96,88.61) v1(297.19,87.54) v1(298.55,102.66) v1(298.76,98.36) v1(299.06,94.4) v1(299.06,75.83) v1(299.19,92.97) v1(299.37,73.42) v1(299.47,78.35) v1(299.72,75.83) v1(300.17,67.83) v1(300.17,66.9) v1(300.86,67.82) v1(300.84,66.88) v1(301.59,67.81) v1(301.58,66.88) v1(302.3,67.78) v1(302.33,66.88) v1(302.47,95.54) v1(303.16,91.81) v1(303.61,75.86) v1(303.64,75.17) v1(303.84,91.72) v1(304.78,68.44) v1(304.98,94.4) v1(305.23,67.04) v1(305.27,60.65) v1(305.75,98.11) v1(306.01,64.09) v1(306.07,83.96) v1(306.25,96.66) v1(306.41,98.12) v1(307.08,98.12) v1(307.03,86.23) v1(307.11,84.75) v1(307.11,83.2) v1(307.28,80.1) v1(307.28,79.45) v1(307.28,78.78) v1(307.44,93.99) v1(307.74,63.53) v1(307.93,93.57) v1(308.99,77.13) v1(309.77,77.32) v1(311.36,99.61) v1(311.34,96.54) v1(311.39,67.33) v1(311.4,66.45) v1(311.42,95.47) v1(311.42,65.5) v1(311.47,64.66) v1(311.9,96.04) v1(312,99.7) v1(312.31,65.48) v1(312.4,68.19) v1(312.35,67.27) v1(312.35,66.43) v1(312.33,64.65) v1(312.48,96.52) v1(312.47,95.43) v1(312.45,78.35) v1(312.6,83.38) v1(312.82,81.64) v1(312.82,80.97) v1(313.28,68.21) v1(313.29,65.48) v1(313.33,67.22) v1(313.34,66.4) v1(313.49,81.62) v1(313.52,80.96) v1(313.95,86.68) v1(314.13,101.58) v1(314.15,81.59) v1(314.18,80.94) v1(314.15,64.67) v1(314.23,66.44) v1(314.46,84.5) v1(314.58,86.48) v1(314.84,101.63) v1(315.01,93.02) v1(315.41,88.1) v1(315.47,81.74) v1(315.47,80.68) v1(315.64,101.53) v1(315.68,100.76) v1(315.74,77.11) v1(316.39,101.54) v1(316.39,100.74) v1(317.45,88.47) v1(317.7,95.45) v1(317.66,86.76) v1(317.63,84.61) v1(317.78,100.78) v1(317.71,96.53) v1(317.77,89.06) v1(318.11,88.5) v1(318.27,95.97) v1(318.75,99.68) v1(318.84,96.53) v1(318.81,95.42) v1(320.37,92.16) v1(320.4,89.9) v2(123.84,137.88) v2(124.29,133.89) v2(124.34,131.91) v2(125.86,137.94) v2(126.42,131.5) v2(129.61,125.34) v2(131.32,127.59) v2(134.75,127.49) v2(134.83,125.61) v2(137.96,155.44) v2(137.96,154.45) v2(137.99,127.64) v2(138.03,134.2) v2(138.81,132.89) v2(139.22,127.48) v2(139.22,126.18) v2(139.35,156.59) v2(141.39,127.69) v2(141.36,126.42) v2(144.04,127.64) v2(144.03,126.4) v2(144.81,154.58) v2(144.83,156.43) v2(146.31,126.21) v2(146.74,127.93) v2(148.49,136.2) v2(148.44,127.59) v2(149.87,136.27) v2(150.88,126.19) v2(151.29,156.38) v2(153.09,156.36) v2(153.52,126.47) v2(153.93,127.52) v2(155.86,127.19) v2(155.86,125.97) v2(158.34,127.36) v2(159.89,125.96) v2(160.08,127.86) v2(162.59,141.14) v2(163.35,133.56) v2(164.59,125) v2(164.65,126.95) v2(168.39,126.94) v2(168.42,124.93) v2(172.76,127.57) v2(176.28,127.72) v2(196.06,144.16) v2(196.11,142.49) v2(196.74,141.04) v2(196.78,140.37) v2(196.76,138.2) v2(197.08,131.8) v2(197.11,130.21) v2(197.12,133.43) v2(197.29,138.75) v2(197.26,136.62) v2(197.21,135.01) v2(201.25,163) v2(203.12,131.58) v2(203.9,148.17) v2(203.99,160.22) v2(204.07,133.77) v2(204.13,162.8) v2(205,134.8) v2(206.4,160.25) v2(206.33,145.93) v2(206.36,133.94) v2(206.45,162.93) v2(206.45,131.23) v2(206.5,128.82) v2(207.24,165.33) v2(207.24,159.35) v2(207.26,149.3) v2(207.25,144.85) v2(207.25,129.59) v2(208.15,145.85) v2(208.28,162.62) v2(208.28,133.77) v2(208.75,158.57) v2(210.31,145.92) v2(210.39,131.21) v2(210.45,162.9) v2(210.44,160.2) v2(210.71,148.29) v2(210.78,133.96) v2(211.76,135.56) v2(215.8,142.62) v2(216.46,157.08) v2(216.69,158.07) v2(216.71,156.04) v2(216.81,153.84) v2(216.76,151.8) v2(216.79,144.37) v2(216.93,152.83) v2(216.97,146.56) v2(216.93,139.85) v2(216.97,137.21) v2(216.98,132.9) v2(217.03,131.83) v2(217.19,160.21) v2(217.19,149.72) v2(217.18,134.01) v2(217.15,129.56) v2(217.26,154.93) v2(217.22,150.72) v2(217.26,142.33) v2(217.59,163.32) v2(217.78,130.48) v2(218.6,142.37) v2(220.51,176.82) v2(221.28,176.82) v2(222.07,175.98) v2(222.13,177.7) v2(222.48,180.05) v2(222.75,167.06) v2(223.86,167.04) v2(224.19,210.44) v2(224.86,177.47) v2(224.84,173.52) v2(225.44,74.17) v2(225.72,176.82) v2(225.79,167.22) v2(226.14,72.45) v2(226.23,145.13) v2(226.32,158.46) v2(226.75,74.29) v2(226.99,166.55) v2(227.7,150.07) v2(227.7,136.07) v2(228.08,186.64) v2(228.4,142.38) v2(228.41,137.47) v2(228.68,186.62) v2(229.04,167.03) v2(229.11,155.67) v2(229.1,133.27) v2(229.11,131.86) v2(229.1,131.17) v2(229.1,130.47) v2(229.09,129.78) v2(229.29,186.61) v2(229.8,137.48) v2(229.93,186.62) v2(230.09,166.89) v2(230.5,143.07) v2(231.17,166.8) v2(231.2,138.86) v2(231.21,136.06) v2(231.9,144.47) v2(231.9,143.07) v2(231.9,140.27) v2(232.3,186.85) v2(232.61,152.88) v2(232.6,151.47) v2(233.27,166.88) v2(233.3,151.48) v2(233.3,150.07) v2(233.29,144.47) v2(233.3,138.88) v2(233.31,152.87) v2(234,138.86) v2(234.35,166.96) v2(234.7,150.78) v2(234.7,143.07) v2(234.7,141.67) v2(234.7,138.87) v2(234.7,137.47) v2(234.7,136.07) v2(235.37,167.22) v2(235.4,137.48) v2(235.74,174.55) v2(236.1,157.07) v2(236.1,152.86) v2(236.1,151.48) v2(236.09,146.57) v2(236.1,141.69) v2(236.1,137.47) v2(236.45,167.06) v2(237.5,155.67) v2(237.5,136.07) v2(237.52,147.97) v2(238.21,150.77) v2(238.2,138.88) v2(238.21,137.48) v2(238.2,135.38) v2(238.89,152.86) v2(238.9,152.17) v2(238.9,150.08) v2(238.9,136.08) v2(238.83,135.28) v2(238.91,131.87) v2(239.2,177.88) v2(239.59,166.88) v2(240.28,150.07) v2(240.3,144.47) v2(240.3,143.07) v2(240.42,131.27) v2(240.41,124.35) v2(240.45,122.98) v2(240.82,125.9) v2(241,154.97) v2(241,137.46) v2(241.4,125.96) v2(241.63,166.54) v2(241.71,157.76) v2(241.7,155.67) v2(241.7,154.28) v2(241.69,152.16) v2(241.7,150.07) v2(241.7,145.86) v2(241.7,143.07) v2(241.95,186.79) v2(241.93,123.46) v2(242.14,125.27) v2(242.4,155.67) v2(242.54,132.67) v2(242.64,186.77) v2(242.66,167.83) v2(243.09,155.67) v2(243.1,144.47) v2(243.1,143.07) v2(243.08,130.46) v2(243.29,186.79) v2(243.81,155.67) v2(243.81,136.07) v2(243.99,186.79) v2(245.2,155.67) v2(245.16,130.45) v2(245.9,155.67) v2(245.88,152.87) v2(245.89,144.46) v2(245.9,138.87) v2(246.28,121.1) v2(246.37,167.52) v2(246.59,155.66) v2(247.09,125.59) v2(247.3,155.67) v2(247.3,143.06) v2(247.28,133.26) v2(247.27,130.44) v2(248.19,126.12) v2(248.19,123.38) v2(248.54,167.68) v2(248.7,131.17) v2(248.86,127.14) v2(248.94,134.68) v2(248.99,125.63) v2(249.4,129.78) v2(249.38,124.55) v2(250.06,166.78) v2(250.81,152.86) v2(250.81,129.06) v2(250.85,131.24) v2(250.93,128.51) v2(251.01,177.55) v2(251.51,180) v2(251.51,133.27) v2(252.57,118.36) v2(253.88,132.74) v2(254.18,167.23) v2(254.72,176.82) v2(254.84,115.79) v2(256.77,135.12) v2(257.57,163.36) v2(257.7,144.42) v2(257.76,164.78) v2(257.74,142.42) v2(257.9,152.83) v2(257.91,140.22) v2(258.03,161.28) v2(258.02,141.31) v2(258.22,159.18) v2(258.21,147.69) v2(258.5,157.76) v2(258.75,160.67) v2(260.97,170.49) v2(263.25,150.6) v2(264.01,156.05) v2(264.32,159.3) v2(264.53,161.93) v2(264.54,147.27) v2(264.76,165.93) v2(265.53,165.94) v2(265.52,143.08) v2(266.65,159.47) v2(267.56,169.14) v2(267.75,164.33) v2(267.75,162.79) v2(267.78,147.34) v2(268.19,137.09) v2(268.6,161.9) v2(269.32,147.36) v2(270.82,159.27) v3(0.89,98.9) v3(0.89,73.11) v3(1.02,60.41) v3(1.15,23.97) v3(1.91,85.94) v3(2.66,44.68) v3(2.92,22.31) v3(2.92,7.71) v3(2.92,5.3) v3(2.92,3.01) v3(3.24,71.02) v3(3.35,60.42) v3(3.43,63.46) v3(3.55,1.3) v3(3.85,66.48) v3(4.19,100.8) v3(4.45,6.57) v3(4.45,4.15) v3(4.7,84.54) v3(4.64,73.29) v3(5.06,87.29) v3(5.12,102.19) v3(5.34,43.27) v3(5.46,22.31) v3(5.56,99.03) v3(5.67,70.28) v3(5.87,1.02) v3(5.98,85.15) v3(6.04,67.77) v3(6.23,9.61) v3(6.61,20.66) v3(6.73,100.8) v3(6.86,24.22) v3(7.18,73.17) v3(7.24,41.75) v3(7.5,43.14) v3(7.5,22.31) v3(7.66,102.19) v3(7.62,44.79) v3(8,9.61) v3(8.43,60.42) v3(8.64,20.66) v3(8.89,86.83) v3(8.89,84.93) v3(9.66,22.31) v3(9.91,23.84) v3(10.04,44.79) v3(10.2,102.19) v3(10.16,9.61) v3(10.42,41.75) v3(10.67,20.66) v3(11.69,22.31) v3(11.81,43.14) v3(12.07,60.29) v3(12.74,102.19) v3(12.83,44.67) v3(15.12,58.26) v3(15.12,46.95) v3(15.28,102.19) v3(15.77,1.02) v3(16.77,46.32) v3(17.82,102.19) v3(18.31,1.02) v3(20.36,102.19) v3(20.85,1.02) v3(22.9,102.19) v3(23.39,1.02) v3(23.9,7.49) v3(23.9,4.95) v3(23.9,2.41) v3(25.44,102.19) v3(25.42,6.22) v3(25.42,3.68) v3(25.93,1.02) v3(26.95,7.49) v3(26.95,4.95) v3(26.95,2.41) v3(27.98,102.19) v3(28.47,28.96) v3(28.47,26.42) v3(28.47,23.88) v3(28.47,21.34) v3(28.47,18.8) v3(28.47,16.26) v3(28.47,13.72) v3(28.47,11.18) v3(28.47,8.64) v3(28.47,6.1) v3(28.47,3.56) v3(28.47,1.02) v3(30.52,102.24) v3(33.06,102.24) v3(35.6,102.24) v3(38.14,102.24) v3(40.68,102.19) v3(42.93,40.37) v3(42.94,39.59) v3(43.22,102.19) v3(43.7,40.37) v3(43.7,39.59) v3(43.67,38.83) v3(45.76,102.19) v3(48.3,102.19) v3(50.7,72.33) v3(50.7,71.54) v3(50.84,102.19) v3(51.49,72.33) v3(51.51,71.54) v3(52.17,37.02) v3(52.3,71.51) v3(53.38,102.19) v3(54.71,37.02) v3(55.92,102.19) v3(57.25,37.02) v3(57.84,72.19) v3(58.46,102.19) v3(58.65,72.2) v3(59.18,38.36) v3(59.44,72.2) v3(61,102.19) v3(61.57,39.52) v3(62.57,40.87) v3(63.34,40.88) v3(63.54,102.2) v3(64.13,40.87) v3(64.11,39.52) v3(64.62,53.71) v3(64.89,40.87) v3(65.41,53.71) v3(65.65,40.87) v3(66.08,102.28) v3(66.22,53.71) v3(66.42,40.87) v3(66.65,39.52) v3(67.01,53.71) v3(67.16,57.52) v3(67.18,40.87) v3(67.95,57.49) v3(67.94,40.87) v3(68.61,102.51) v3(68.7,40.87) v3(68.76,57.53) v3(69.19,39.52) v3(69.49,40.87) v3(69.52,57.55) v3(70.31,57.5) v3(70.28,40.87) v3(70.72,53.71) v3(71.09,57.57) v3(71.07,54.42) v3(71.12,102.89) v3(71.73,39.52) v3(73.61,103.39) v3(74.27,39.52) v3(76.06,104.04) v3(76.81,39.52) v3(78.48,104.82) v3(79.38,42.76) v3(79.35,39.52) v3(79.41,44.67) v3(79.45,43.78) v3(80.14,42.76) v3(80.27,43.78) v3(80.49,44.71) v3(80.85,105.74) v3(80.9,42.76) v3(81.03,43.78) v3(81.61,45.3) v3(81.66,44.54) v3(81.66,42.76) v3(81.79,43.78) v3(81.89,39.52) v3(82.48,103.79) v3(82.43,42.76) v3(82.54,44.63) v3(82.55,43.78) v3(83.19,42.76) v3(83.32,43.78) v3(84.08,43.78) v3(84.3,102.02) v3(84.43,39.52) v3(86.7,101.19) v3(86.97,39.52) v3(89.23,101.44) v3(89.79,39.46) v3(91.45,112) v3(91.42,102.72) v3(92.66,109.77) v3(92.87,104.81) v3(93.33,113.71) v3(93.31,107.31) v3(94.06,39.51) v3(95.12,115.52) v3(96.8,117.42) v3(96.78,39.46) v3(98.39,119.4) v3(99.67,39.52) v3(99.86,121.47) v3(101.22,123.62) v3(102.46,125.83) v3(103.58,128.11) v3(104.58,130.45) v3(105.45,132.83) v3(106.2,135.26) v3(106.68,137.75) v3(107.14,140.42) v3(107.46,142.94) v3(107.84,145.27) v3(107.92,208.77) v3(107.92,206.23) v3(107.92,203.69) v3(107.92,201.15) v3(107.92,198.61) v3(107.92,196.07) v3(107.92,193.53) v3(107.92,190.99) v3(107.92,188.45) v3(107.92,185.91) v3(107.92,183.37) v3(107.92,180.83) v3(107.92,178.29) v3(107.92,175.75) v3(107.92,173.21) v3(107.92,170.67) v3(107.92,168.13) v3(107.92,165.59) v3(107.92,163.05) v3(107.92,160.51) v3(107.92,157.97) v3(107.92,155.43) v3(107.92,152.89) v3(107.92,150.35) v3(107.92,147.81) v3(108.39,218.88) v3(109.83,39.52) v3(110.93,218.88) v3(111.22,181.54) v3(111.98,181.52) v3(112.37,39.52) v3(112.63,193.41) v3(113.47,218.88) v3(113.41,194.4) v3(113.41,193.38) v3(114.18,194.4) v3(114.3,193.38) v3(114.94,194.4) v3(114.91,39.52) v3(115.07,193.38) v3(115.02,164.83) v3(115.54,162.8) v3(115.7,194.4) v3(115.7,45.07) v3(115.78,46.04) v3(115.83,193.38) v3(116.01,218.88) v3(116.77,46.04) v3(117.35,192.88) v3(117.45,39.52) v3(117.99,192.37) v3(118.55,218.88) v3(118.62,192.88) v3(118.88,209.39) v3(119,211.67) v3(120.09,38.57) v3(120.15,210.53) v3(121.09,218.88) v3(121.29,211.67) v3(121.29,209.39) v3(121.47,51.91) v3(121.47,51.07) v3(121.47,50.31) v3(121.47,49.54) v3(121.85,37.58) v3(122.3,193.38) v3(122.28,51.88) v3(122.28,51.04) v3(122.28,50.28) v3(122.28,49.52) v3(122.9,149.86) v3(122.9,149.09) v3(123.07,194.4) v3(123.07,193.38) v3(123.04,51.88) v3(123.04,51.04) v3(123.04,50.28) v3(123.04,49.52) v3(123.63,218.88) v3(123.66,149.86) v3(123.66,149.09) v3(123.8,51.88) v3(123.8,51.04) v3(123.8,50.28) v3(123.8,49.52) v3(123.83,194.4) v3(123.96,193.38) v3(124.38,37.52) v3(124.42,149.86) v3(124.42,149.09) v3(124.59,194.4) v3(124.72,193.38) v3(125.35,194.4) v3(125.48,193.38) v3(126.17,218.88) v3(127,192.88) v3(126.95,72.79) v3(126.92,37.52) v3(127.41,46.65) v3(127.64,192.37) v3(127.76,72.79) v3(128.17,46.67) v3(128.27,192.88) v3(128.71,218.88) v3(129.04,46.67) v3(129.29,212.66) v3(129.24,211.65) v3(129.31,210.83) v3(129.34,72.84) v3(129.46,37.52) v3(129.85,46.67) v3(130.2,212.69) v3(130.13,211.72) v3(130.15,210.86) v3(131.12,212.74) v3(131.25,218.88) v3(131.91,40.22) v3(131.96,193.38) v3(132,37.52) v3(132.16,212.71) v3(132.26,45.51) v3(132.31,44.69) v3(132.36,43.88) v3(132.67,40.25) v3(132.72,194.4) v3(132.72,193.38) v3(133.07,212.64) v3(133.02,45.53) v3(133.07,44.72) v3(133.12,43.9) v3(133.48,194.4) v3(133.61,193.38) v3(133.53,40.25) v3(133.79,218.88) v3(133.89,45.53) v3(133.99,212.64) v3(133.96,211.7) v3(133.99,210.66) v3(133.94,44.72) v3(133.99,43.9) v3(134.24,194.4) v3(134.37,193.38) v3(134.34,40.25) v3(134.44,72.75) v3(134.54,37.52) v3(134.7,45.53) v3(134.75,44.72) v3(134.8,43.9) v3(135,194.4) v3(135.13,193.38) v3(135.16,50.27) v3(135.61,52.97) v3(135.63,52.17) v3(136.33,218.88) v3(136.44,50.16) v3(136.44,49.4) v3(136.66,192.88) v3(136.84,52.14) v3(137.29,192.37) v3(137.25,50.14) v3(137.26,49.39) v3(137.93,192.88) v3(138.12,41.56) v3(138.16,40.73) v3(138.2,39.89) v3(138.23,39) v3(138.87,218.88) v3(138.94,41.54) v3(138.94,40.73) v3(138.97,39.91) v3(139,39.03) v3(139.62,37.52) v3(139.79,39.9) v3(139.82,39.13) v3(140.62,71.87) v3(140.64,39.9) v3(140.66,39.13) v3(141.41,218.88) v3(141.4,71.9) v3(141.42,40) v3(141.42,39.08) v3(141.61,193.38) v3(142.19,40.03) v3(142.19,39.11) v3(142.16,37.52) v3(142.37,194.4) v3(142.37,193.38) v3(143.06,40.02) v3(143.11,39.1) v3(143.13,194.4) v3(143.26,193.38) v3(143.89,194.4) v3(143.83,40.05) v3(143.88,39.13) v3(143.92,219.3) v3(144.02,193.38) v3(144.66,194.4) v3(144.7,37.52) v3(144.78,193.38) v3(144.72,40.06) v3(144.73,39.12) v3(145.47,48.38) v3(145.49,40.09) v3(145.5,39.15) v3(146.07,220.63) v3(146.31,192.88) v3(146.26,48.38) v3(146.34,40.11) v3(146.35,39.14) v3(146.94,192.37) v3(147.11,40.14) v3(147.12,39.17) v3(147.24,37.52) v3(147.58,192.88) v3(147.94,71.89) v3(148.61,220.63) v3(148.72,71.91) v3(149.78,37.52) v3(151.15,220.63) v3(151.26,193.38) v3(152.02,194.4) v3(152.02,193.38) v3(152.32,37.52) v3(152.78,194.4) v3(152.91,193.38) v3(153.55,194.4) v3(153.69,220.63) v3(153.67,193.38) v3(154.31,194.4) v3(154.44,193.38) v3(154.86,37.52) v3(155.15,52.9) v3(155.15,52.13) v3(155.15,50.61) v3(155.15,49.85) v3(155.15,49.09) v3(155.15,48.32) v3(155.15,47.56) v3(155.15,46.8) v3(155.15,46.04) v3(155.96,192.88) v3(155.98,53.68) v3(155.96,52.9) v3(155.96,52.13) v3(155.96,51.37) v3(155.96,50.61) v3(155.96,49.85) v3(155.96,49.09) v3(155.96,48.32) v3(155.96,47.56) v3(155.96,46.8) v3(155.96,46.04) v3(156.59,192.37) v3(156.75,53.68) v3(156.72,52.9) v3(156.72,52.13) v3(156.72,51.37) v3(156.72,50.61) v3(156.72,49.85) v3(156.72,49.09) v3(156.72,48.32) v3(156.72,47.56) v3(156.72,46.8) v3(156.72,46.04) v3(157.23,192.88) v3(157.4,37.52) v3(157.51,53.68) v3(157.48,52.9) v3(157.48,52.13) v3(157.48,51.37) v3(157.48,50.61) v3(157.48,49.85) v3(157.48,49.09) v3(157.48,48.32) v3(157.48,47.56) v3(157.48,46.8) v3(157.48,46.04) v3(158.27,53.68) v3(158.25,52.9) v3(158.25,52.13) v3(158.25,50.61) v3(158.25,49.85) v3(158.25,49.09) v3(158.25,48.32) v3(158.25,47.56) v3(158.25,46.8) v3(158.25,46.04) v3(158.77,220.63) v3(159.94,37.52) v3(160.91,193.38) v3(161.31,220.63) v3(161.67,194.4) v3(161.67,193.38) v3(162.44,194.4) v3(162.48,37.52) v3(162.56,193.38) v3(163.2,194.4) v3(163.33,193.38) v3(163.85,220.63) v3(163.96,194.4) v3(164.09,193.38) v3(164.76,41.76) v3(164.84,40.87) v3(164.83,39.98) v3(164.9,39.1) v3(165.02,37.52) v3(165.6,41.76) v3(165.68,40.87) v3(165.66,39.98) v3(165.74,192.85) v3(165.74,39.1) v3(165.88,182.7) v3(165.93,183.55) v3(166.06,187.24) v3(166.05,186.3) v3(166.03,185.35) v3(166.03,184.46) v3(166.12,192.06) v3(166.39,220.63) v3(166.6,199.24) v3(166.58,192.77) v3(166.62,39.99) v3(166.7,39.11) v3(166.78,47.77) v3(166.89,183.54) v3(166.84,182.68) v3(167.01,186.28) v3(166.99,185.34) v3(166.98,184.44) v3(167.04,189.83) v3(167.04,189) v3(167.06,188.13) v3(167.01,187.23) v3(167.4,180.3) v3(167.39,179.41) v3(167.35,178.64) v3(167.36,177.88) v3(167.36,177.11) v3(167.46,39.99) v3(167.57,47.77) v3(167.53,39.11) v3(167.56,37.52) v3(168,185.36) v3(168.03,187.26) v3(168.02,186.31) v3(168.29,39.97) v3(168.34,178.78) v3(168.37,39.08) v3(168.93,220.63) v3(169.12,39.95) v3(169.17,39.08) v3(169.8,197.57) v3(169.96,39.95) v3(170.01,39.08) v3(170.03,196.76) v3(170.06,195.84) v3(170.1,37.52) v3(170.8,39.92) v3(170.89,196.81) v3(170.85,39.06) v3(170.92,197.62) v3(170.92,195.89) v3(171.47,220.63) v3(171.73,39.92) v3(171.73,39.08) v3(171.94,197.49) v3(171.96,196.65) v3(171.99,195.84) v3(172.64,40.73) v3(172.61,39.96) v3(172.66,39.08) v3(172.64,37.52) v3(173.46,39.81) v3(173.46,38.97) v3(173.58,41.54) v3(173.58,40.7) v3(173.64,184.77) v3(173.79,187.23) v3(173.79,186.27) v3(173.76,185.52) v3(174.01,220.63) v3(174.46,184.63) v3(174.55,194.78) v3(174.53,186.96) v3(174.53,185.38) v3(174.63,186.2) v3(174.88,213.32) v3(174.88,211.8) v3(175.19,178.74) v3(175.19,52.13) v3(175.18,37.52) v3(175.21,184.67) v3(175.22,180.71) v3(175.39,194.76) v3(175.42,186.17) v3(175.42,185.41) v3(175.67,41.11) v3(175.67,40.3) v3(175.69,39.49) v3(175.94,178.74) v3(175.95,52.13) v3(176.02,180.79) v3(176.53,217.89) v3(176.53,213.96) v3(176.53,211.42) v3(176.53,209.13) v3(176.71,52.13) v3(177.72,37.52) v3(179.07,209.39) v3(180.26,37.52) v3(182.12,209.39) v3(182.8,37.52) v3(184.66,209.39) v3(185.34,37.52) v3(187.88,37.52) v3(187.96,209.39) v3(190.42,37.52) v3(191.14,209.13) v3(191.27,213.45) v3(191.77,210.4) v3(192.96,37.52) v3(193.77,220.63) v3(195.5,37.52) v3(195.69,220.78) v3(198.04,37.52) v3(198.25,220.83) v3(200.58,37.52) v3(201.39,220.63) v3(201.38,188.67) v3(202.44,97.88) v3(203.05,98.59) v3(203.12,37.52) v3(204.47,218.02) v3(204.47,213.96) v3(204.47,211.42) v3(204.6,209) v3(204.65,99.05) v3(205.2,99.58) v3(205.66,37.52) v3(205.77,100.14) v3(206.89,209.39) v3(208.2,37.52) v3(210.06,209.39) v3(210.74,37.52) v3(210.84,190.19) v3(212.6,209.39) v3(213.28,37.52) v3(215.9,209.39) v3(215.82,37.52) v3(216.61,103.55) v3(216.61,102.79) v3(217.5,103.55) v3(217.5,102.79) v3(217.54,36.03) v3(218.24,93.56) v3(218.39,103.55) v3(218.39,102.79) v3(218.65,92.8) v3(219.08,209) v3(219.03,93.56) v3(219.28,103.55) v3(219.28,102.79) v3(219.33,217.64) v3(219.33,213.45) v3(219.43,92.8) v3(219.73,90.38) v3(219.84,210.4) v3(219.81,93.56) v3(220.17,103.55) v3(220.17,102.79) v3(220.21,35.02) v3(220.22,92.8) v3(220.22,91.02) v3(220.22,89.75) v3(220.48,36.79) v3(220.6,93.56) v3(220.6,92.04) v3(221.01,92.8) v3(220.98,38.32) v3(221.06,103.55) v3(221.06,102.79) v3(221.39,93.56) v3(221.39,92.04) v3(221.8,92.8) v3(221.94,103.55) v3(221.94,102.79) v3(222.18,93.56) v3(222.18,92.04) v3(222.58,92.8) v3(222.75,220.63) v3(222.76,39.21) v3(222.83,103.55) v3(222.83,102.79) v3(222.96,93.56) v3(223.72,103.55) v3(223.72,102.79) v3(224.41,38.44) v3(224.92,36.79) v3(225.29,220.63) v3(225.29,35.02) v3(225.94,94.58) v3(226.25,103.4) v3(226.25,102.64) v3(227.14,103.4) v3(227.14,102.64) v3(227.83,220.63) v3(227.83,35.02) v3(228.03,103.4) v3(228.03,102.64) v3(228.02,93.56) v3(228.46,212.9) v3(228.45,211.98) v3(228.45,211.07) v3(228.43,92.8) v3(228.81,93.56) v3(228.92,103.4) v3(228.92,102.64) v3(229.21,92.8) v3(229.36,212.91) v3(229.39,211.98) v3(229.41,211.08) v3(229.51,90.38) v3(229.59,93.56) v3(229.81,103.4) v3(229.81,102.64) v3(230,92.8) v3(230,89.75) v3(230.05,91) v3(230.28,212.89) v3(230.29,211.97) v3(230.37,220.63) v3(230.31,211.1) v3(230.38,93.56) v3(230.38,92.04) v3(230.37,35.02) v3(230.7,103.4) v3(230.7,102.64) v3(230.79,92.8) v3(231.17,93.56) v3(231.17,92.04) v3(231.59,103.4) v3(231.59,102.64) v3(231.57,92.8) v3(231.96,93.56) v3(231.96,92.04) v3(232.36,92.8) v3(232.48,103.4) v3(232.48,102.64) v3(232.74,93.56) v3(232.91,220.63) v3(232.91,35.02) v3(233.36,103.4) v3(233.36,102.64) v3(234.23,85.13) v3(234.27,84.32) v3(234.32,83.53) v3(235.11,85.13) v3(235.06,84.34) v3(235.07,83.5) v3(235.02,82.73) v3(235.45,220.63) v3(235.45,35.02) v3(235.8,82.66) v3(235.77,81.89) v3(235.84,84.32) v3(235.84,83.5) v3(235.97,85.15) v3(236.6,84.32) v3(236.61,83.5) v3(236.59,82.67) v3(236.55,81.85) v3(236.73,85.15) v3(236.86,103.21) v3(236.86,102.45) v3(237.49,85.15) v3(237.75,103.21) v3(237.75,102.45) v3(237.8,93.56) v3(237.99,35.02) v3(238.2,92.8) v3(238.26,85.15) v3(238.59,93.56) v3(238.64,103.21) v3(238.64,102.45) v3(238.99,92.8) v3(239.02,85.2) v3(239.29,90.38) v3(239.37,93.56) v3(239.53,103.21) v3(239.53,102.45) v3(239.78,92.8) v3(239.78,91.05) v3(239.78,89.75) v3(239.78,85.25) v3(240.08,81.98) v3(240.16,93.56) v3(240.16,92.04) v3(240.41,84.77) v3(240.41,103.21) v3(240.41,102.45) v3(240.53,220.63) v3(240.57,92.8) v3(240.53,35.02) v3(240.95,93.56) v3(240.95,92.04) v3(241.3,103.21) v3(241.3,102.45) v3(241.35,92.8) v3(241.73,93.56) v3(241.73,92.04) v3(242.19,103.21) v3(242.19,102.45) v3(242.14,92.8) v3(242.35,199.32) v3(242.35,198.53) v3(242.52,93.56) v3(243.07,220.63) v3(243.08,103.21) v3(243.08,102.45) v3(243.07,35.02) v3(243.13,199.32) v3(243.13,198.53) v3(243.92,199.32) v3(243.92,198.53) v3(243.97,103.21) v3(243.97,102.45) v3(244.05,43.8) v3(244.17,39.21) v3(244.22,39.98) v3(244.46,188.96) v3(244.45,44.49) v3(244.45,43.17) v3(244.71,199.32) v3(244.71,198.53) v3(244.83,38.82) v3(245.26,188.97) v3(245.5,199.32) v3(245.5,198.53) v3(245.49,94.58) v3(245.61,220.63) v3(245.6,38.8) v3(245.61,35.02) v3(246.05,188.99) v3(246.28,199.32) v3(246.28,198.53) v3(246.64,103.21) v3(246.64,102.45) v3(246.81,188.98) v3(247.53,103.21) v3(247.53,102.45) v3(247.58,93.56) v3(247.62,188.98) v3(247.82,38.87) v3(247.98,92.8) v3(248.15,220.63) v3(248.15,35.02) v3(248.25,202.47) v3(248.25,201.66) v3(248.25,200.87) v3(248.25,200.08) v3(248.39,188.98) v3(248.36,93.56) v3(248.42,103.21) v3(248.42,102.45) v3(248.6,38.87) v3(248.77,92.8) v3(249.04,202.47) v3(249.04,201.66) v3(249.04,200.87) v3(249.04,200.08) v3(249.06,90.38) v3(249.15,93.56) v3(249.3,103.21) v3(249.3,102.45) v3(249.56,92.8) v3(249.56,91.05) v3(249.56,89.75) v3(249.83,202.47) v3(249.83,201.66) v3(249.83,200.87) v3(249.83,200.08) v3(249.94,93.56) v3(249.94,92.04) v3(250.19,103.21) v3(250.19,102.45) v3(250.35,92.8) v3(250.69,220.63) v3(250.61,202.47) v3(250.61,201.66) v3(250.61,200.87) v3(250.61,200.08) v3(250.69,35.02) v3(250.73,93.56) v3(250.73,92.04) v3(251.08,103.21) v3(251.08,102.45) v3(251.13,92.8) v3(251.4,202.47) v3(251.4,201.66) v3(251.4,200.87) v3(251.4,200.08) v3(251.51,93.56) v3(251.51,92.04) v3(251.97,103.21) v3(251.97,102.45) v3(251.92,92.8) v3(252.19,202.47) v3(252.19,201.66) v3(252.19,200.87) v3(252.19,200.08) v3(252.3,93.56) v3(252.53,219.01) v3(252.86,103.21) v3(252.86,102.45) v3(252.98,201.66) v3(252.98,200.87) v3(252.98,200.08) v3(253.23,35.02) v3(253.76,200.87) v3(253.76,200.08) v3(253.75,103.21) v3(253.75,102.45) v3(255.07,219.01) v3(255.27,94.58) v3(255.77,35.02) v3(256.39,61.4) v3(256.55,60.66) v3(256.81,103.23) v3(256.81,102.46) v3(257.36,93.56) v3(257.61,219.01) v3(257.7,103.23) v3(257.7,102.46) v3(257.76,92.8) v3(258.14,93.56) v3(258.31,35.02) v3(258.59,103.23) v3(258.59,102.46) v3(258.55,92.8) v3(258.84,90.38) v3(258.93,93.56) v3(259.34,92.8) v3(259.39,91.05) v3(259.34,89.75) v3(259.48,103.23) v3(259.48,102.46) v3(259.72,93.56) v3(259.72,92.04) v3(260.15,219.01) v3(260.12,92.8) v3(260.37,103.23) v3(260.37,102.46) v3(260.51,93.56) v3(260.51,92.04) v3(260.85,35.02) v3(260.91,92.8) v3(261.25,103.23) v3(261.25,102.46) v3(261.29,93.56) v3(261.29,92.04) v3(261.7,92.8) v3(262.08,93.56) v3(262.14,103.23) v3(262.14,102.46) v3(262.69,219.01) v3(262.94,62.23) v3(263.03,103.23) v3(263.03,102.46) v3(263.3,66.1) v3(263.39,35.02) v3(263.73,62.23) v3(263.92,103.23) v3(263.92,102.46) v3(264.09,66.1) v3(265.05,94.58) v3(265.93,35.02) v3(266.59,103.23) v3(266.59,102.46) v3(267.01,63.13) v3(267.13,93.56) v3(267.48,103.23) v3(267.48,102.46) v3(267.54,92.8) v3(267.92,93.56) v3(268.37,103.23) v3(268.37,102.46) v3(268.33,92.8) v3(268.47,35.02) v3(268.71,93.56) v3(268.62,90.38) v3(269.12,92.8) v3(269.17,91.05) v3(269.12,89.75) v3(269.26,103.23) v3(269.26,102.46) v3(269.5,93.56) v3(269.5,92.04) v3(269.9,92.8) v3(270.14,103.23) v3(270.14,102.46) v3(270.28,93.56) v3(270.28,92.04) v3(270.69,92.8) v3(271.01,35.02) v3(271.03,103.23) v3(271.03,102.46) v3(271.07,93.56) v3(271.07,92.04) v3(271.48,92.8) v3(271.86,93.56) v3(271.92,103.23) v3(271.92,102.46) v3(272.8,36.67) v3(272.8,35.01) v3(272.81,103.23) v3(272.81,102.46) v3(273.18,38.19) v3(273.7,103.23) v3(273.7,102.46) v3(274.58,39.08) v3(276.29,103.23) v3(276.29,102.46) v3(276.23,38.82) v3(276.99,37.68) v3(277.18,103.23) v3(277.18,102.46) v3(277.12,93.87) v3(277.12,36.28) v3(277.12,35.01) v3(277.52,93.1) v3(277.9,93.87) v3(278.07,103.23) v3(278.07,102.46) v3(278.31,93.1) v3(278.69,93.87) v3(278.66,90.64) v3(278.63,35.02) v3(278.96,103.23) v3(278.96,102.46) v3(279.1,93.1) v3(279.25,91.3) v3(279.28,89.96) v3(279.48,93.87) v3(279.48,92.34) v3(279.85,103.23) v3(279.85,102.46) v3(279.89,93.1) v3(280.27,93.87) v3(280.27,92.34) v3(280.47,218.88) v3(280.67,93.1) v3(280.74,103.23) v3(280.74,102.46) v3(281.05,93.87) v3(281.05,92.34) v3(281.17,35.02) v3(281.46,93.1) v3(281.63,103.23) v3(281.63,102.46) v3(281.84,93.87) v3(282.51,103.23) v3(282.51,102.46) v3(283.01,218.88) v3(283.71,35.02) v3(284.74,128.33) v3(284.74,127.56) v3(285.55,218.88) v3(285.52,128.33) v3(285.54,127.55) v3(285.62,103.24) v3(285.62,102.48) v3(286.3,127.55) v3(286.25,35.02) v3(286.31,128.33) v3(286.51,103.24) v3(286.51,102.48) v3(286.77,93.87) v3(287.18,93.1) v3(287.4,103.24) v3(287.4,102.48) v3(287.56,93.87) v3(287.86,218.2) v3(287.89,209.13) v3(287.88,207.73) v3(287.88,205.19) v3(287.88,202.65) v3(287.88,200.11) v3(287.88,197.57) v3(287.88,195.03) v3(287.88,192.49) v3(287.88,189.95) v3(287.88,187.41) v3(287.88,184.87) v3(287.88,182.33) v3(287.88,179.79) v3(287.88,177.25) v3(287.88,174.71) v3(287.88,172.17) v3(287.88,169.63) v3(287.88,167.09) v3(287.88,164.55) v3(287.88,162.01) v3(287.88,159.47) v3(287.88,156.93) v3(287.94,155.18) v3(287.92,144.23) v3(287.96,93.1) v3(287.94,91.35) v3(287.99,90.13) v3(288.1,141.7) v3(288.29,103.24) v3(288.29,102.48) v3(288.34,93.87) v3(288.42,139.18) v3(288.6,90.69) v3(288.75,93.1) v3(288.79,35.02) v3(288.88,136.68) v3(289.18,103.24) v3(289.18,102.48) v3(289.13,93.87) v3(289.13,92.34) v3(289.18,91.3) v3(289.18,90.08) v3(289.47,134.21) v3(289.54,93.1) v3(289.58,52.67) v3(289.58,50.13) v3(289.58,47.59) v3(289.58,45.05) v3(289.58,42.51) v3(289.58,39.97) v3(289.58,37.43) v3(289.92,93.87) v3(289.92,92.34) v3(290.06,103.24) v3(290.06,102.48) v3(290.19,131.78) v3(290.12,55.15) v3(290.33,93.1) v3(290.71,93.87) v3(290.71,92.34) v3(290.95,103.24) v3(290.95,102.48) v3(291.05,129.39) v3(291.11,93.1) v3(291.47,93.87) v3(291.84,103.24) v3(291.84,102.48) v3(291.91,56.95) v3(292.04,127.05) v3(293.16,124.76) v3(294.4,122.55) v3(295.76,120.4) v3(296.98,118.89) v3(298.15,100.32) v3(298.15,99.53) v3(298.15,98.74) v3(298.15,97.96) v3(298.13,58.06) v3(301.04,114.11) v3(301.68,101.61) v3(301.68,100.83) v3(302.31,112.66) v3(302.47,101.61) v3(302.47,100.83) v3(302.57,108.09) v3(302.68,105.55) v3(303.54,110.44) v3(303.84,103.29) v3(308.31,101.15) v3(310.8,101.66) v3(312.85,103.16) v3(315.24,104.02) v3(317.16,103.26) v3(319.98,102.2) v3(322.38,101.37) v3(322.38,98.83) v3(322.38,96.29) v3(322.38,93.75) v3(322.38,81.05) v3(322.38,78.51) v3(322.38,75.97) v3(322.38,73.43) v3(322.38,70.89) v3(322.54,91.21) v3(322.54,88.67) v3(322.54,86.13) v3(322.54,83.59)
