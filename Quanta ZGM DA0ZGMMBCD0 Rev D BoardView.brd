# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
R287  *10K_1%_2  [R0201]  72.65 80.61 270 top
R288  *Short_0201  [S0201]  217.94 80.61 270 top
R289  *Short_0603  [S0603]  297.56 81.42 0 top
R290  *20K_1%_2  [R0201]  215.29 80.38 270 top
R291  *20K_1%_2  [R0201]  213.85 80.35 90 top
R293  1K_1%_2  [R0201]  288.04 80.48 0 top
R294  240_1%_2  [R0201]  155.71 80.1 0 top
R295  *Short_0805  [S0805]  271.57 79.91 180 top
R296  10K_1%_2  [R0201]  185.57 79.82 0 top
R297  10K_1%_2  [R0201]  186.78 79.81 180 top
R298  *10K_1%_2  [R0201]  187.79 79.8 180 top
R299  100K_1%_2  [R0201]  27.18 79.72 180 top
R300  *2M_1%_2  [R0201]  14.85 79.62 270 top
R301  100K_1%_2  [R0201]  217.94 79.59 270 top
R302  100K_1%_2  [R0201]  296.29 80.23 180 top
R303  *Short_0201  [S0201]  33.84 79.46 270 top
R304  *Short_0201  [S0201]  34.67 79.46 270 top
R305  *Short_0201  [S0201]  35.44 79.46 270 top
R306  *Short_0201  [S0201]  36.2 79.46 270 top
R307  *10K_1%_2  [R0201]  63.12 79.21 270 top
R308  *10K_1%_2  [R0201]  155.71 79.21 180 top
R309  *100K_1%_2  [R0201]  221.08 79.11 0 top
R310  *0_5%_2  [R0201]  222.1 79.11 0 top
R311  10K_1%_2  [R0201]  71.89 79.08 270 top
R312  *10K_1%_2  [R0201]  72.65 79.08 90 top
R313  *10K_1%_2  [R0201]  27.18 78.96 0 top
R314  *10K_1%_2  [R0201]  25.78 78.93 180 top
R315  10K_1%_2  [R0201]  215.27 78.7 90 top
R316  *10K_1%_2  [R0201]  183.73 78.84 90 top
R317  *0_5%_4  [R0402]  176.03 78.73 90 top
R318  *Short_0402  [S0402]  178.46 78.73 270 top
R319  2.2_5%_6  [R0603]  180.39 78.45 0 top
R320  75K_1%_2  [R0201]  221.1 78.37 180 top
R321  10K_1%_2  [R0201]  222.11 78.37 0 top
R322  *Short_0603  [S0603]  303.1 78.27 270 top
R323  *0_5%_2  [R0201]  25.78 78.19 180 top
R324  *Short_0201  [S0201]  27.18 78.19 0 top
R325  100K_1%_2  [R0201]  219.73 78.17 90 top
R326  *1M_1%_2  [R0201]  34.93 78.07 180 top
R327  *1M_1%_2  [R0201]  35.94 78.07 0 top
R328  10K_1%_2  [R0201]  216.67 77.81 90 top
R329  10K_1%_2  [R0201]  217.43 77.81 90 top
R330  *Short_0603  [S0603]  294.21 77.59 180 top
R331  10K_1%_2  [R0201]  71.89 77.56 90 top
R332  *10K_1%_2  [R0201]  72.65 77.56 270 top
R333  33_1%_2  [R0201]  171.45 77.31 270 top
R334  4.7K_1%_2  [R0201]  174.37 77.31 90 top
R335  4.7K_1%_2  [R0201]  175.14 77.31 90 top
R336  4.7K_1%_2  [R0201]  176.03 77.31 90 top
R337  4.7K_1%_2  [R0201]  178.18 77.26 0 top
R338  *0_5%_4  [R0402]  179.94 77.23 0 top
R339  *Short_0805  [S0805]  97.75 77.17 0 top
R340  100K_1%_2  [R0201]  300.78 77.07 180 top
R341  **33K_1%_2  [R0201]  15.75 76.59 90 top
R342  **33K_1%_2  [R0201]  16.51 76.59 270 top
R343  *10K_1%_2  [R0201]  167.01 76.54 90 top
R344  *0_5%_2  [R0201]  170.69 76.54 270 top
R345  10K_1%_2  [R0201]  218.13 76.44 0 top
R346  *10K_1%_2  [R0201]  222.09 76.35 0 top
R347  2.2_5%_2  [R0201]  28.83 76.29 180 top
R348  4.7K_1%_2  [R0201]  183.51 76.28 90 top
R349  TPM@2.2_5%_6  [R0603]  237.22 76.13 180 top
R350  221K_1%_2  [R0201]  11.81 75.78 270 top
R351  2.2_5%_2  [R0201]  28.83 75.4 180 top
R352  *Short_0201  [S0201]  222.34 75.32 180 top
R353  33_1%_2  [R0201]  167.01 75.27 270 top
R354  2ADP@10K_1%_2  [R0201]  170.72 75.27 90 top
R355  100K_1%_2  [R0201]  172.6 75.27 90 top
R356  *Short_0201  [S0201]  176.03 75.27 90 top
R357  *Short_0201  [S0201]  176.79 75.27 90 top
R358  *100K_1%_2  [R0201]  177.73 75.27 90 top
R359  *10K_1%_2  [R0201]  179.45 75.27 90 top
R360  *10K_1%_2  [R0201]  180.22 75.27 90 top
R361  10K_1%_2  [R0201]  180.98 75.27 90 top
R362  *Short_0201  [S0201]  181.74 75.27 90 top
R363  *Short_0201  [S0201]  183.52 75.27 270 top
R364  33_1%_2  [R0201]  173.57 75.27 270 top
R365  10K_1%_2  [R0201]  282.99 75.16 270 top
R366  Debug@0_5%_4  [R0402]  280.47 74.97 180 top
R367  TPM@10K_1%_2  [R0201]  240.02 74.92 0 top
R368  TPM@10K_1%_2  [R0201]  242.56 74.92 180 top
R369  *10K_1%_2  [R0201]  218.78 74.86 0 top
R370  221K_1%_2  [R0201]  11.81 74.71 90 top
R371  *Short_0201  [S0201]  222.34 74.55 180 top
R372  *SUB@0_5%_4  [R0402]  291.8 74.54 0 top
R373  SUB@10K_1%_2  [R0201]  290.56 74.53 90 top
R374  4.7K_1%_2  [R0201]  159.62 74.49 270 top
R375  10K_1%_2  [R0201]  216.78 74.38 0 top
R376  100K_1%_2  [R0201]  308.5 74.32 270 top
R377  SUB@2.2K_1%_2  [R0201]  293.6 74.31 180 top
R378  SUB@2.2K_1%_2  [R0201]  294.6 74.31 0 top
R379  TPM@10K_1%_2  [R0201]  236.08 74.29 0 top
R380  2.2_5%_2  [R0201]  28.83 74.26 180 top
R381  Debug@0_5%_4  [R0402]  280.47 73.95 180 top
R382  *TPM@Short_0402  [S0402]  242.96 73.93 0 top
R383  10K_1%_2  [R0201]  303.62 73.93 180 top
R384  *TPM@Short_0201  [S0201]  238.75 73.91 270 top
R385  *TPM@Short_0402  [S0402]  240.02 73.91 0 top
R386  *TPM@Short_0201  [S0201]  241.29 73.91 270 top
R387  100K_1%_2  [R0201]  308.1 73.47 0 top
R388  *TPM@Short_0201  [S0201]  236.08 73.4 0 top
R389  2.2_5%_2  [R0201]  28.83 73.37 180 top
R390  *Short_0201  [S0201]  304.48 73.36 270 top
R391  100K_1%_2  [R0201]  155.81 73.29 180 top
R392  10K_1%_2  [R0201]  283.21 72.99 270 top
R393  100K_1%_2  [R0201]  217.2 72.98 90 top
R394  1K_1%_2  [R0201]  320.93 72.84 270 top
R395  4.7K_1%_2  [R0201]  319.62 72.73 0 top
R396  4.7K_1%_2  [R0201]  318.3 72.21 270 top
R397  2.2_5%_2  [R0201]  28.83 72.1 180 top
R398  *10K_1%_2  [R0201]  305.25 72.09 90 top
R399  *0_5%_2  [R0201]  167.67 72.07 180 top
R400  100K_1%_2  [R0201]  151.42 72.03 270 top
R401  1K_1%_2  [R0201]  320.83 71.94 0 top
R402  15K_1%_2  [R0201]  155.81 71.85 180 top
R403  10K_1%_2  [R0201]  268.56 71.83 180 top
R404  *SUB@10K_1%_2  [R0201]  288.55 72.73 0 top
R405  100K_1%_2  [R0201]  217.22 71.65 0 top
R406  33_1%_2  [R0201]  165.9 71.59 180 top
R407  200K_1%_2  [R0201]  307.96 71.49 270 top
R408  *0_5%_6  [R0603]  270.9 71.36 180 top
R409  *10K_1%_2  [R0201]  306.52 71.32 0 top
R410  2.2_5%_2  [R0201]  28.83 71.21 180 top
R411  *20K_1%_2  [R0201]  220.12 71.13 270 top
R412  4.7K_1%_2  [R0201]  187.07 71.11 0 top
R413  2.2_5%_6  [R0603]  163.03 71.01 180 top
R414  100K_1%_2  [R0201]  156.55 71.01 0 top
R415  *100K_1%_2  [R0201]  219.26 70.99 180 top
R416  100K_1%_2  [R0201]  268.56 70.82 180 top
R417  SUB@33_1%_2  [R0201]  292.36 68.8 0 top
R418  *SUB@0_5%_4  [R0402]  288.55 71.84 180 top
R419  100K_1%_2  [R0201]  308.36 70.63 180 top
R420  *Short_0402  [S0402]  316.46 70.63 90 top
R421  SUB@33_1%_2  [R0201]  294.82 70.63 270 top
R422  SUB@33_1%_2  [R0201]  295.54 70.63 270 top
R423  SUB@33_1%_2  [R0201]  296.25 70.63 270 top
R424  SUB@33_1%_2  [R0201]  294.11 70.62 270 top
R425  10K_1%_2  [R0201]  306.52 70.6 0 top
R426  4.7K_1%_2  [R0201]  187.07 70.35 0 top
R427  *Short_0805  [S0805]  96.09 70.34 270 top
R428  2.2_5%_2  [R0201]  28.83 70.07 180 top
R429  *Short_0201  [S0201]  165.71 70.04 180 top
R430  *Short_0201  [S0201]  164.72 70.02 270 top
R431  *0_5%_6  [R0603]  270.89 69.94 180 top
R432  *0_5%_2  [R0201]  226.19 69.89 270 top
R433  *20K_1%_2  [R0201]  220.76 69.79 90 top
R434  *0_5%_2  [R0201]  319.05 69.56 270 top
R435  *0_5%_2  [R0201]  317.61 69.56 270 top
R436  *2.2_5%_6  [R0603]  163.03 69.49 180 top
R437  *100K_1%_2  [R0201]  220.02 69.46 270 top
R438  2.2_5%_6  [R0603]  189.08 69.38 0 top
R439  2.2_5%_2  [R0201]  28.83 69.18 180 top
R440  *22_5%_2  [R0201]  163.53 68.42 0 top
R441  *TPM@0_5%_4  [R0402]  234.56 68.32 270 top
R442  *10K_1%_2  [R0201]  29.34 67.91 90 top
R443  *2.2K_1%_2  [R0201]  30.23 67.91 270 top
R444  10K_1%_2  [R0201]  31.12 67.91 270 top
R445  *2.2K_1%_2  [R0201]  32.26 67.91 270 top
R446  *2.2K_1%_2  [R0201]  33.15 67.91 270 top
R447  *10K_1%_2  [R0201]  34.04 67.91 90 top
R448  10K_1%_2  [R0201]  34.93 67.91 90 top
R449  *10K_1%_2  [R0201]  35.82 67.91 90 top
R450  *10K_1%_2  [R0201]  36.71 67.91 90 top
R451  10K_1%_2  [R0201]  37.98 67.91 90 top
R452  100_1%_2  [R0201]  38.74 67.91 270 top
R453  10K_1%_2  [R0201]  39.5 67.91 90 top
R454  10K_1%_2  [R0201]  319.89 67.78 180 top
R455  *Short_0201  [S0201]  185.68 67.67 180 top
R456  *4.7K_1%_2  [R0201]  23.18 67.23 0 top
R457  22_5%_2  [R0201]  307.63 67.54 0 top
R458  100K_1%_2  [R0201]  163.45 67.4 180 top
R459  *10K_1%_2  [R0201]  160.07 67.15 0 top
R460  *0_5%_2  [R0201]  223.88 67.04 270 top
R461  **1K_1%_2  [R0201]  224.62 67.04 270 top
R462  4.7K_1%_2  [R0201]  14.63 66.84 180 top
R463  *71.5K_1%_2  [R0201]  268.79 66.69 90 top
R464  22_5%_2  [R0201]  307.77 66.64 90 top
R465  *4.7K_1%_2  [R0201]  23.4 66.46 0 top
R466  10K_1%_2  [R0201]  36.55 66.39 90 top
R467  *10K_1%_2  [R0201]  29.34 66.38 270 top
R468  *10K_1%_2  [R0201]  30.36 66.38 270 top
R469  *10K_1%_2  [R0201]  32.26 66.38 270 top
R470  *10K_1%_2  [R0201]  34.93 66.38 270 top
R471  10K_1%_2  [R0201]  37.34 66.38 270 top
R472  100K_1%_2  [R0201]  160.07 66.38 180 top
R473  *10K_1%_2  [R0201]  35.74 66.38 270 top
R474  33_1%_2  [R0201]  188.62 66.37 180 top
R475  10K_1%_2  [R0201]  33.16 66.35 90 top
R476  *10K_1%_2  [R0201]  34.05 66.35 270 top
R477  *Short_0201  [S0201]  163.55 66.29 0 top
R478  **2K_1%_2  [R0201]  224.39 66.18 180 top
R479  *4.7K_1%_2  [R0201]  14.63 65.95 0 top
R480  *100K_1%_2  [R0201]  217.03 65.8 90 top
R481  *Short_0402  [S0402]  210.33 65.64 270 top
R482  *0_5%_2  [R0201]  273.69 65.49 270 top
R483  *Short_0201  [S0201]  163.58 65.37 0 top
R484  *Short_0201  [S0201]  188.62 65.35 180 top
R485  4.7K_1%_2  [R0201]  24.03 65.06 270 top
R486  *4.7K_1%_2  [R0201]  14.63 64.94 180 top
R487  *100K_1%_2  [R0201]  217.03 64.81 270 top
R488  *0_5%_2  [R0201]  165.6 64.52 180 top
R489  100K_1%_2  [R0201]  163.22 64.5 90 top
R490  *TPM@Short_0402  [S0402]  236.86 64.22 180 top
R491  *0_5%_2  [R0201]  273.51 63.68 270 top
R492  *4.7K_1%_2  [R0201]  220.32 63.56 0 top
R493  *Short_0402  [S0402]  163.6 63.51 0 top
R494  4.7K_1%_2  [R0201]  24.03 63.34 90 top
R495  *Short_0201  [S0201]  100.56 63.21 0 top
R496  *4.7K_1%_2  [R0201]  22.89 63.16 90 top
R497  10K_1%_2  [R0201]  14.84 63.06 180 top
R498  *0_5%_4  [R0402]  198.44 63 180 top
R499  *10K_1%_2  [R0201]  201.93 62.96 180 top
R500  75K_1%_2  [R0201]  268.74 62.95 270 top
R501  *100K_1%_2  [R0201]  219.83 62.85 0 top
R502  10K_1%_2  [R0201]  165.66 62.83 270 top
R503  *Short_0201  [S0201]  308.57 62.46 90 top
R504  *100K_1%_2  [R0201]  100.56 62.45 0 top
R505  100K_1%_2  [R0201]  309.28 62.44 270 top
R506  *5G_S@0_5%_2  [R0201]  282.58 62.32 270 top
R507  *5G_S@0_5%_2  [R0201]  285.88 62.32 90 top
R508  4.7K_1%_2  [R0201]  218.76 62.27 90 top
R509  *Short_0201  [S0201]  163.99 62.19 90 top
R510  100K_1%_2  [R0201]  224.03 62.04 0 top
R511  *Short_0402  [S0402]  198.44 61.98 180 top
R512  *100K_1%_2  [R0201]  201.96 61.91 180 top
R513  100K_1%_2  [R0201]  203.29 61.91 180 top
R514  100K_1%_2  [R0201]  165.66 61.84 90 top
R515  4.99K_1%_2  [R0201]  22.89 61.79 0 top
R516  100K_1%_2  [R0201]  209.99 62.2 0 top
R517  *SUB@Short_0402  [S0402]  297.15 61.73 90 top
R518  SUB@10K_1%_2  [R0201]  298.91 61.65 180 top
R519  *0_5%_4  [R0402]  307.38 61.52 90 top
R520  100K_1%_2  [R0201]  186.81 61.45 270 top
R521  4.7K_1%_2  [R0201]  45.29 61.41 270 top
R522  4.7K_1%_2  [R0201]  46.05 61.41 270 top
R523  *4.7K_1%_2  [R0201]  38.03 61.41 270 top
R524  *4.7K_1%_2  [R0201]  224.03 61.28 0 top
R525  *Short_0201  [S0201]  309.34 61.28 270 top
R526  33_1%_2  [R0201]  310.07 61.28 270 top
R527  *Short_0603  [S0603]  48.39 61.18 0 top
R528  *Short_0402  [S0402]  163.07 61.18 0 top
R529  *100K_1%_2  [R0201]  202.01 61.07 180 top
R530  100K_1%_2  [R0201]  203.34 61.07 180 top
R531  *SUB@0.1_1%_8  [R0805]  305.29 61.04 180 top
R532  *20K_1%_2  [R0201]  219.84 60.99 90 top
R533  *0_5%_2  [R0201]  221.86 60.96 180 top
R534  100K_1%_2  [R0201]  186.06 60.44 270 top
R535  *SUB@0_5%_4  [R0402]  297.8 60.37 0 top
R536  *Short_0201  [S0201]  224.16 60.29 180 top
R537  *100K_1%_2  [R0201]  225.3 60.29 180 top
R538  *Short_0402  [S0402]  163.07 60.16 0 top
R539  *10K_1%_2  [R0201]  186.82 60.16 90 top
R540  *Short_0201  [S0201]  187.58 60.16 90 top
R541  *100K_1%_2  [R0201]  202.02 60.14 180 top
R542  100K_1%_2  [R0201]  203.34 60.13 180 top
R543  *Short_0201  [S0201]  18.7 59.98 90 top
R544  *Short_0201  [S0201]  19.46 59.98 90 top
R545  *Short_0201  [S0201]  217.56 59.95 90 top
R546  *20K_1%_2  [R0201]  220.5 59.91 270 top
R547  *20K_1%_2  [R0201]  216.62 59.81 0 top
R548  100K_1%_2  [R0201]  227.33 60.08 90 top
R549  *4.7K_1%_2  [R0201]  47.37 59.53 180 top
R550  *0_5%_2  [R0201]  222.9 59.18 180 top
R551  *0_5%_2  [R0201]  221.91 59.14 90 top
R552  *4.7K_1%_2  [R0201]  36.15 59 180 top
R553  *20K_1%_2  [R0201]  219.7 58.98 90 top
R554  *100K_1%_2  [R0201]  202.01 58.93 180 top
R555  100K_1%_2  [R0201]  203.37 58.93 180 top
R556  *Short_0201  [S0201]  33.66 58.76 180 top
R557  *4.7K_1%_2  [R0201]  47.37 58.76 180 top
R558  100K_1%_2  [R0201]  217.38 58.45 0 top
R559  *5G@10K_1%_2  [R0201]  283.06 58.31 90 top
R560  100K_1%_2  [R0201]  163.82 58.28 180 top
R561  *4.7K_1%_2  [R0201]  36.15 58.24 180 top
R562  100K_1%_2  [R0201]  218.52 58.18 90 top
R563  *Short_0201  [S0201]  33.66 58 180 top
R564  *4.7K_1%_2  [R0201]  47.37 58 180 top
R565  *Short_0201  [S0201]  219.82 57.98 270 top
R566  *5G_S@0_5%_2  [R0201]  277.24 57.49 90 top
R567  *5G_S@0_5%_2  [R0201]  280.34 57.49 270 top
R568  *20K_1%_2  [R0201]  217.91 57.24 0 top
R569  1M_1%_2  [R0201]  33.66 57.24 180 top
R570  4.7K_1%_2  [R0201]  47.37 57.24 180 top
R571  100K_1%_2  [R0201]  208.41 57.24 0 top
R572  *100K_1%_2  [R0201]  201.82 57.02 180 top
R573  100K_1%_2  [R0201]  203.21 57.01 180 top
R574  33_1%_2  [R0201]  186.57 56.99 180 top
R575  *Short_0201  [S0201]  221.12 56.89 270 top
R576  *0_5%_2  [R0201]  168.6 56.81 0 top
R577  100K_1%_2  [R0201]  218.03 56.34 180 top
R578  *0_5%_4  [R0402]  251.21 56.22 270 top
R579  *Short_0402  [S0402]  247.48 56.15 270 top
R580  *0_5%_4  [R0402]  248.62 56.15 270 top
R581  *10K_1%_2  [R0201]  253.37 56.05 90 top
R582  10K_1%_2  [R0201]  205.54 55.71 270 top
R583  *0_5%_2  [R0201]  173.08 55.69 180 top
R584  *0_5%_4  [R0402]  252.33 55.46 90 top
R585  *0_5%_2  [R0201]  169.93 55.21 90 top
R586  *0_5%_2  [R0201]  170.69 55.21 90 top
R587  *0_5%_2  [R0201]  172.22 55.21 90 top
R588  *0_5%_2  [R0201]  171.46 55.21 90 top
R589  100K_1%_2  [R0201]  209.6 55.17 0 top
R590  20K_1%_2  [R0201]  32.64 55.08 180 top
R591  *4.7K_1%_2  [R0201]  37.21 55.08 270 top
R592  4.7K_1%_2  [R0201]  37.98 55.08 90 top
R593  *0_5%_2  [R0201]  178.11 55.06 90 top
R594  *0_5%_2  [R0201]  179.45 55.06 90 top
R595  *0_5%_2  [R0201]  218.03 55.06 180 top
R596  *0_5%_2  [R0201]  174.18 54.95 180 top
R597  100K_1%_2  [R0201]  210.45 54.88 90 top
R598  *Short_0201  [S0201]  38.99 54.83 270 top
R599  *Short_0201  [S0201]  39.75 54.83 270 top
R600  *Short_0201  [S0201]  40.52 54.83 270 top
R601  *Short_0201  [S0201]  41.28 54.83 270 top
R602  *Short_0201  [S0201]  42.04 54.83 270 top
R603  *Short_0201  [S0201]  42.8 54.83 270 top
R604  *Short_0201  [S0201]  43.56 54.83 270 top
R605  *Short_0201  [S0201]  44.33 54.83 270 top
R606  *4.7K_1%_2  [R0201]  45.09 54.83 90 top
R607  4.7K_1%_2  [R0201]  45.85 54.83 90 top
R608  100K_1%_2  [R0201]  31.63 54.57 270 top
R609  47K_1%_2  [R0201]  32.64 54.32 180 top
R610  *Short_0201  [S0201]  258.25 53.93 180 top
R611  *10K_1%_2  [R0201]  172.09 53.43 180 top
R612  *100K_1%_2  [R0201]  258.23 53.04 0 top
R613  *Short_0201  [S0201]  211 52.91 270 top
R614  10K_1%_2  [R0201]  172.33 52.56 0 top
R615  *Short_0402  [S0402]  252.76 52.41 180 top
R616  100K_1%_2  [R0201]  258.25 51.71 180 top
R617  10K_1%_2  [R0201]  208.03 50.51 90 top
R618  *Short_0603  [S0603]  21.91 49.66 180 top
R619  *10K_1%_2  [R0201]  185.17 48.35 90 top
R620  10K_1%_2  [R0201]  188.6 48.22 270 top
R621  *Short_0603  [S0603]  22.94 47.61 90 top
R622  *0_5%_2  [R0201]  208.03 47.33 180 top
R623  *10K_1%_2  [R0201]  209.3 46.32 270 top
R624  *Short_0201  [S0201]  210.06 46.32 270 top
R625  *Short_0603  [S0603]  203.67 45.71 0 top
R626  *0_5%_2  [R0201]  209.3 45.17 90 top
R627  *0_5%_2  [R0201]  210.06 45.17 90 top
R628  *0_5%_6  [R0603]  194.69 45.05 270 top
R629  *Short_0603  [S0603]  196.22 45.05 270 top
R630  *Short_0603  [S0603]  205.67 44.29 0 top
R631  *0_5%_6  [R0603]  183.52 43.78 0 top
R632  *Short_0201  [S0201]  208.31 43.78 270 top
R633  *100K_1%_2  [R0201]  209.17 43.78 90 top
R634  10K_1%_2  [R0201]  219.33 43.65 90 top
R635  100K_1%_2  [R0201]  215.14 43.27 270 top
R636  *0_5%_2  [R0201]  196.98 43.14 180 top
R637  10K_1%_2  [R0201]  198.38 43.14 0 top
R638  2.2K_1%_2  [R0201]  200.41 42.89 180 top
R639  *0_5%_2  [R0201]  201.81 42.89 180 top
R640  *Short_0603  [S0603]  18.83 42.81 180 top
R641  *Short_0805  [S0805]  285.37 42.63 270 top
R642  10K_1%_2  [R0201]  185.8 42.51 0 top
R643  *Short_0603  [S0603]  180.88 42.11 270 top
R644  *0_5%_6  [R0603]  221.75 41.67 180 top
R645  100K_1%_2  [R0201]  189.56 40.43 90 top
R646  *Short_0603  [S0603]  218.64 40.08 0 top
R647  *0_5%_2  [R0201]  200.54 39.46 0 top
R648  2.2K_1%_2  [R0201]  201.55 39.46 0 top
R649  *Short_0603  [S0603]  45.94 37.74 0 top
R650  *Short_0603  [S0603]  39.42 36.72 90 top
R651  100K_1%_2  [R0201]  40.87 36.7 90 top
R652  100K_1%_2  [R0201]  44.58 36.45 270 top
R653  100K_1%_2  [R0201]  35 35.93 270 top
R654  *Short_0603  [S0603]  41.46 34.76 180 top
R655  1K_1%_2  [R0201]  20.35 27.27 270 top
R656  1K_1%_2  [R0201]  21.31 27.27 270 top
R657  *1K_1%_2  [R0201]  22.28 27.27 270 top
R658  *1K_1%_2  [R0201]  19.13 25.49 0 top
R659  *1K_1%_2  [R0201]  20.91 25.44 0 top
R660  1K_1%_2  [R0201]  22.74 25.49 180 top
R661  1K_1%_2  [R0201]  24.64 24.37 90 top
R662  *0_5%_4  [R0402]  25.9 24.09 90 top
R663  *1K_1%_2  [R0201]  26.87 24.09 90 top
R664  4.7K_1%_2  [R0201]  24.31 19.32 90 top
R665  *Short_0402  [S0402]  21.39 19.19 90 top
R666  100K_1%_2  [R0201]  22.41 19.19 270 top
R667  *4.7K_1%_2  [R0201]  23.42 19.19 270 top
R668  *0_5%_4  [R0402]  24.59 15.43 0 top
R669  5.1M_5%_2  [R0201]  15.91 13.87 270 top
R670  1M_1%_2  [R0201]  22.2 13.28 90 top
R671  *Short_0402  [S0402]  24.19 11.98 0 top
R672  *Short_0201  [S0201]  19.31 11.77 270 top
R673  10K_1%_2  [R0201]  22.25 11.22 270 top
R674  10K_1%_2  [R0201]  26.83 9.61 180 top
R675  10K_1%_2  [R0201]  21.09 8.07 0 top
R676  *100K_1%_2  [R0201]  18.57 7.58 180 top
R677  *100K_1%_2  [R0201]  19.56 7.58 180 top
R678  *124_1%_6  [R0603]  223.4 218.28 0 bottom
R679  *124_1%_6  [R0603]  249.49 218.22 0 bottom
R680  *124_1%_6  [R0603]  230.42 217.86 180 bottom
R681  *100K_1%_2  [R0201]  138.84 217.31 90 bottom
R682  *124_1%_6  [R0603]  166.44 217.22 0 bottom
R683  *124_1%_6  [R0603]  141.34 217.15 180 bottom
R684  10K_1%_2  [R0201]  262.28 216.62 270 bottom
R685  *200_1%_6  [R0603]  246.28 216.23 180 bottom
R686  *200_1%_6  [R0603]  144.2 216.19 0 bottom
R687  *100K_1%_2  [R0201]  135.13 216.04 270 bottom
R688  100K_1%_2  [R0201]  274.13 216.02 270 bottom
R689  *4.7K_1%_2  [R0201]  146.04 215.4 180 bottom
R690  *200_1%_6  [R0603]  225.79 214.98 0 bottom
R691  *Short_0201  [S0201]  266.18 214.7 270 bottom
R692  *Short_0201  [S0201]  266.9 214.7 270 bottom
R693  4.7K_1%_2  [R0201]  262.53 214.68 90 bottom
R694  *124_1%_6  [R0603]  163.09 214.22 90 bottom
R695  *200_1%_6  [R0603]  161.65 214.22 270 bottom
R696  *200_1%_6  [R0603]  166.95 214.16 90 bottom
R697  *124_1%_6  [R0603]  148.91 214.12 180 bottom
R698  *Short_0201  [S0201]  258.39 213.81 0 bottom
R699  *2.2K_1%_2  [R0201]  256.04 213.32 270 bottom
R700  *Short_0201  [S0201]  255.91 211.54 90 bottom
R701  *Short_0805  [S0805]  140.97 211.42 90 bottom
R702  *Short_0805  [S0805]  143.26 211.42 90 bottom
R703  *4.7K_1%_2  [R0201]  146.31 211.29 0 bottom
R704  *2.2K_1%_2  [R0201]  257.64 210.74 0 bottom
R705  *Short_0201  [S0201]  268.84 210.41 180 bottom
R706  *Short_0201  [S0201]  259.85 210.27 180 bottom
R707  *Short_0201  [S0201]  268.84 209.65 180 bottom
R708  *Short_0201  [S0201]  259.85 209.51 180 bottom
R709  *100K_1%_2  [R0201]  151.82 209.15 90 bottom
R710  *Short_0201  [S0201]  150.98 208.78 90 bottom
R711  *Short_0805  [S0805]  140.72 207.84 270 bottom
R712  *4.7K_1%_2  [R0201]  148.59 206.97 0 bottom
R713  100K_1%_2  [R0201]  284.61 205.7 270 bottom
R714  *Short_0201  [S0201]  151.64 205.58 180 bottom
R715  10_1%_2  [R0201]  285.5 205.32 270 bottom
R716  *4.7K_1%_2  [R0201]  153.55 204.05 270 bottom
R717  *4.7K_1%_2  [R0201]  149.77 203.39 90 bottom
R718  *Short_0201  [S0201]  278.26 202.78 180 bottom
R719  4.7K_1%_2  [R0201]  148.71 202.63 90 bottom
R720  4.7K_1%_2  [R0201]  145.01 202.31 270 bottom
R721  *Short_0201  [S0201]  151.64 202.02 0 bottom
R722  100K_1%_2  [R0201]  278.26 202.02 0 bottom
R723  *22_5%_8  [R0805]  284.36 200.24 180 bottom
R724  *Short_0603  [S0603]  273.43 197.98 180 bottom
R725  100K_1%_2  [R0201]  278.13 197.19 90 bottom
R726  100K_1%_2  [R0201]  274.32 196.56 270 bottom
R727  *0_5%_2  [R0201]  280.22 195.15 180 bottom
R728  *1M_1%_2  [R0201]  283.37 194.98 0 bottom
R729  *Short_0603  [S0603]  273.38 194.81 0 bottom
R730  *Short_0603  [S0603]  276.02 194.81 180 bottom
R731  100K_1%_2  [R0201]  266.45 194.02 180 bottom
R732  *1M_1%_2  [R0201]  283.31 194.02 180 bottom
R733  4.7K_1%_2  [R0201]  266.78 192.93 270 bottom
R734  100K_1%_2  [R0201]  274.93 192.37 270 bottom
R735  G3@10K_1%_2  [R0201]  210.64 192.32 180 bottom
R736  100K_1%_2  [R0201]  268.99 186.83 180 bottom
R737  2M_1%_2  [R0201]  204.21 186.52 90 bottom
R738  22_5%_8  [R0805]  198.63 186.02 180 bottom
R739  *0_5%_4  [R0402]  208.66 186.02 0 bottom
R740  1M_1%_2  [R0201]  204.21 185.5 90 bottom
R741  *Short_0402  [S0402]  266.67 185.36 270 bottom
R742  *Short_0402  [S0402]  208.66 184.87 0 bottom
R743  *Short_0805  [S0805]  198.63 183.99 180 bottom
R744  *Short_0805  [S0805]  276.79 181.62 0 bottom
R745  866_1%_2  [R0201]  200.76 180.29 0 bottom
R746  *22_5%_8  [R0805]  205.74 179.92 270 bottom
R747  *Short_0805  [S0805]  205.74 177.25 180 bottom
R748  *Short_0201  [S0201]  283.26 176.49 90 bottom
R749  *2M_1%_2  [R0201]  207.78 174.59 270 bottom
R750  *1M_1%_2  [R0201]  208.54 174.59 90 bottom
R751  *100K_1%_2  [R0201]  194.37 169.25 0 bottom
R752  1M_1%_2  [R0201]  190.76 166.49 270 bottom
R753  1M_1%_2  [R0201]  192.31 166.49 270 bottom
R754  *100K_1%_2  [R0201]  166.33 165.01 270 bottom
R755  *Short_0201  [S0201]  163.7 164.79 180 bottom
R756  0_5%_8  [R0805]  185.55 164.68 0 bottom
R757  *100K_1%_2  [R0201]  166.3 163.96 90 bottom
R758  *100K_1%_2  [R0201]  164.95 163.89 90 bottom
R759  1M_1%_2  [R0201]  195.58 163.77 270 bottom
R760  *Short_0201  [S0201]  163.9 163.49 90 bottom
R761  *0_5%_2  [R0201]  166.3 162.95 90 bottom
R762  *Short_0201  [S0201]  164.95 162.9 90 bottom
R763  *0_5%_8  [R0805]  185.55 162.65 0 bottom
R764  51_1%_2  [R0201]  176.17 160.4 90 bottom
R765  *51_1%_2  [R0201]  178.08 160.4 270 bottom
R766  1K_1%_2  [R0201]  177.17 160.39 270 bottom
R767  *51_1%_2  [R0201]  174.63 160.36 90 bottom
R768  1K_1%_2  [R0201]  168.04 159.76 90 bottom
R769  *1K_1%_2  [R0201]  169.06 159.76 90 bottom
R770  *1K_1%_2  [R0201]  170.71 159.76 90 bottom
R771  51_1%_2  [R0201]  178.16 158.75 90 bottom
R772  10K_1%_2  [R0201]  176.17 158.75 90 bottom
R773  *51_1%_2  [R0201]  177.19 158.75 90 bottom
R774  10K_1%_2  [R0201]  179.09 158.75 90 bottom
R775  *51_1%_2  [R0201]  180.11 158.75 90 bottom
R776  150_1%_2  [R0201]  168.05 157.95 90 bottom
R777  150_1%_2  [R0201]  149.63 157.86 180 bottom
R778  *1K_1%_2  [R0201]  171.98 157.86 90 bottom
R779  *1K_1%_2  [R0201]  172.87 157.86 90 bottom
R780  1K_1%_2  [R0201]  174.89 157.86 90 bottom
R781  150_1%_2  [R0201]  150.86 157.66 180 bottom
R782  150_1%_2  [R0201]  141.47 157.09 0 bottom
R783  100K_1%_2  [R0201]  163.79 157.08 90 bottom
R784  2.2K_1%_2  [R0201]  143.68 157.04 180 bottom
R785  150_1%_2  [R0201]  148.68 157.04 90 bottom
R786  150_1%_2  [R0201]  149.63 156.97 180 bottom
R787  150_1%_2  [R0201]  151 156.92 180 bottom
R788  *Short_0201  [S0201]  180.36 156.08 0 bottom
R789  *54.9_1%_2  [R0201]  181.89 156.08 180 bottom
R790  *Short_0201  [S0201]  180.36 155.19 0 bottom
R791  56.2_1%_2  [R0201]  181.89 155.19 0 bottom
R792  *Short_0201  [S0201]  180.36 154.3 180 bottom
R793  100_1%_2  [R0201]  181.89 154.3 180 bottom
R794  49.9_1%_2  [R0201]  180.36 153.54 0 bottom
R795  *2.2K_1%_2  [R0201]  180.36 152.78 0 bottom
R796  20_1%_2  [R0201]  181.2 150.16 180 bottom
R797  *2.2K_1%_2  [R0201]  181.09 147.91 0 bottom
R798  47K_1%_2  [R0201]  120.53 145.76 180 bottom
R799  *0_5%_4  [R0402]  113.42 144.56 90 bottom
R800  *Short_0201  [S0201]  123.45 144.36 0 bottom
R801  100K_1%_2  [R0201]  112.53 144.23 270 bottom
R802  1K_1%_2  [R0201]  123.47 143.64 0 bottom
R803  60.4_1%_2  [R0201]  123.47 142.87 180 bottom
R804  *Short_0201  [S0201]  123.47 142.11 180 bottom
R805  20_1%_2  [R0201]  123.47 141.35 0 bottom
R806  *Short_0201  [S0201]  121.94 140.59 180 bottom
R807  100K_1%_2  [R0201]  123.47 140.59 180 bottom
R808  *Short_0201  [S0201]  123.47 139.32 0 bottom
R809  *100K_1%_2  [R0201]  114.04 132.46 270 bottom
R810  1K_1%_2  [R0201]  114.77 132.46 270 bottom
R811  1K_1%_2  [R0201]  112.02 132.42 90 bottom
R812  *Short_0201  [S0201]  264.12 127.56 180 bottom
R813  *0_5%_2  [R0201]  264 126.84 180 bottom
R814  *0_5%_2  [R0201]  262.64 126.07 0 bottom
R815  100_1%_2  [R0201]  177.53 125.62 180 bottom
R816  1K_1%_2  [R0201]  109.2 112.84 180 bottom
R817  10K_1%_2  [R0201]  109.7 108.29 0 bottom
R818  10K_1%_2  [R0201]  106.84 107.86 90 bottom
R819  *10K_1%_2  [R0201]  108.11 107.86 270 bottom
R820  *Short_0201  [S0201]  109.7 107.27 180 bottom
R821  *Short_0402  [S0402]  110.33 104.88 270 bottom
R822  10K_1%_2  [R0201]  214.99 101.21 0 bottom
R823  *0_5%_4  [R0402]  209.98 99.38 0 bottom
R824  *5G@0_5%_2  [R0201]  303.51 96.63 90 bottom
R825  2.2K_1%_2  [R0201]  213.52 98.44 270 bottom
R826  *5G@Short_0201  [S0201]  304.23 96.64 90 bottom
R827  2.2K_1%_2  [R0201]  210.49 97.88 90 bottom
R828  5G@2.2K_1%_2  [R0201]  302.13 97.38 180 bottom
R829  221K_1%_2  [R0201]  12.07 97.27 270 bottom
R830  *Short_0805  [S0805]  51.06 97.24 270 bottom
R831  *Short_0805  [S0805]  53.98 97.24 270 bottom
R832  *Short_0402  [S0402]  36.11 96.73 0 bottom
R833  *0_5%_4  [R0402]  213.18 96.72 180 bottom
R834  221K_1%_2  [R0201]  12.07 96.2 90 bottom
R835  *5G@Short_0201  [S0201]  311.25 94.02 270 bottom
R836  *5G@0_5%_2  [R0201]  312.02 94.02 270 bottom
R837  *0_5%_2  [R0201]  38.33 93.77 270 bottom
R838  *5G@1M_1%_2  [R0201]  298.96 93.56 180 bottom
R839  *5G@100K_1%_2  [R0201]  311.97 92.88 90 bottom
R840  4.75K_0.5%_2  [R0201]  39.75 92.67 180 bottom
R841  *5G@Short_0201  [S0201]  298.96 92.16 180 bottom
R842  *Short_0201  [S0201]  60.83 92.13 270 bottom
R843  *5G@10K_1%_2  [R0201]  310.65 91.91 0 bottom
R844  *0_5%_4  [R0402]  70.23 91.66 90 bottom
R845  *5G@Short_0201  [S0201]  298.96 91.4 180 bottom
R846  100K_1%_2  [R0201]  61.85 91.15 0 bottom
R847  100K_1%_2  [R0201]  61.64 90.37 180 bottom
R848  *0_5%_4  [R0402]  68.33 90.01 180 bottom
R849  221K_1%_2  [R0201]  11.81 89.78 270 bottom
R850  *Short_0201  [S0201]  113.03 89.75 180 bottom
R851  *0_5%_2  [R0201]  63 89.62 0 bottom
R852  *0_5%_2  [R0201]  61.76 89.46 180 bottom
R853  8.2K_1%_2  [R0201]  65.03 89.24 0 bottom
R854  *Short_0201  [S0201]  113.03 88.99 180 bottom
R855  *5G@Short_0603  [S0603]  297.83 88.89 90 bottom
R856  221K_1%_2  [R0201]  11.81 88.71 90 bottom
R857  *5G@1M_1%_2  [R0201]  299.05 88.55 180 bottom
R858  4.7K_1%_2  [R0201]  65.03 88.48 0 bottom
R859  *Short_0201  [S0201]  59.82 88.23 0 bottom
R860  *Short_0201  [S0201]  62.49 88.23 180 bottom
R861  5G@100K_1%_2  [R0201]  299.05 87.8 180 bottom
R862  4.7K_1%_2  [R0201]  65.03 87.34 0 bottom
R863  *100K_1%_2  [R0201]  62.49 87.21 0 bottom
R864  10K_1%_2  [R0201]  41.02 87.08 0 bottom
R865  *5G@0_5%_2  [R0201]  310.65 86.96 180 bottom
R866  2.2K_1%_2  [R0201]  36.07 86.7 270 bottom
R867  2.2K_1%_2  [R0201]  36.83 86.7 270 bottom
R868  *Short_0201  [S0201]  113.03 86.7 180 bottom
R869  *1K_1%_2  [R0201]  214.2 86.5 180 bottom
R870  *Short_0201  [S0201]  65.03 86.32 180 bottom
R871  *0_5%_4  [R0402]  68.33 86.2 0 bottom
R872  *Short_0201  [S0201]  113.03 85.94 180 bottom
R873  *100_1%_2  [R0201]  218.32 85.26 90 bottom
R874  *10K_1%_2  [R0201]  37.6 86.7 270 bottom
R875  *0_5%_2  [R0201]  38.87 85.43 270 bottom
R876  *Short_0201  [S0201]  221.36 85.05 270 bottom
R877  10K_1%_2  [R0201]  222.13 85.05 90 bottom
R878  *Short_0201  [S0201]  223.52 85.05 180 bottom
R879  30_1%_2  [R0201]  213.23 84.93 270 bottom
R880  *5G@100K_1%_2  [R0201]  298.32 84.84 0 bottom
R881  *Short_0201  [S0201]  59.44 84.8 90 bottom
R882  *Short_0201  [S0201]  60.2 84.8 90 bottom
R883  *210_1%_2  [R0201]  219.84 84.8 270 bottom
R884  *210_1%_2  [R0201]  220.6 84.8 270 bottom
R885  30_1%_2  [R0201]  215.83 84.75 90 bottom
R886  620_5%_2  [R0201]  207.9 84.65 180 bottom
R887  *Short_0402  [S0402]  61.47 84.54 0 bottom
R888  *Short_0402  [S0402]  63.25 84.54 180 bottom
R889  *Short_0201  [S0201]  223.52 84.04 180 bottom
R890  *5G@Short_0201  [S0201]  298.33 83.99 180 bottom
R891  60.4_1%_2  [R0201]  206.29 83.72 0 bottom
R892  *Short_0201  [S0201]  113.03 83.66 180 bottom
R893  *4.7_5%_2  [R0201]  215.27 83.55 180 bottom
R894  *0_5%_4  [R0402]  98.47 83.55 90 bottom
R895  *100K_1%_2  [R0201]  99.45 83.55 90 bottom
R896  *5G@0_5%_2  [R0201]  310.39 83.27 180 bottom
R897  *20K_1%_2  [R0201]  224.54 83.45 0 bottom
R898  221K_1%_2  [R0201]  12.07 83.27 270 bottom
R899  *100_1%_2  [R0201]  218.81 83.23 0 bottom
R900  *5G@Short_0201  [S0201]  298.33 83.23 180 bottom
R901  *100_1%_2  [R0201]  219.8 83.14 180 bottom
R902  10K_1%_2  [R0201]  202.77 83.02 270 bottom
R903  113_1%_2  [R0201]  203.53 83.02 270 bottom
R904  10K_1%_2  [R0201]  204.3 83.02 270 bottom
R905  30_1%_2  [R0201]  216.77 83.02 90 bottom
R906  *Short_0201  [S0201]  217.48 83.02 270 bottom
R907  *100_1%_2  [R0201]  220.69 82.97 270 bottom
R908  *Short_0201  [S0201]  113.03 82.89 180 bottom
R909  100K_1%_2  [R0201]  222.39 82.88 90 bottom
R910  10K_1%_2  [R0201]  221.66 82.87 270 bottom
R911  13_1%_2  [R0201]  215.47 82.84 180 bottom
R912  4.7K_1%_2  [R0201]  230.53 82.73 0 bottom
R913  *Short_0201  [S0201]  212.02 82.44 180 bottom
R914  *20K_1%_2  [R0201]  224.53 82.41 0 bottom
R915  221K_1%_2  [R0201]  12.07 82.2 90 bottom
R916  *Short_0201  [S0201]  227.5 81.88 180 bottom
R917  10K_1%_2  [R0201]  227.51 81.15 0 bottom
R918  *Short_0201  [S0201]  113.03 80.61 180 bottom
R919  *Short_0201  [S0201]  113.03 79.85 180 bottom
R920  *5G@Short_0201  [S0201]  310.53 79.38 180 bottom
R921  *Short_0402  [S0402]  31.5 79.08 0 bottom
R922  *0_5%_2  [R0201]  271.78 79.08 0 bottom
R923  4.7K_1%_2  [R0201]  231.16 78.92 180 bottom
R924  *100K_1%_2  [R0201]  229.37 78.83 0 bottom
R925  *5G@Short_0201  [S0201]  310.53 78.62 180 bottom
R926  *Short_0201  [S0201]  271.78 78.32 180 bottom
R927  *20K_1%_2  [R0201]  227.84 77.94 180 bottom
R928  *5G@Short_0201  [S0201]  310.53 77.85 180 bottom
R929  *Short_0201  [S0201]  113.03 77.56 180 bottom
R930  *0_5%_2  [R0201]  100.08 77.43 180 bottom
R931  *20K_1%_2  [R0201]  227.84 77.05 180 bottom
R932  *100K_1%_2  [R0201]  229.37 77.05 0 bottom
R933  *10K_1%_2  [R0201]  272.64 76.99 0 bottom
R934  *Short_0201  [S0201]  113.03 76.8 180 bottom
R935  *0_5%_2  [R0201]  33.76 76.5 270 bottom
R936  200_1%_2  [R0201]  227.84 76.26 180 bottom
R937  *100K_1%_2  [R0201]  229.37 76.26 0 bottom
R938  *10K_1%_2  [R0201]  272.63 76.12 0 bottom
R939  221K_1%_2  [R0201]  11.81 75.78 270 bottom
R940  *5G@1M_1%_2  [R0201]  298.28 75.76 180 bottom
R941  *20K_1%_2  [R0201]  229.37 75.55 0 bottom
R942  4.75K_0.5%_2  [R0201]  35.18 75.4 180 bottom
R943  *0_5%_2  [R0201]  272.64 75.16 180 bottom
R944  *5G@1M_1%_2  [R0201]  298.28 74.99 180 bottom
R945  221K_1%_2  [R0201]  11.81 74.71 90 bottom
R946  100_1%_2  [R0201]  198.41 74.5 90 bottom
R947  *Short_0201  [S0201]  272.64 74.4 180 bottom
R948  200_1%_2  [R0201]  227.84 74.26 0 bottom
R949  150_1%_2  [R0201]  229.37 74.26 180 bottom
R950  *Short_0402  [S0402]  313.1 73.62 0 bottom
R951  *Short_0402  [S0402]  272.16 73.5 0 bottom
R952  *20K_1%_2  [R0201]  227.69 72.22 180 bottom
R953  *4.7K_1%_2  [R0201]  229.1 72.21 0 bottom
R954  *20K_1%_2  [R0201]  227.69 71.5 180 bottom
R955  *4.7K_1%_2  [R0201]  229.11 71.49 0 bottom
R956  SUB@0.1_1%_8  [R0805]  289.06 72.1 180 bottom
R957  100K_1%_2  [R0201]  314.35 70.66 180 bottom
R958  2.2K_1%_2  [R0201]  227.69 70.03 0 bottom
R959  *20K_1%_2  [R0201]  269.52 69.92 180 bottom
R960  10K_1%_2  [R0201]  271.04 69.92 0 bottom
R961  *2.2K_1%_2  [R0201]  32.26 69.72 270 bottom
R962  *2.2K_1%_2  [R0201]  33.03 69.72 270 bottom
R963  10K_1%_2  [R0201]  36.58 69.69 0 bottom
R964  2.2K_1%_2  [R0201]  227.69 69.31 0 bottom
R965  200_1%_2  [R0201]  229.11 69.31 180 bottom
R966  *Short_0402  [S0402]  314.13 68.71 90 bottom
R967  20K_1%_2  [R0201]  269.52 68.58 180 bottom
R968  *20K_1%_2  [R0201]  271.04 68.58 0 bottom
R969  2.2K_1%_2  [R0201]  229.39 68.49 0 bottom
R970  2.2K_1%_2  [R0201]  227.7 68.38 0 bottom
R971  51_1%_2  [R0201]  272.42 68.29 180 bottom
R972  *10K_1%_2  [R0201]  33.15 68.03 180 bottom
R973  *0_5%_2  [R0201]  35.18 66.38 0 bottom
R974  *4.7K_1%_2  [R0201]  229.39 67.77 0 bottom
R975  10K_1%_2  [R0201]  227.7 67.66 0 bottom
R976  *20K_1%_2  [R0201]  230.26 67.59 270 bottom
R977  *0_5%_4  [R0402]  314.76 67.23 0 bottom
R978  51_1%_2  [R0201]  272.42 67.09 180 bottom
R979  *0_5%_2  [R0201]  229.11 66.95 180 bottom
R980  *4.7K_1%_2  [R0201]  227.7 66.73 0 bottom
R981  *Short_0402  [S0402]  18.06 66.33 180 bottom
R982  *20K_1%_2  [R0201]  229.11 66.23 180 bottom
R983  2.2K_1%_2  [R0201]  227.71 66.01 0 bottom
R984  *100K_1%_2  [R0201]  229.11 65.51 0 bottom
R985  *1M_1%_2  [R0201]  305.13 64.81 180 bottom
R986  2.2K_1%_2  [R0201]  229.14 64.78 0 bottom
R987  2.2K_1%_2  [R0201]  228.1 64.57 0 bottom
R988  *Short_0201  [S0201]  112.4 64.35 180 bottom
R989  2.2K_1%_2  [R0201]  229.14 64.06 0 bottom
R990  *Short_0402  [S0402]  313.49 64.02 270 bottom
R991  10K_1%_2  [R0201]  227.74 63.83 0 bottom
R992  *Short_0201  [S0201]  112.4 63.59 180 bottom
R993  *SUB@Short_0402  [S0402]  300.61 63.59 270 bottom
R994  10K_1%_2  [R0201]  229.15 63.33 0 bottom
R995  *SUB@Short_0402  [S0402]  302.01 63.21 180 bottom
R996  10K_1%_2  [R0201]  227.74 63.04 0 bottom
R997  10K_1%_2  [R0201]  229.11 62.6 0 bottom
R998  *0_5%_2  [R0201]  231.07 62.47 180 bottom
R999  10K_1%_2  [R0201]  227.74 62.32 0 bottom
R1000  10K_1%_2  [R0201]  229.09 61.86 0 bottom
R1001  *0_5%_2  [R0201]  231.07 61.75 180 bottom
R1002  *100K_1%_2  [R0201]  306.96 61.56 90 bottom
R1003  *Short_0805  [S0805]  251.64 61.33 0 bottom
R1004  *Short_0201  [S0201]  112.4 61.3 180 bottom
R1005  10K_1%_2  [R0201]  227.71 61.3 0 bottom
R1006  *100K_1%_2  [R0201]  229.13 61.14 0 bottom
R1007  *0_5%_4  [R0402]  302.63 61.01 180 bottom
R1008  *Short_0201  [S0201]  112.4 60.54 180 bottom
R1009  *20K_1%_2  [R0201]  227.76 60.41 180 bottom
R1010  *4.7K_1%_2  [R0201]  229.11 60.39 0 bottom
R1011  *SUB@Short_0402  [S0402]  304.5 60.11 270 bottom
R1012  *0_5%_4  [R0402]  305.97 60.11 270 bottom
R1013  *100K_1%_2  [R0201]  98.56 59.91 180 bottom
R1014  TPM@15_1%_2  [R0201]  243.61 59.68 270 bottom
R1015  TPM@15_1%_2  [R0201]  244.33 59.68 270 bottom
R1016  100_1%_2  [R0201]  245.09 59.68 90 bottom
R1017  *20K_1%_2  [R0201]  227.77 59.66 180 bottom
R1018  *5G@4.7K_1%_2  [R0201]  242.89 59.56 90 bottom
R1019  *4.7K_1%_2  [R0201]  229.37 59.55 0 bottom
R1020  *Short_0201  [S0201]  245.95 59.09 180 bottom
R1021  33_1%_2  [R0201]  229.37 58.72 180 bottom
R1022  5G@100_1%_2  [R0201]  237.85 57.67 0 bottom
R1023  *100K_1%_2  [R0201]  230.8 58.7 0 bottom
R1024  *Short_0201  [S0201]  243.94 58.69 0 bottom
R1025  5G@100_1%_2  [R0201]  240.06 57.72 0 bottom
R1026  5G@100_1%_2  [R0201]  242.12 57.95 0 bottom
R1027  10K_1%_2  [R0201]  191.13 58.49 180 bottom
R1028  *Short_0201  [S0201]  112.4 58.26 180 bottom
R1029  15_1%_2  [R0201]  245.27 58.23 270 bottom
R1030  *Short_0201  [S0201]  246 58.23 270 bottom
R1031  *1M_1%_2  [R0201]  227.84 58.05 0 bottom
R1032  5G_S@0_5%_2  [R0201]  276.02 58.05 90 bottom
R1033  5G_S@2.2K_1%_2  [R0201]  276.79 58.05 90 bottom
R1034  5G_S@2.2K_1%_2  [R0201]  277.55 58.05 90 bottom
R1035  5G_S@0_5%_2  [R0201]  278.31 58.05 90 bottom
R1036  1K_1%_2  [R0201]  230.79 57.98 0 bottom
R1037  33_1%_2  [R0201]  229.37 57.97 180 bottom
R1038  5G_S@2.2K_1%_2  [R0201]  281.97 57.8 90 bottom
R1039  5G_S@0_5%_2  [R0201]  282.73 57.8 90 bottom
R1040  5G_S@0_5%_2  [R0201]  283.49 57.8 90 bottom
R1041  5G_S@2.2K_1%_2  [R0201]  284.25 57.8 90 bottom
R1042  100_1%_2  [R0201]  243.62 57.6 270 bottom
R1043  15_1%_2  [R0201]  244.34 57.6 270 bottom
R1044  *Short_0201  [S0201]  112.4 57.49 180 bottom
R1045  5G_S@0_5%_4  [R0402]  280.04 57.34 180 bottom
R1046  33_1%_2  [R0201]  230.79 57.27 180 bottom
R1047  49.9_1%_2  [R0201]  246 57.21 270 bottom
R1048  *1M_1%_2  [R0201]  227.84 57.11 0 bottom
R1049  33_1%_2  [R0201]  229.37 57.11 180 bottom
R1050  5G_S@0_5%_2  [R0201]  275.37 57.07 180 bottom
R1051  5G_S@0_5%_4  [R0402]  286.67 56.63 180 bottom
R1052  *20K_1%_2  [R0201]  230.79 56.55 180 bottom
R1053  10K_1%_2  [R0201]  21.85 56.43 90 bottom
R1054  39K_1%_2  [R0201]  22.69 56.43 270 bottom
R1055  5G_S@0_5%_2  [R0201]  281.84 56.38 180 bottom
R1056  5G_S@2.2K_1%_2  [R0201]  275.37 56.31 180 bottom
R1057  20K_1%_2  [R0201]  24.64 55.72 0 bottom
R1058  5G_S@2.2K_1%_2  [R0201]  281.84 55.61 180 bottom
R1059  *Short_0201  [S0201]  112.4 55.21 180 bottom
R1060  5G_S@0_5%_4  [R0402]  280.05 54.8 180 bottom
R1061  *Short_0805  [S0805]  230.76 54.55 180 bottom
R1062  *Short_0201  [S0201]  112.4 54.45 180 bottom
R1063  5G_S@0_5%_4  [R0402]  286.67 54.09 0 bottom
R1064  100K_1%_2  [R0201]  232.74 53.89 270 bottom
R1065  5G_S@0_5%_4  [R0402]  280.05 53.79 0 bottom
R1066  5G_S@0_5%_4  [R0402]  286.67 53.07 0 bottom
R1067  1K_1%_2  [R0201]  212.27 52.45 270 bottom
R1068  100K_1%_2  [R0201]  210.84 52.4 270 bottom
R1069  *Short_0201  [S0201]  218.77 52.36 90 bottom
R1070  *Short_0201  [S0201]  219.51 52.36 90 bottom
R1071  *Short_0201  [S0201]  112.4 52.16 180 bottom
R1072  *0_5%_2  [R0201]  98.81 52.03 180 bottom
R1073  *20K_1%_2  [R0201]  218 51.94 270 bottom
R1074  33_1%_2  [R0201]  220.8 51.94 270 bottom
R1075  33_1%_2  [R0201]  221.8 51.93 270 bottom
R1076  *Short_0201  [S0201]  222.63 51.93 270 bottom
R1077  10K_1%_2  [R0201]  223.53 51.92 90 bottom
R1078  10K_1%_2  [R0201]  224.25 51.92 90 bottom
R1079  *20K_1%_2  [R0201]  217.28 51.91 90 bottom
R1080  10K_1%_2  [R0201]  214.57 51.84 90 bottom
R1081  *100K_1%_2  [R0201]  213.53 51.84 270 bottom
R1082  10K_1%_2  [R0201]  215.41 51.73 90 bottom
R1083  10M_5%_2  [R0201]  219.11 51.49 180 bottom
R1084  *Short_0201  [S0201]  112.4 51.4 180 bottom
R1085  *0_5%_2  [R0201]  209.97 51.4 0 bottom
R1086  *Short_0201  [S0201]  237.63 51.17 270 bottom
R1087  100K_1%_2  [R0201]  211.84 51.02 180 bottom
R1088  10K_1%_2  [R0201]  198.58 50.94 270 bottom
R1089  100K_1%_2  [R0201]  199.3 50.94 270 bottom
R1090  10K_1%_2  [R0201]  200.15 50.94 270 bottom
R1091  1ADP@100K_1%_2  [R0201]  203.86 50.82 270 bottom
R1092  SUB@100K_1%_2  [R0201]  204.58 50.82 270 bottom
R1093  G2@100K_1%_2  [R0201]  201.15 50.82 270 bottom
R1094  TPM@100K_1%_2  [R0201]  201.96 50.82 270 bottom
R1095  i7@100K_1%_2  [R0201]  203.05 50.81 90 bottom
R1096  *100K_1%_2  [R0201]  205.67 50.76 270 bottom
R1097  5G@100K_1%_2  [R0201]  206.4 50.76 270 bottom
R1098  DDS@100K_1%_2  [R0201]  207.2 50.76 270 bottom
R1099  100K_1%_2  [R0201]  214.25 50.76 270 bottom
R1100  100K_1%_2  [R0201]  208.04 50.75 270 bottom
R1101  100K_1%_2  [R0201]  194.29 50.74 0 bottom
R1102  *Short_0201  [S0201]  208.9 50.62 180 bottom
R1103  20K_1%_2  [R0201]  233.56 50.61 180 bottom
R1104  470_1%_2  [R0201]  210.76 50.61 0 bottom
R1105  1M_1%_2  [R0201]  212.74 50.58 270 bottom
R1106  *100K_1%_2  [R0201]  216.56 50.45 0 bottom
R1107  100K_1%_2  [R0201]  215.55 50.43 180 bottom
R1108  *Short_0201  [S0201]  237.63 50.18 90 bottom
R1109  *Short_0201  [S0201]  235.34 50.18 270 bottom
R1110  TPM@15_1%_2  [R0201]  236.05 50.18 270 bottom
R1111  *Short_0201  [S0201]  236.77 50.18 270 bottom
R1112  *Short_0402  [S0402]  278.77 50 90 bottom
R1113  10K_1%_2  [R0201]  22.67 49.98 270 bottom
R1114  10K_1%_2  [R0201]  21.71 49.97 270 bottom
R1115  100K_1%_2  [R0201]  24.04 49.97 270 bottom
R1116  20K_1%_2  [R0201]  233.56 49.85 180 bottom
R1117  *Short_0402  [S0402]  189.13 49.4 90 bottom
R1118  i9@100K_1%_2  [R0201]  203.07 49.3 270 bottom
R1119  2ADP@100K_1%_2  [R0201]  203.91 49.3 270 bottom
R1120  SUB_N@100K_1%_2  [R0201]  204.67 49.3 270 bottom
R1121  100K_1%_2  [R0201]  205.56 49.3 270 bottom
R1122  5G_N@100K_1%_2  [R0201]  206.32 49.3 270 bottom
R1123  N_DDS@100K_1%_2  [R0201]  207.05 49.3 270 bottom
R1124  10K_1%_2  [R0201]  199.47 49.29 270 bottom
R1125  TPM_N@100K_1%_2  [R0201]  202.14 49.29 270 bottom
R1126  *100K_1%_2  [R0201]  184.75 49.2 270 bottom
R1127  1M_1%_2  [R0201]  208.28 49.09 180 bottom
R1128  10K_1%_2  [R0201]  201.28 49.03 270 bottom
R1129  *Short_0201  [S0201]  237.63 48.91 270 bottom
R1130  49.9_1%_2  [R0201]  235.34 48.91 270 bottom
R1131  15_1%_2  [R0201]  236.05 48.91 270 bottom
R1132  100_1%_2  [R0201]  236.77 48.91 270 bottom
R1133  10K_1%_2  [R0201]  209.81 48.76 180 bottom
R1134  G3@100K_1%_2  [R0201]  200.41 48.48 270 bottom
R1135  *4.7K_1%_2  [R0201]  267.34 48.48 180 bottom
R1136  4.7K_1%_2  [R0201]  268.86 48.48 180 bottom
R1137  *Short_0402  [S0402]  20.29 48.13 90 bottom
R1138  *Short_0402  [S0402]  21.26 48.13 90 bottom
R1139  10K_1%_2  [R0201]  202.67 47.59 90 bottom
R1140  10K_1%_2  [R0201]  203.84 47.59 90 bottom
R1141  *4.7K_1%_2  [R0201]  267.34 47.59 180 bottom
R1142  4.7K_1%_2  [R0201]  268.86 47.59 180 bottom
R1143  *Short_0402  [S0402]  183.26 47.46 90 bottom
R1144  *Short_0402  [S0402]  184.28 47.46 90 bottom
R1145  *4.7K_1%_2  [R0201]  277.96 47.46 0 bottom
R1146  *110K_1%_2  [R0201]  186.45 47.09 0 bottom
R1147  *Short_0603  [S0603]  260.37 47 90 bottom
R1148  *Short_0603  [S0603]  261.89 47 90 bottom
R1149  *Short_0603  [S0603]  263.92 46.99 90 bottom
R1150  *Short_0603  [S0603]  265.44 46.99 90 bottom
R1151  *0_5%_4  [R0402]  189.76 46.88 90 bottom
R1152  *Short_0402  [S0402]  188.79 46.87 90 bottom
R1153  *4.7K_1%_2  [R0201]  267.34 46.7 180 bottom
R1154  4.7K_1%_2  [R0201]  268.86 46.7 0 bottom
R1155  *4.7K_1%_2  [R0201]  276.48 46.57 180 bottom
R1156  *4.7K_1%_2  [R0201]  277.96 46.57 0 bottom
R1157  *Short_0402  [S0402]  235.82 46.27 90 bottom
R1158  *4.7K_1%_2  [R0201]  212.66 46.13 270 bottom
R1159  *4.7K_1%_2  [R0201]  213.43 46.13 90 bottom
R1160  1K_1%_2  [R0201]  232.03 46.06 0 bottom
R1161  33_1%_2  [R0201]  217.55 45.83 270 bottom
R1162  33_1%_2  [R0201]  218.31 45.83 270 bottom
R1163  33_1%_2  [R0201]  219.1 45.83 270 bottom
R1164  *4.7K_1%_2  [R0201]  267.34 45.81 180 bottom
R1165  4.7K_1%_2  [R0201]  268.86 45.81 0 bottom
R1166  *4.7K_1%_2  [R0201]  276.48 45.68 180 bottom
R1167  *4.7K_1%_2  [R0201]  277.96 45.68 0 bottom
R1168  4.99K_1%_2  [R0201]  276.48 44.79 180 bottom
R1169  *Short_0402  [S0402]  268.94 43.75 180 bottom
R1170  *150K_1%_2  [R0201]  209.43 42.49 0 bottom
R1171  *Short_0402  [S0402]  278.13 41.87 180 bottom
R1172  *68.1K_1%_2  [R0201]  209.4 41.19 90 bottom
R1173  2.2K_1%_2  [R0201]  18.34 37.15 180 bottom
R1174  2.2K_1%_2  [R0201]  20.14 37.15 180 bottom
R1175  *Short_0201  [S0201]  16.26 34.2 270 bottom
R1176  *Short_0201  [S0201]  16.26 33.14 90 bottom
R1177  2.2K_1%_2  [R0201]  17.94 30.08 180 bottom
R1178  2.2K_1%_2  [R0201]  17.94 29.36 180 bottom
R1179  *1K_1%_2  [R0201]  26.42 26.07 180 bottom
R1180  1K_1%_2  [R0201]  25.17 26.05 270 bottom
R1181  *1K_1%_2  [R0201]  26.85 24.7 270 bottom
R1182  1K_1%_2  [R0201]  25.88 24.69 270 bottom
R1183  *1K_1%_2  [R0201]  16.52 23.34 0 bottom
R1184  100K_1%_2  [R0201]  26.3 23.21 180 bottom
R1185  100K_1%_2  [R0201]  26.3 22.45 180 bottom
R1186  20K_1%_2  [R0201]  16.47 22.36 0 bottom
R1187  5G_S@2.2K_1%_2  [R0201]  274.45 56.6 270 bottom
R1188  5G_S@2.2K_1%_2  [R0201]  282.2 55.46 270 top
R1189  *100K_1%_2  [R0201]  167.34 56.81 0 top
R1190  *100K_1%_2  [R0201]  173.08 54.95 180 top
R1191  *Short_0201  [S0201]  215.52 81.37 0 top
R1192  *Short_0402  [S0402]  195.46 50.38 90 top
R1193  *100K_1%_2  [R0201]  185.81 45.65 0 top
R1194  *10K_1%_2  [R0201]  196.73 49.87 0 top
R1195  *10K_1%_2  [R0201]  196.73 50.64 0 top
R1196  10K_1%_2  [R0201]  196.73 51.4 0 top
R1197  10K_1%_2  [R0201]  157.72 168.34 270 bottom
R1198  100K_1%_2  [R0201]  152.73 165.43 0 bottom
R1199  1.1K_1%_2  [R0201]  152.75 166.2 180 bottom
R1200  10K_1%_2  [R0201]  161.84 167.33 270 bottom
R1201  1.1K_1%_2  [R0201]  168.64 166.08 90 bottom
R1202  100K_1%_2  [R0201]  169.39 166.08 90 bottom
R1203  10K_1%_2  [R0201]  172.21 162.57 90 bottom
R1204  1.1K_1%_2  [R0201]  169.38 165.05 90 bottom
R1205  100K_1%_2  [R0201]  168.64 165.07 90 bottom
R1206  10K_1%_2  [R0201]  161.85 168.41 90 bottom
R1207  10K_1%_2  [R0201]  173.74 164.11 180 bottom
R1208  10K_1%_2  [R0201]  169.3 163.76 180 bottom
R1209  10K_1%_2  [R0201]  193.94 51.12 270 top
R1210  *Short_0402  [S0402]  192.76 53.15 0 top
R1211  4.7K_1%_2  [R0201]  254.49 211.93 90 top
R1212  *Short_0603  [S0603]  168.74 198.87 0 top
R1213  *Short_0603  [S0603]  168.68 200.5 0 top
R1214  *Short_0603  [S0603]  250.83 208.78 270 top
R1215  100K_1%_2  [R0201]  162.94 201.56 270 top
R1216  100K_1%_2  [R0201]  162.94 200.55 90 top
R1217  100K_1%_2  [R0201]  246.36 208.98 270 top
R1218  *Short_0201  [S0201]  31.75 95.47 180 bottom
R1219  *Short_0201  [S0201]  31.75 96.23 0 bottom
R1220  *Short_0201  [S0201]  24.01 79.72 270 bottom
R1221  *Short_0201  [S0201]  23.24 79.72 90 bottom
R1222  *0_5%_2  [R0201]  37.34 85.18 270 bottom
R1223  *0_5%_2  [R0201]  38.1 85.18 270 bottom
R1224  *0_5%_2  [R0201]  38.23 71.97 90 bottom
R1225  *0_5%_2  [R0201]  38.99 71.97 90 bottom
R1226  10K_1%_2  [R0201]  39.63 85.43 270 bottom
R1227  10K_1%_2  [R0201]  34.17 66.38 180 bottom
R1228  *Short_0805  [S0805]  276.61 179.64 0 bottom
R1229  *0_5%_2  [R0201]  285.75 186.14 180 bottom
R1230  *10K_1%_2  [R0201]  285.75 186.91 180 bottom
R1231  10K_1%_2  [R0201]  270.56 58.18 180 bottom
R1232  *5G@100K_1%_2  [R0201]  310.29 85.79 0 top
R1233  1.1K_1%_2  [R0201]  190.81 39.33 0 top
R1234  1.1K_1%_2  [R0201]  213.29 39.36 0 top
RG1  *Short_0201  [S0201]  226.53 215.25 270 top
RG2  *Short_0201  [S0201]  225.85 213.93 90 top
RG3  10K_1%_2  [R0201]  221.82 179.9 270 top
RG4  10K_1%_2  [R0201]  252.14 179.43 270 top
RG5  10K_1%_2  [R0201]  238.69 178.94 270 top
RG6  1K_1%_2  [R0201]  231.22 178.35 90 top
RG7  121_1%_2  [R0201]  216.94 177.48 180 top
RG8  121_1%_2  [R0201]  244.17 177.3 90 top
RG9  121_1%_2  [R0201]  246.3 176.89 270 top
RG10  10K_1%_2  [R0201]  230.58 176.8 270 top
RG11  10K_1%_2  [R0201]  227.96 176.78 270 top
RG12  121_1%_2  [R0201]  216.93 176.73 180 top
RG13  121_1%_2  [R0201]  248.04 176.04 0 top
RG14  121_1%_2  [R0201]  244.12 175.77 270 top
RG15  1K_1%_2  [R0201]  229.87 175.73 0 top
RG16  1K_1%_2  [R0201]  257.25 175.54 270 top
RG17  10K_1%_2  [R0201]  223.07 175.19 270 top
RG18  10K_1%_2  [R0201]  251.93 174.59 90 top
RG19  10K_1%_2  [R0201]  238.57 173.94 90 top
RG20  10K_1%_2  [R0201]  204.84 162 180 top
RG21  10K_1%_2  [R0201]  206.89 160.98 0 top
RG22  10K_1%_2  [R0201]  266.28 158.89 180 top
RG23  10K_1%_2  [R0201]  268.54 157.53 0 top
RG24  1K_1%_2  [R0201]  206.95 155.44 180 top
RG25  10K_1%_2  [R0201]  207.96 155.43 180 top
RG26  121_1%_2  [R0201]  267.52 154.2 270 top
RG27  121_1%_2  [R0201]  268.28 154.2 270 top
RG28  10K_1%_2  [R0201]  206.12 153.43 180 top
RG29  1K_1%_2  [R0201]  207.55 153.4 180 top
RG30  2.49K_1%_2  [R0201]  224.01 152.77 90 top
RG31  40.2_1%_2  [R0201]  226.21 152.53 270 top
RG32  121_1%_2  [R0201]  267.48 152.27 90 top
RG33  121_1%_2  [R0201]  268.25 152.27 90 top
RG34  40.2_1%_2  [R0201]  224.72 152.08 90 top
RG35  40.2_1%_2  [R0201]  226.58 151.63 180 top
RG36  10K_1%_2  [R0201]  270.51 146.74 180 top
RG37  10K_1%_2  [R0201]  204.67 146.26 0 top
RG38  10K_1%_2  [R0201]  264.75 145.86 0 top
RG39  10K_1%_2  [R0201]  209.79 145.43 180 top
RG40  121_1%_2  [R0201]  206.38 142.3 90 top
RG41  121_1%_2  [R0201]  208.11 140.81 0 top
RG42  1K_1%_2  [R0201]  267.79 139.83 0 top
RG43  121_1%_2  [R0201]  206.76 139.04 180 top
RG44  100K_1%_2  [R0201]  283.69 139.01 180 top
RG45  1.1K_1%_2  [R0201]  285.34 138.91 0 top
RG46  121_1%_2  [R0201]  207.85 136.94 270 top
RG47  100K_1%_2  [R0201]  277.14 136.4 0 top
RG48  10K_1%_2  [R0201]  272.44 136.27 90 top
RG49  100K_1%_2  [R0201]  277.14 135.63 0 top
RG50  10K_1%_2  [R0201]  208.91 134.02 270 top
RG51  10K_1%_2  [R0201]  205.65 133.35 180 top
RG52  10K_1%_2  [R0201]  272.44 132.71 90 top
RG53  100K_1%_2  [R0201]  277.12 132.68 0 top
RG54  2.2K_1%_2  [R0201]  251.5 132.63 180 top
RG55  10K_1%_2  [R0201]  277.12 131.92 0 top
RG56  1K_1%_2  [R0201]  243.79 131.78 90 top
RG57  1K_1%_2  [R0201]  245.9 130.85 180 top
RG58  1K_1%_2  [R0201]  241.58 130.43 270 top
RG59  10K_1%_2  [R0201]  272.38 129.85 0 top
RG60  100K_1%_2  [R0201]  277.14 129.16 0 top
RG61  100K_1%_2  [R0201]  277.14 128.4 0 top
RG62  10K_1%_2  [R0201]  278.53 125.98 90 top
RG63  10K_1%_2  [R0201]  280.42 123.91 0 top
RG64  *Short_0402  [S0402]  240.71 120.6 180 top
RG65  10K_1%_2  [R0201]  260.51 120.03 180 top
RG66  10K_1%_2  [R0201]  243.08 120.02 270 top
RG67  10K_1%_2  [R0201]  243.84 120.02 90 top
RG68  *Short_0201  [S0201]  244.72 119.35 0 top
RG69  100K_1%_2  [R0201]  243.71 119.16 0 top
RG70  1.1K_1%_2  [R0201]  292.21 118.83 180 top
RG71  XXX@100K_1%_2  [R0201]  260.72 118.79 180 top
RG72  XXX@100K_1%_2  [R0201]  261.58 118.59 90 top
RG73  100K_1%_2  [R0201]  246 118.43 180 top
RG74  100K_1%_2  [R0201]  247.15 118.43 0 top
RG75  *Short_0201  [S0201]  241.23 118.4 90 top
RG76  10K_1%_2  [R0201]  240.31 118.28 0 top
RG77  XXX@100K_1%_2  [R0201]  263.13 118.21 90 top
RG78  100K_1%_2  [R0201]  292.23 118.1 180 top
RG79  4.7K_1%_2  [R0201]  259.24 117.58 180 top
RG80  XXX@100K_1%_2  [R0201]  260.92 117.55 90 top
RG81  XXX@100K_1%_2  [R0201]  261.65 117.55 90 top
RG82  XXX@100K_1%_2  [R0201]  262.39 117.55 90 top
RG83  75K_1%_2  [R0201]  248.8 117.29 270 top
RG84  2K_1%_2  [R0201]  260.15 116.69 90 top
RG85  *Short_0201  [S0201]  256.09 116.68 90 top
