# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CNV_WR_LANE1_DN: length 96.8
  IN4 w0.086: v1(278.79,64.59) 278.79,64.48 278.5,64.19 277.85,64.19 277.59,64.45 277.59,64.84 277.36,65.07 276.84,65.07 276.58,64.81 276.58,62.5 276.76,62.32 277.7,62.32 277.78,62.23 277.78,62.01 277.7,61.92 276.76,61.92 276.58,61.74 276.58,59.36 276.42,59.2 276.42,58.86 273.51,55.96 270.17,55.96 268.84,54.63 262.96,54.63 261.04,52.71 253.45,52.71 252.58,51.83 249.59,51.83 249.15,51.39 243.81,51.39 241.88,53.33 238.99,53.33 238.05,54.27 237.78,54.27 236.47,55.58 236.47,56.16 236.23,56.4 235.84,56.4 235.67,56.23 235.55,56.23 235.34,56.44 235.34,56.56 235.58,56.8 235.58,57.06 235.2,57.43 234.94,57.43 234.89,57.37 234.76,57.37 234.56,57.57 234.56,57.71 234.61,57.76 234.61,58.02 233.36,59.27 233.05,59.27 232.26,60.06 232.26,60.37 230.71,61.92 230.71,62.79 230.8,62.88 231.11,62.88 231.29,63.06 231.29,63.62 231.11,63.81 230.8,63.81 230.71,63.89 230.71,64.5 231.07,64.86 231.07,66.8 230.77,67.1 230.34,67.1 230.25,67.18 230.25,67.75 230.66,68.16 230.66,69.69 230.46,69.89 230.46,70.27 230.8,70.61 v1(230.99,70.61)
  BOTTOM w0.102: U49.BD11 223.45,75.06 224.85,75.06 225.08,75.29 228.11,75.29 228.6,74.8 229.84,74.8 230.56,74.08 230.56,71.8 230.78,71.57 230.78,70.82 v1(230.99,70.61) ; CN12.9 279.86,62.99 279.35,62.48 278.37,62.48 277.83,63.01 277.83,64.01 278.2,64.38 278.58,64.38 v1(278.79,64.59)
CNV_WR_LANE1_DP: length 96.8
  IN4 w0.086: v1(229.93,70.63) 230.29,70.26 230.29,69.83 230.5,69.62 230.5,68.23 230.09,67.82 230.09,67.12 230.27,66.93 230.7,66.93 230.91,66.73 230.91,64.93 230.55,64.57 230.55,63.82 230.73,63.64 231.04,63.64 231.12,63.55 231.12,63.13 231.04,63.05 230.73,63.05 230.55,62.86 230.55,61.85 232.1,60.3 232.1,59.99 232.98,59.11 233.29,59.11 234.45,57.95 234.45,57.83 234.39,57.77 234.39,57.51 234.69,57.21 234.96,57.21 235.01,57.26 235.13,57.26 235.41,56.99 235.41,56.86 235.17,56.63 235.17,56.37 235.48,56.06 235.74,56.06 235.91,56.24 236.16,56.24 236.31,56.09 236.31,55.51 237.71,54.11 237.98,54.11 238.93,53.16 241.81,53.16 243.74,51.22 249.22,51.22 249.66,51.66 252.65,51.66 253.52,52.54 261.11,52.54 263.03,54.47 268.91,54.47 270.24,55.8 273.58,55.8 276.58,58.8 276.58,59.13 276.74,59.29 276.74,61.67 276.83,61.76 277.77,61.76 277.95,61.94 277.95,62.3 277.77,62.48 276.83,62.48 276.74,62.57 276.74,64.74 276.91,64.91 277.29,64.91 277.42,64.78 277.42,64.38 277.78,64.02 278.51,64.02 v1(278.79,63.74)
  BOTTOM w0.102: v1(278.79,63.74) 278.92,63.86 278.92,64.05 278.79,64.17 278.28,64.17 278.04,63.93 278.04,63.09 278.45,62.68 279.26,62.68 279.78,63.19 281.81,63.19 281.89,63.27 281.89,63.44 281.94,63.49 CN12.11 ; U49.BE11 223.45,74.68 223.45,74.76 223.53,74.85 224.93,74.85 225.17,75.09 228.03,75.09 228.52,74.6 229.76,74.6 230.36,74 230.36,71.71 230.58,71.49 230.58,70.6 230.46,70.47 230.08,70.47 v1(229.93,70.63)
CNV_WT_CLK_DN: length 97.3
  IN4 w0.086: v1(280.36,79.53) 280.71,79.53 280.83,79.41 280.83,79.13 280.49,78.8 279.56,78.8 278.09,77.33 278.09,75.96 275.68,73.55 275.68,71.56 275.35,71.23 275.35,70.97 275.59,70.73 275.59,70.53 275.45,70.39 275.27,70.39 275.02,70.64 274.76,70.64 274.33,70.21 274.33,69.95 274.48,69.8 274.48,69.68 274.27,69.47 274.15,69.47 274,69.62 273.74,69.62 272.17,68.05 272.17,65.83 271.65,65.3 271.21,65.3 270.72,64.81 270.72,60.07 269.76,59.11 268.86,59.11 267.44,57.69 261.51,57.69 260.82,57 257.8,57 257.08,56.27 251.13,56.27 250.73,55.88 244.57,55.88 243.72,56.73 243.72,57.87 243.26,58.33 241.58,58.33 240.81,59.09 240.29,59.09 239.44,59.95 239.44,60.43 235.65,64.22 235.65,67.21 234.72,68.14 234.72,71.28 230.58,75.43 228.06,75.43 226.99,76.5 224.2,76.5 222.03,74.33 221.28,74.33 220.64,73.69 220.36,73.69 220.23,73.82 220.23,73.94 v1(220.42,74.13)
  BOTTOM w0.102: v1(220.42,74.13) 220.39,74.1 U49.AW13
  BOTTOM w0.14: v1(280.36,79.53) 280.5,79.39 280.5,79.04 280.95,78.59 282.11,78.59 282.21,78.49 CN12.71
CNV_WT_CLK_DP: length 97.3
  IN4 w0.086: v1(281.21,79.53) 280.99,79.32 280.99,79.06 280.56,78.63 279.63,78.63 278.26,77.26 278.26,75.89 275.85,73.48 275.85,71.49 275.52,71.16 275.52,71.04 275.76,70.79 275.76,70.46 275.52,70.22 275.2,70.22 274.95,70.47 274.83,70.47 274.5,70.14 274.5,70.02 274.65,69.87 274.65,69.61 274.34,69.3 274.08,69.3 273.93,69.45 273.81,69.45 272.34,67.98 272.34,65.76 271.72,65.14 271.28,65.14 270.89,64.75 270.89,60 269.83,58.94 268.93,58.94 267.51,57.52 261.58,57.52 260.89,56.83 257.87,56.83 257.15,56.11 251.2,56.11 250.8,55.71 244.5,55.71 243.56,56.66 243.56,57.8 243.2,58.16 241.51,58.16 240.75,58.93 240.22,58.93 239.27,59.88 239.27,60.37 235.48,64.15 235.48,67.14 234.55,68.07 234.55,71.21 230.51,75.26 227.99,75.26 226.92,76.33 224.27,76.33 222.1,74.16 221.35,74.16 220.71,73.53 220.29,73.53 219.99,73.83 219.84,73.83 v1(219.79,73.78)
  BOTTOM w0.102: v1(219.79,73.78) 219.66,73.64 U49.AU14
  BOTTOM w0.14: CN12.73 282.22,78.99 282.09,78.86 281.06,78.86 280.76,79.15 280.76,79.4 280.95,79.59 281.15,79.59 v1(281.21,79.53)
CNV_WT_LANE0_DN: length 96.7
  IN4 w0.086: v1(280.36,78.16) 280.67,77.85 280.67,77.57 280.48,77.38 279.18,77.38 278.72,76.92 278.72,75.69 276.85,73.82 276.85,73.07 276.76,72.99 276.51,72.99 276.33,72.8 276.33,72.37 276.51,72.19 276.76,72.19 276.85,72.1 276.85,70.24 275.55,68.94 275.42,68.94 275.16,69.2 274.9,69.2 274.6,68.9 274.6,68.64 274.86,68.38 274.86,68.26 274.65,68.05 274.53,68.05 274.27,68.31 274.01,68.31 273.7,68 273.7,67.74 273.96,67.48 273.96,67.36 273.75,67.15 273.63,67.15 273.37,67.41 273.11,67.41 272.81,67.11 272.81,66.85 273.07,66.59 273.07,65.49 272.18,64.61 272.18,62.95 271.36,62.12 271.36,59.75 270.06,58.46 269.19,58.46 267.78,57.05 261.77,57.05 260.08,55.36 257.39,55.36 257.21,55.54 251.48,55.54 251.19,55.24 243.77,55.24 240.58,58.43 240.06,58.43 238.69,59.8 238.16,59.8 237.06,60.9 237.06,61.43 234.09,64.4 234.09,71.02 230.31,74.79 227.79,74.79 227.13,75.46 224.05,75.46 222.29,73.69 222.14,73.69 221.54,73.09 221.34,73.09 v1(221.14,73.29)
  BOTTOM w0.102: U49.BA14 221.52,73.29 v1(221.14,73.29)
  BOTTOM w0.14: v1(280.36,78.16) 280.46,78.06 280.46,77.62 280.78,77.3 281.88,77.3 282.19,76.99 CN12.65
CNV_WT_LANE0_DP: length 96.6
  IN4 w0.086: v1(221.54,72.56) 221.47,72.63 221.47,72.81 221.59,72.92 221.61,72.92 222.2,73.52 222.36,73.52 224.12,75.29 227.06,75.29 227.73,74.63 230.24,74.63 233.92,70.95 233.92,64.33 236.9,61.36 236.9,60.83 238.09,59.64 238.62,59.64 239.99,58.27 240.51,58.27 243.7,55.08 251.26,55.08 251.55,55.37 257.14,55.37 257.32,55.19 260.15,55.19 261.84,56.89 267.85,56.89 269.26,58.29 270.13,58.29 271.52,59.68 271.52,62.05 272.35,62.88 272.35,64.54 273.23,65.42 273.23,66.65 272.97,66.92 272.97,67.04 273.18,67.25 273.3,67.25 273.56,66.99 273.82,66.99 274.13,67.29 274.13,67.55 273.87,67.81 273.87,67.93 274.08,68.14 274.2,68.14 274.46,67.88 274.72,67.88 275.02,68.19 275.02,68.45 274.76,68.71 274.76,68.83 274.97,69.04 275.09,69.04 275.36,68.78 275.61,68.78 277.01,70.18 277.01,72.17 276.83,72.35 276.58,72.35 276.49,72.44 276.49,72.73 276.58,72.82 276.83,72.82 277.01,73 277.01,73.75 278.89,75.63 278.89,76.85 279.25,77.21 280.54,77.21 280.83,77.5 280.83,77.79 v1(281.21,78.16)
  BOTTOM w0.102: U49.AY15 221.22,72.56 v1(221.54,72.56)
  BOTTOM w0.14: CN12.67 282.07,77.49 281.99,77.57 280.89,77.57 280.73,77.73 280.73,77.95 280.98,78.2 281.17,78.2 v1(281.21,78.16)
CNV_WT_LANE1_DN: length 97
  IN4 w0.086: v1(220.53,72.94) 220.22,72.63 220.22,72.28 220.63,71.87 221.13,71.87 221.41,72.16 222.01,72.16 222.99,73.14 223.25,73.14 223.44,72.95 223.56,72.95 223.86,73.25 223.86,73.37 223.67,73.56 223.67,73.82 224.68,74.83 226.97,74.83 227.56,74.24 230.08,74.24 233.53,70.79 233.53,64.07 236.35,61.25 236.35,60.82 237.62,59.55 237.62,59.05 238.64,58.03 239.68,58.03 240.01,57.7 240.53,57.7 243.54,54.69 260.19,54.69 262.01,56.5 268.04,56.5 269.45,57.9 270.92,57.9 272.86,59.85 273.86,59.85 274.76,60.75 274.76,67.37 277.4,70.01 277.4,73.59 279.44,75.63 279.83,75.63 280.11,75.35 280.34,75.35 280.56,75.57 280.56,76.67 280.41,76.82 v1(280.08,76.82)
  BOTTOM w0.102: U49.AW15 220.35,72.76 v1(220.53,72.94)
  BOTTOM w0.14: CN12.59 280.87,75.49 280.2,76.16 280.2,76.7 v1(280.08,76.82)
CNV_WT_LANE1_DP: length 97
  IN4 w0.086: v1(219.82,72.7) 220.06,72.47 220.06,72.21 220.56,71.71 221.19,71.71 221.48,71.99 222.07,71.99 223.06,72.98 223.18,72.98 223.37,72.79 223.63,72.79 224.02,73.18 224.02,73.44 223.83,73.63 223.83,73.75 224.75,74.66 226.9,74.66 227.5,74.07 230.01,74.07 233.36,70.72 233.36,64 236.18,61.18 236.18,60.75 237.45,59.48 237.45,58.98 238.57,57.86 239.61,57.86 239.94,57.53 240.46,57.53 243.47,54.52 260.26,54.52 262.07,56.33 268.11,56.33 269.51,57.74 270.99,57.74 272.93,59.68 273.93,59.68 274.92,60.68 274.92,67.3 277.57,69.95 277.57,73.52 279.51,75.46 279.77,75.46 280.05,75.19 280.41,75.19 280.72,75.5 280.72,76.61 v1(280.93,76.82)
  BOTTOM w0.102: v1(219.82,72.7) 219.62,72.5 U49.AU16
  BOTTOM w0.14: CN12.61 282.07,75.99 281.83,75.76 280.98,75.76 280.46,76.27 280.46,76.63 280.69,76.86 280.89,76.86 v1(280.93,76.82)
CNV_WT_RCOMP: length 7.9
  BOTTOM w0.102: R949.2 228.57,74.26 228.14,74.69 227.54,74.69 227.18,74.33 227.18,73.51 226.83,73.16 225.77,73.16 225.38,73.55 225.38,73.65 224.84,74.18 224.15,74.18 223.97,73.99 223.41,73.99 U49.BE12
CPU_2_PCH_TRIG: length 182.7
  IN1 w0.086: v1(113.75,122.61) 116.25,125.11 116.25,136.07 122.19,142.01 122.19,144.5 v1(122.56,144.87)
  IN2 w0.089: v1(216.32,81.15) 216.32,81.11 215.79,80.58 213.92,80.58 213.39,81.11 212.86,81.11 212.56,80.81 209.47,80.81 209.05,81.24 208.1,81.24 207.68,81.66 206.6,81.66 205.79,82.46 205.79,83.02 204.58,84.24 203.86,84.24 203.77,84.15 203.77,83.58 202.26,82.08 201.26,82.08 200.9,82.43 200.9,84.42 200.85,84.47 200.25,84.47 196.04,80.27 192.3,80.27 191.49,81.08 190.18,81.08 188.93,79.84 171.37,79.84 170.35,78.82 169.98,78.82 169.34,79.47 151.85,79.47 150.58,78.2 149.78,78.2 148.49,76.9 145.13,76.9 144.97,77.06 143.02,77.06 142.87,76.9 139.22,76.9 136.76,79.36 131.16,79.36 130.48,78.67 129.93,78.67 129.54,79.06 129.54,80.08 127.51,82.11 121.21,82.11 119.03,84.29 119.03,94.91 116.62,97.32 116.62,102.06 115.73,102.95 115.73,111.4 113.14,113.99 113.14,120.33 114.33,121.52 114.33,122.02 v1(113.75,122.61)
  BOTTOM w0.102: U49.AL3 216.11,78.86 216.11,80.91 216.32,81.11 v1(216.32,81.15)
  BOTTOM w0.14: v1(122.56,144.87) 122.57,144.85 122.9,144.85 123.22,144.53 R800.1
CPU_C10_GATE#: length 168
  TOP w0.14: R70.1 203.02,187.42 v1(203.51,186.93) ; v1(212.04,102.76) 212.08,102.76 212.98,101.85 212.98,98.62 213.62,97.98 215.04,97.98 216.13,96.89 216.13,89.42 217.05,88.51 217.05,87.95 217.73,87.26 223.95,87.26 225.75,85.46 230.02,85.46 231.96,83.53 v1(231.96,81.59) 233.88,79.67 233.88,79.28 233.6,79.01 232.77,79.01 230.61,81.16 227.51,81.16 226.01,79.67 Q32.3 225.41,79.19 224.39,78.17 223.03,78.17 222.84,78.36 222.84,78.83 222.56,79.11 R310.2 222.33,78.95 221.89,78.52 R321.1
  IN2 w0.089: v1(189.32,168.78) 188.99,168.44 188.99,168.12 188.55,167.69 188.55,124.9 198.59,114.87 202.27,114.87 208.08,109.06 208.08,107.91 208.64,107.35 208.96,107.35 211.67,104.64 211.67,103.13 v1(212.04,102.76)
  IN3 w0.089: v1(189.32,168.78) 189.7,169.15 190.01,169.15 192.83,171.97 192.83,175.99 196.07,179.23 196.07,182.36 197.69,183.99 202.16,183.99 202.77,184.6 202.77,186.2 v1(203.51,186.93)
  BOTTOM w0.14: v1(189.32,168.78) 189.8,169.25 R751.1 194.14,168.92 193.79,168.57 Q93.2
CPU_EDP_HPD: length 227.7
  IN3 w0.089: v1(268.02,215.48) 267.92,215.37 267.92,214.93 268.16,214.69 268.16,214.06 268.47,213.75 270.83,213.75 271.29,214.21 274.91,214.21 275.69,213.43 275.69,212.02 275.88,211.84 276.38,211.84 277.12,211.1 278.23,211.1 280.39,208.93 281.83,208.93 282.93,207.84 282.93,201.63 285.28,199.28 285.28,189.56 285.35,189.49 285.35,186.2 284.76,185.61 284.76,183.43 285.35,182.84 285.35,172.88 284.78,172.31 284.78,154.96 281.47,151.65 281.47,119.38 277.43,115.34 270.65,115.34 270.05,115.94 269.48,115.94 268.45,114.91 265.52,114.91 262.14,111.53 251.96,111.53 251.39,110.97 240.35,110.97 240,111.31 213.81,111.31 213.46,110.97 213.46,110.23 212.97,109.74 212.97,108.96 212.94,108.93 212.94,107.31 213.04,107.22 213.04,97.75 213.06,97.72 213.06,94.88 214.61,93.34 214.61,88.11 215.94,86.78 216.54,86.78 216.85,86.48 216.85,86.1 217.51,85.44 218.97,85.44 219.28,85.13 222.15,85.13 223.04,84.24 223.04,82.69 v1(222.35,82)
  BOTTOM w0.102: R909.1 222.39,82.04 v1(222.35,82) 221.84,81.49 221.02,81.49 220.42,80.88 220.11,80.88 219.64,80.41 219.64,79.87 219.75,79.75 219.75,79.4 U49.AT2
  BOTTOM w0.14: R692.1 267.16,214.93 267.71,215.48 v1(268.02,215.48)
CPU_EDP_HPD_R: length 2.8
  BOTTOM w0.14: U37.2 266.36,212.88 266.18,213.06 266.18,213.75 R692.2
CPU_ID: length 5.2
  TOP w0.14: U23.126 170.31,74.64 R354.1 170.48,75.05 170.31,75.22 170.31,75.78 170.69,76.16 R344.2 170.54,76.32 v1(169.8,77.05)
CPU_ID_64314600: length 4.5
  BOTTOM w0.102: 125.22,129.57 127.8,129.57 U42.CT3
  BOTTOM w0.14: 125.22,129.57 123.87,129.57 TP111.1
CPU_PCI_BCLKN: length 103.6
  IN4 w0.086: v2(175.37,151.87) 175.22,151.87 175.08,152.01 175.08,152.18 175.21,152.31 176.18,152.31 176.94,151.54 176.94,151.26 176.38,150.7 176.38,150.36 176.81,149.93 177.06,149.93 177.64,150.5 177.76,150.5 178.06,150.2 178.06,150.08 177.49,149.51 177.49,149.25 177.88,148.86 178.14,148.86 178.71,149.43 178.83,149.43 179.13,149.13 179.13,149 178.56,148.44 178.56,148.18 178.99,147.75 179.25,147.75 179.54,148.04 179.66,148.04 179.96,147.74 179.96,147.62 179.67,147.33 179.67,147.07 180.06,146.67 180.32,146.67 180.9,147.25 181.07,147.25 181.32,147 181.32,146.83 180.74,146.25 180.74,145.99 181.14,145.6 181.4,145.6 181.93,146.14 182.2,146.14 182.36,145.97 182.36,145.72 181.82,145.18 181.82,144.92 182.25,144.49 182.51,144.49 182.65,144.64 182.77,144.64 183.07,144.34 183.07,144.22 182.93,144.07 182.93,143.81 183.32,143.42 183.58,143.42 183.86,143.7 183.99,143.7 184.13,143.56 184.13,143.12 184,142.99 184,142.74 185.72,141.02 185.72,128.88 191.79,122.81 191.79,113.99 196.03,109.74 196.03,107.24 196.7,106.58 196.7,106.02 197.51,105.21 199.03,105.21 199.44,104.79 199.44,102.96 200.8,101.6 200.8,98.37 200.04,97.61 200.04,96.04 198.77,94.77 198.77,85.46 199.58,84.64 200.69,84.64 200.85,84.48 200.85,84.01 201.12,83.74 201.6,83.74 201.73,83.62 201.73,83.46 v1(201.64,83.37)
  BOTTOM w0.102: U49.A5 201.49,77.37 201.41,77.37 200.95,77.82 200.95,78.94 201.15,79.14 201.15,83.58 201.32,83.75 201.51,83.75 201.64,83.62 v1(201.64,83.37) ; v2(175.37,151.87) 175.25,151.76 175.25,151.57 175.43,151.4 U42.B37
CPU_PCI_BCLKP: length 103.6
  IN4 w0.086: v2(174.73,151.87) 174.92,152.06 174.92,152.24 175.15,152.47 176.24,152.47 177.11,151.61 177.11,151.19 176.54,150.63 176.54,150.43 176.87,150.1 177,150.1 177.57,150.67 177.83,150.67 178.22,150.27 178.22,150.01 177.65,149.44 177.65,149.32 177.95,149.02 178.07,149.02 178.64,149.59 178.9,149.59 179.3,149.19 179.3,148.94 178.73,148.37 178.73,148.24 179.06,147.91 179.18,147.91 179.47,148.2 179.73,148.2 180.12,147.81 180.12,147.55 179.83,147.26 179.83,147.14 180.13,146.84 180.25,146.84 180.83,147.42 181.14,147.42 181.49,147.07 181.49,146.76 180.91,146.18 180.91,146.06 181.21,145.76 181.33,145.76 181.87,146.3 182.27,146.3 182.53,146.04 182.53,145.65 181.98,145.11 181.98,144.99 182.31,144.66 182.44,144.66 182.59,144.8 182.84,144.8 183.24,144.41 183.24,144.15 183.09,144 183.09,143.88 183.39,143.58 183.51,143.58 183.79,143.86 184.06,143.86 184.29,143.63 184.29,143.05 184.17,142.93 184.17,142.8 185.88,141.09 185.88,128.95 191.96,122.88 191.96,114.06 196.2,109.81 196.2,107.31 196.87,106.65 196.87,106.08 197.58,105.37 199.1,105.37 199.61,104.86 199.61,103.03 200.97,101.67 200.97,98.3 200.21,97.54 200.21,95.98 198.93,94.7 198.93,85.52 199.65,84.81 200.76,84.81 201.02,84.55 201.02,84.08 201.19,83.91 201.39,83.91 v1(201.63,84.14)
  BOTTOM w0.102: v2(174.73,151.87) 174.73,151.67 U42.C37 ; U49.A6 200.75,77.74 200.75,79.02 200.95,79.22 200.95,83.67 201.24,83.95 201.44,83.95 v1(201.63,84.14)
CPU_PLTRST#: length 5.3
  BOTTOM w0.102: TP142.1 211.05,82.44 R913.2 211.79,81.62 212.63,80.79 212.63,80.54 213.27,79.9 213.27,79.62 213.36,79.52 213.36,78.67 U49.AE3
CPU_PLTRST#R: length 188.6
  IN1 w0.086: v1(123.89,145.36) 123.89,145.19 123.31,144.62 122.91,144.22 122.91,142.06 116.73,135.88 116.73,122.86 114.56,120.69 114.56,98.08 112.36,95.88 112.36,91.34 v1(111.97,90.95)
  IN2 w0.089: v1(111.97,90.95) 112.42,90.5 112.42,90.08 111.68,89.34 111.68,79.92 112.93,78.67 116.47,78.67 117.47,77.67 120.62,77.67 121.44,76.85 128.95,76.85 129.7,77.6 137.56,77.6 138.94,76.23 143.18,76.23 143.57,75.84 144.73,75.84 145.12,76.23 148.76,76.23 150.06,77.53 150.86,77.53 151.36,78.02 152.68,78.02 153.45,78.79 169.06,78.79 170.11,77.74 172.46,77.74 173,78.27 173,78.7 173.47,79.17 183.57,79.17 184.51,78.22 195.64,78.22 198.32,80.91 199.46,80.91 199.84,80.53 200.9,80.53 201.26,80.17 201.26,79.79 201.91,79.13 205.58,79.13 206.29,78.42 209.17,78.42 210.26,79.5 212.59,79.5 212.97,79.89 212.97,80.6 v1(213.08,80.71)
  BOTTOM w0.079: 128.49,144.79 127.26,144.79 127.16,144.69
  BOTTOM w0.088: U42.CR25 128.49,144.79
  BOTTOM w0.102: v1(213.08,80.71) 212.24,81.55 R913.1
  BOTTOM w0.14: 127.16,144.69 126.71,144.69 126.2,145.2 124.05,145.2 v1(123.89,145.36)
CPU_RTC_CLK: length 177.6
  IN2 w0.089: v1(119.49,141.51) 119.49,140.19 114.23,134.94 112.89,134.94 112.2,134.25 112.2,127.11 111.17,126.07 111.17,121.49 112.76,119.9 112.76,113.84 115.35,111.24 115.35,102.79 116.24,101.9 116.24,97.16 118.65,94.76 118.65,84.13 121.05,81.73 127.35,81.73 129.16,79.92 129.16,78.9 130.09,77.97 137.61,77.97 139.06,76.52 143.03,76.52 143.18,76.67 144.81,76.67 144.97,76.52 148.64,76.52 149.94,77.82 150.74,77.82 152.01,79.09 169.18,79.09 170.21,78.05 172.36,78.05 172.6,78.29 172.6,78.84 173.21,79.46 187.9,79.46 188.31,79.06 195.5,79.06 198.13,81.69 199.65,81.69 200.13,81.21 201.08,81.21 201.56,81.7 202.77,81.7 204.37,83.29 205.15,83.29 205.6,82.84 205.6,79.52 206.41,78.71 209.05,78.71 210.89,80.55 211.74,80.55 v1(212.38,79.9)
  BOTTOM w0.102: v1(212.38,79.9) 212.38,79.83 U49.AD1
  BOTTOM w0.14: v1(119.49,141.51) 119.49,141.16 121.33,139.32 R808.1
CPU_RTC_CLK_R: length 7.7
  BOTTOM w0.102: U42.CR22 128.36,141.75 126.47,141.75 126.06,141.34 124.67,141.34 124.32,141 124.32,139.95 124.03,139.66
  BOTTOM w0.14: v1(123.69,138.53) R808.2 124.03,139.66
CPU_VCCIO_PWR_GATE#: length 7.1
  TOP w0.14: v1(220.3,76.26) 220.3,76.36 v1(220.75,76.82) 221.09,77.16 221.09,77.44 221.16,77.51 221.16,77.94 221.32,78.1 R320.1 221.32,79.1 R309.2 R310.1 221.88,79.34 222.18,79.64 223.02,79.64 223.41,79.25 Q32.1
  BOTTOM w0.102: U49.AV7 219.99,76.57 v1(220.3,76.26)
CRISIS_DISK_ENABLE: length 105.3
  TOP w0.14: R455.1 185.91,67.66 189.12,67.66 190.07,66.72 v1(190.79,66.72) ; R610.1 258.54,53.93 259.05,54.43 v1(259.05,55.9)
  IN3 w0.089: v1(190.62,50.77) 190.66,50.81 191.12,50.81 192.94,48.99 194.01,48.99 195.79,47.2 198.63,47.2 198.84,47 203.41,47 203.65,47.24 203.65,47.79 204.15,48.28 204.15,48.55 204.58,48.99 208.04,48.99 208.74,48.28 209.38,48.28 209.5,48.17 212.63,48.17 212.87,47.93 214.6,47.93 214.78,48.11 214.78,49.42 215.95,50.58 220.1,50.58 220.82,49.86 221.53,49.86 222.05,50.38 222.05,51.45 223.15,52.55 227.43,52.55 227.8,52.92 228.38,52.92 228.87,52.43 229.2,52.43 229.83,53.06 234.89,53.06 234.98,53.14 234.98,53.56 235.84,54.42 236.88,54.42 238.34,55.87 245.04,55.87 245.44,56.28 245.44,56.6 245.89,57.06 246.72,57.06 247.24,56.53 251.21,56.53 251.86,55.87 259.02,55.87 v1(259.05,55.9)
  BOTTOM w0.14: v1(190.62,50.77) 190.62,50.85 189.44,52.03 189.44,53.59 188.57,54.47 188.57,54.95 187.74,55.78 187.74,59.95 188.74,60.94 189,60.94 190.43,62.37 190.67,62.37 190.94,62.65 190.94,63.69 190.65,63.99 190.65,66.58 v1(190.79,66.72)
CSI_RCOMP: length 8.2
  BOTTOM w0.254: U42.R35 167.35,150.42 167.35,154.14 167.22,154.27 167.22,155.71 168.05,156.54 R776.1
CTL0_DP:
  vias: v1(27.16,23.81)
CTL1_DP: length 1.7
  TOP w0.14: 26.8,24.73 v1(26.8,25.49)
  BOTTOM w0.14: U56.23 25.11,23.68 v1(25.25,23.68)
CTL2_1: length 1.5
  TOP w0.14: U7.7 318.51,92.9 R172.2
CTL2_2: length 1.6
  TOP w0.14: U6.7 312.16,93.91 312.37,93.71 312.37,93.23 312.23,93.09 R168.2
CTL2_3: length 1.7
  BOTTOM w0.14: R1113.1 22.2,50.67 U52.7
CTL3_1: length 2.7
  TOP w0.14: U7.8 319.02,93.57 319.28,93.31 R173.2 320.14,92.9 v1(320.3,93.05)
CTL3_2: length 1.5
  TOP w0.14: R167.2 312.81,93.09 312.67,93.23 U6.8
CTL3_3: length 1.6
  BOTTOM w0.14: U52.8 21.7,50.21 R1114.1
DBG_PMODE: length 6.3
  TOP w0.14: R291.2 214.02,80.58 214.16,80.72 214.16,81.01 v1(214.29,81.14) 214.37,81.14 214.9,80.6 R290.1
  BOTTOM w0.102: v1(214.29,81.14) 214.21,81.06 214.21,80.71 213.88,80.39 213.88,79.87 214.14,79.6 214.14,79.1 214.34,78.91 214.34,78.11 214.49,77.96 214.49,77.37 U49.AG5
DC-DET: length 3.6
  TOP w0.14: 309.29,62.66 R505.1 ; 309.29,62.66 309.89,62.66 310.15,62.91 U20.13 ; 309.29,62.66 309.2,62.66 308.93,62.4 308.93,62.37 308.79,62.23 R503.1 307.7,62.23 307.53,62.06 R519.1
DCI_EN: length 3.5
  TOP w0.178: R486.1 R479.2 15.17,65.95 15.82,65.3 U24.12
DDR0_VREF_CA0: length 114
  TOP w0.508: C315.1 160.17,81.89 R279.1 161.07,81.36 162.11,82.39 162.11,83.27 162.59,83.76 v1(162.59,83.96)
  IN3 w0.508: v2(128.52,141.02) 127.45,139.94 125.58,139.94 125.22,139.58 124.48,139.58 120.73,135.84 120.73,122.8 120.01,122.07 120.01,110.14 117.4,107.53 117.4,104.38 v1(116.23,103.21)
  IN4 w0.508: v1(116.23,103.21) 116.92,102.53 116.92,95.6 122.24,90.29 162.89,90.29 164.09,89.09 164.09,85.59 163.5,85 163.1,85 162.59,84.49 v1(162.59,83.96)
  BOTTOM w0.305: U42.CR21 128.52,141.18 v2(128.52,141.02)
DDR1_VREF_CA0: length 107.4
  TOP w0.508: C256.1 169.76,90.04 R180.1 v1(169.49,91.43)
  IN3 w0.508: v1(124.75,140.73) 124,140.73 119.59,136.32 119.59,123.32 118.86,122.59 118.86,110.61 116.13,107.88 v1(116.13,104.74)
  IN4 w0.508: v1(169.49,91.43) 122.71,91.43 118.06,96.08 118.06,103 116.33,104.74 v1(116.13,104.74)
  BOTTOM w0.508: v1(124.75,140.73) 124.83,140.81 126.42,140.81 126.63,141.02 126.63,141.06
DDR4_DRAMRST#: length 126.1
  TOP w0.191: C183.2 147.59,98.38 v1(147.7,98.28) ; R613.1 211.74,53.88 v1(211.74,54.06) 211.34,54.47 TP78.1 ; v1(153.47,74.82) 153.47,76.23 v1(150.48,79.22)
  TOP w0.203: C295.2 147.71,84.62 v1(147.53,84.8)
  IN3 w0.127: v1(150.48,79.22) 150.48,80.25 149.91,80.83 148.14,82.6 148.14,84.19 v1(147.53,84.8) ; v1(192.92,63.01) 192.9,63.03 192.9,63.15 191.78,64.28 189.44,66.62 189.44,67.7 188.6,68.54 187.04,68.54 186.81,68.77 186.81,69.8 187.02,70 187.02,72.03 186.89,72.15 184.43,72.15 183.69,72.89 183.69,73.36 183.26,73.8 180.62,73.8 180.23,73.42 166.34,73.42 166.26,73.34 164.56,73.34 164.13,73.76 156.33,73.76 155.88,74.22 154.01,74.22 153.47,74.77 v1(153.47,74.82)
  IN4 w0.114: v1(192.92,63.01) 192.94,62.99 193.85,62.99 194.97,61.87 194.97,56.78 195.43,56.32 195.89,56.32 196.29,55.92 196.29,55.46 196.46,55.29 197.56,55.29 198.25,55.98 199.94,55.98 200.86,55.06 208.05,55.06 209.85,53.26 210.93,53.26 v1(211.74,54.06)
  BOTTOM w0.191: JDIM2.108 148.03,84.15 147.53,84.65 v1(147.53,84.8) 147.81,85.07 149.13,85.07 149.64,84.56 150.47,84.56 151.08,85.18 156.42,85.18 158.65,87.42 158.65,89.15 155.46,92.34 149.15,92.34 148.09,93.41 148.09,96.14 JDIM1.108 148.08,97.14 148.15,97.21 148.15,97.83 v1(147.7,98.28)
DDR4_DRAMRST#_PCH: length 8.8
  TOP w0.14: v1(210.9,51.68) 211,51.78 R613.2
  BOTTOM w0.102: R1104.2 210.99,51.59 v1(210.9,51.68) 210.74,51.68 210.48,51.94 210.48,52.77 210.68,52.97 210.94,52.97 211.52,53.56 211.81,53.56 212.15,53.89 212.15,56.21 212.03,56.32 212.03,56.47 212.21,56.64 212.21,56.94 U49.AC46
DDR4_SUSON_2V5: length 99
  TOP w0.14: R594.2 179.45,56 179.11,56.34 U23.57 179.11,58.83 v1(178.79,59.15)
  IN1 w0.086: v1(159.78,58.95) 160.27,58.46 161.14,58.46 161.98,57.62 163.12,57.62 163.63,58.12 166.28,58.12 166.48,58.32 167.13,58.32 167.76,58.95 177.03,58.95 177.23,58.75 178.39,58.75 v1(178.79,59.15)
  IN4 w0.086: v1(160.82,70.95) 160.82,70.95 160.89,70.88 164.59,70.88 164.96,70.52 167.37,70.52 168.51,71.66 178.51,71.66 178.82,71.35 179.45,71.35 179.71,71.61 184.85,71.61 185.53,72.29 186.82,72.29 187.05,72.52 188.23,72.52 188.5,72.79 190.27,72.79 197,79.52 197,96.5 v1(197.5,97.01)
  BOTTOM w0.14: v1(197.5,97.01) 197.15,97.01 PR539.1 ; v1(160.82,70.95) 160.82,70.95 160.76,71 160.76,71.4 160.55,71.61 159.8,71.61 159.53,71.35 159.53,65.54 160.51,64.57 160.51,59.67 v1(159.78,58.95)
DDR_THERMDA: length 6.1
  BOTTOM w0.14: U46.2 212.15,105.59 212.67,106.11 212.67,106.48 212.38,106.77 C689.1 212.38,107.52 Q101.3 210.89,109.01 Q101.2
DDR_THERMDC: length 5.6
  BOTTOM w0.14: Q101.1 212.56,109.82 212.56,108.06 212.83,107.79 C689.2 213.13,106.73 213.13,105.92 212.8,105.59 U46.3
DDR_VTT:
  vias: v1(105.67,52.46) v1(107.05,65.2) v1(107.73,65.19) v1(108.39,65.19) v1(117.96,44.1) v1(118.63,44.08) v1(187.61,83.91) v1(187.61,83.26) v1(187.96,98.11) v1(187.96,97.45) v1(188.27,83.91) v1(188.52,97.78)
DDR_VTT_CTRL: length 45.6
  TOP w0.14: R108.1 113.1,123.89 113.65,124.44 114.32,124.44 114.72,124.84 v1(114.72,140.31) 115.15,140.73 119.47,140.73 121.19,142.45 126.48,142.45 128.61,140.32 129.69,140.32 130.3,139.7 130.71,139.7 130.99,139.42 130.99,139.03 129.79,137.83 129.79,135.87 130.26,135.4 133.84,135.4 v2(134.35,135.91)
  BOTTOM w0.102: U42.CG12 134.03,135.56 134.35,135.88 v2(134.35,135.91)
DDR_VTTT_PG_CTRL: length 84.8
  TOP w0.254: Q17.3 111.38,118.2 111.64,118.45 112.34,118.45 112.81,117.97 R111.2 113.35,117.97 113.47,117.85 113.47,117.17 113.33,117.03 R113.2 R112.2 111.95,117.03 111.81,116.89 111.81,113.99 112.31,113.49 112.31,104.03 111.39,103.1 111.39,97.25 109.89,95.75 109.89,83.76 109.63,83.5 109.63,76.65 109.31,76.33 109.31,75.39 108.6,74.68 108.6,69.22 110.23,67.59 110.23,64.65 109.97,64.39 109.97,50.39 v1(110.76,49.6)
  IN2 w0.089: v1(111.03,41.58) 110.75,41.86 110.75,44.9 110.07,45.58 110.07,48.91 v1(110.76,49.6)
  BOTTOM w0.203: v1(111.03,41.58) PR651.1
DDSP_HPD1: length 184.5
  TOP w0.14: R325.1 219.73,77.53 219.98,77.28 219.98,76.89 219.71,76.62 219.07,76.62 v1(219.05,76.64) ; R185.2 66.29,90.08 66.55,90.34 66.55,90.89 65.88,91.57 65.88,93.53 67.42,95.06 73.19,95.06 88.83,79.42 97.42,79.42 v1(98.43,78.42)
  IN2 w0.089: v1(219.05,76.64) 217.13,76.64 216.46,75.97 216.46,75.27 216.15,74.96 215.77,74.96 215.42,75.31 215.42,75.61 215.08,75.95 213.83,75.95 213.36,75.48 213.36,74.68 212.14,73.46 211.76,73.46 210.85,72.55 210.85,71.92 210.26,71.34 209.88,71.34 209.43,70.89 208.16,70.89 207.47,71.59 206.94,71.59 205.64,70.29 203.06,70.29 202.05,69.28 200.39,69.28 198.67,70.99 194.97,70.99 192.3,73.67 190.98,73.67 190.72,73.4 188.28,73.4 187.28,74.4 181.92,74.4 180.84,75.48 173.62,75.48 173,74.87 169.87,74.87 169.79,74.79 166.45,74.79 165.98,75.26 164.59,75.26 163.96,74.63 161.67,74.63 158.72,77.58 153.87,77.58 153.16,76.87 151.84,76.87 151.34,76.37 150.54,76.37 149.24,75.07 145.6,75.07 145.21,74.68 143.09,74.68 142.7,75.07 138.46,75.07 137.08,76.45 131.81,76.45 131.05,75.69 119.62,75.69 119.62,75.69 116.41,75.69 114.59,77.51 112.19,77.51 111.63,78.07 110.85,78.07 109.5,79.42 105.04,79.42 104.98,79.36 103.16,79.36 101.64,77.84 99.01,77.84 v1(98.43,78.42)
  BOTTOM w0.079: v1(219.05,76.64) 219,76.69 219,77.11 219.14,77.25 219.14,77.46 219.03,77.57 219.03,77.57 218.92,77.68 218.92,77.94 219.2,78.22 U49.AU3
DDSP_HPD2: length 5.7
  TOP w0.14: R288.2 R301.1 218.13,79.82 218.7,80.38 v1(219.71,80.38) 220.22,80.38 v1(220.34,80.25)
  BOTTOM w0.102: v1(220.34,80.25) 220.16,80.07 220.16,79.24 219.63,78.7 219.63,78.15 U49.AU4
DDSP_HPD3: length 173.4
  TOP w0.14: v1(216.42,73.03) 216.57,73.03 216.85,72.75 R393.1 ; R209.2 66.5,86.15 67.19,86.83 67.19,87.04 67.88,87.74 68.94,87.74 68.96,87.72 71,87.72 71.16,87.56 71.16,85.15 74.85,81.45 79.42,81.45 82.18,78.7 v1(84.06,78.7)
  IN2 w0.089: v1(216.42,73.03) 216.06,73.39 214.86,73.39 214.79,73.32 212.8,73.32 212.52,73.04 212.52,72.76 211.86,72.1 211.86,71.87 211.51,71.51 211.51,71.24 211.23,70.96 210.04,70.96 209.58,70.5 207.52,70.5 207.47,70.55 207.11,70.55 206.89,70.32 206.89,70.3 206.88,70.29 206.88,70.08 206.55,69.74 204.29,69.74 204.13,69.91 203.22,69.91 202.21,68.89 200.23,68.89 198.52,70.61 194.75,70.61 192.07,73.28 191.14,73.28 190.88,73.02 188.12,73.02 187.12,74.02 181.72,74.02 180.64,75.1 173.78,75.1 173.37,74.69 173.37,74.3 172.92,73.86 168.47,73.86 167.91,74.41 166.29,74.41 165.83,74.88 165.18,74.88 164.55,74.25 161.51,74.25 160.82,74.94 159.42,74.94 158.55,75.81 158.55,76.27 157.62,77.2 154.04,77.2 153.33,76.49 152,76.49 151.5,75.99 150.7,75.99 149.4,74.69 145.76,74.69 145.36,74.3 142.93,74.3 142.54,74.69 138.26,74.69 136.89,76.07 131.97,76.07 131.21,75.31 119.46,75.31 119.46,75.31 116.25,75.31 115.03,76.53 108.73,76.53 106.29,78.98 103.32,78.98 101.8,77.46 94.38,77.46 91.96,79.88 89.68,79.88 87.93,78.13 87.4,78.13 86.76,78.78 84.14,78.78 v1(84.06,78.7)
  BOTTOM w0.102: U49.AP15 217.33,72.92 216.53,72.92 v1(216.42,73.03)
DDSP_HPD4: length 1.4
  TOP w0.203: R405.1 216.61,72.03 v1(216.41,72.03)
  BOTTOM w0.102: v1(216.41,72.03) 215.98,72.46 U49.AK15
DEVSLP0_HDD: length 80.6
  IN2 w0.089: v1(274.18,54.3) 272.81,55.67 266.75,55.67 264.62,53.54 251.84,53.54 251.48,53.19 245.21,53.19 244.56,52.54 235.5,52.54 234.23,53.8 232.84,53.8 232.83,53.8 232.12,53.8 231.63,54.28 228.66,54.28 227.97,54.98 225.45,54.98 224.86,54.4 220.88,54.4 220.78,54.5 220.36,54.5 220.04,54.18 216.3,54.18 215.39,55.09 215.39,55.49 214.94,55.93 212.39,55.93 212.07,56.26 208.45,56.26 207.44,57.26 207.44,57.28 v1(207.43,57.29)
  BOTTOM w0.102: U49.N47 207.31,56.44 207.58,56.71 207.58,57.12 207.44,57.26 207.44,57.28 v1(207.43,57.29)
  BOTTOM w0.14: R1112.1 278.4,50.75 278.19,50.97 274.8,50.97 274.04,51.73 274.04,54.12 274.18,54.27 v1(274.18,54.3)
DEVSLP0_R: length 2.7
  BOTTOM w0.14: CN18.1 279.83,47.95 279.58,48.2 279.58,48.8 R1112.2
DEVSLP_N1: length 3.9
  BOTTOM w0.14: CN6.38 100.5,84.48 v1(100.26,84.24) 99.79,83.77 R895.2 99,83.77 98.83,83.94 R894.1
DEVSLP_N2: length 3.5
  BOTTOM w0.14: CN13.38 100.43,59.43 v1(99.95,59.91) R1013.1
DEVSLP_SSD_PCH: length 132.9
  IN2 w0.089: v1(104.53,73.12) 104.63,73.02 104.63,72.92 110.4,67.14 118.8,67.14 123.33,71.67 134.46,71.67 134.95,71.19 141.83,71.19 142.01,71.37 146.29,71.37 146.48,71.19 150.53,71.19 150.87,71.53 156.57,71.53 156.58,71.52 158.99,71.52 159.98,70.53 162.01,70.53 165.03,70.53 165.79,69.77 169.87,69.77 169.99,69.65 172.74,69.65 173.27,70.19 174.54,70.19 175.68,69.05 177.95,69.05 178.84,68.15 179.64,68.15 180.33,67.45 181.31,67.45 181.66,67.8 184.23,67.8 184.51,67.52 185.57,67.52 186.51,66.57 186.51,66.31 188.31,64.52 190.29,64.52 190.66,64.15 190.66,64.06 190.85,63.87 191.45,63.87 191.63,64.05 193.85,64.05 195.18,62.72 198.66,62.72 199.08,63.14 200.4,63.14 200.8,62.75 200.8,62.43 201.38,61.84 202.07,61.84 204.76,59.15 205.78,59.15 206.09,58.84 206.09,58.17 v1(206.27,57.99)
  BOTTOM w0.102: v1(206.27,57.99) 206.29,57.99 206.63,57.64 U49.M45
  BOTTOM w0.14: v1(104.53,73.12) 104.53,72.01 104.02,71.5 103.46,71.5 102.14,72.82 100.81,72.82 99.03,74.59 99.03,76.42 97.62,77.83 97.62,78.91 97.29,79.24 97.29,81.03 98.47,82.21 R894.2
DGPU_EC_PROCHOT#: length 253.5
  TOP w0.14: U23.122 171.91,73.73 171.59,74.04 v1(171.59,74.45) ; v1(144.03,208.73) 144.22,208.93 PR62.2 ; v1(117.46,74.35) 113.63,78.19 113.63,80.03 113.25,80.41 113.25,94.41 v1(115.21,96.37)
  IN1 w0.086: v1(160.6,74.2) 160.95,73.86 171.01,73.86 v1(171.59,74.45)
  IN2 w0.089: v1(117.46,74.35) 118.04,74.93 131.37,74.93 132.13,75.69 136.73,75.69 138.11,74.31 142.38,74.31 142.78,73.91 145.52,73.91 145.91,74.31 149.56,74.31 150.86,75.61 151.66,75.61 152.16,76.11 153.49,76.11 154.19,76.81 157.46,76.81 158.17,76.11 158.17,75.65 159.46,74.35 160.45,74.35 v1(160.6,74.2) ; v1(115.21,96.37) 115.38,96.54 115.38,101.8 114.66,102.51 114.66,110.96 113.51,112.12 112.92,112.12 110.78,114.25 110.78,126.23 111.82,127.26 111.82,134.44 118.51,141.14 118.51,143.59 120.65,145.73 120.65,152.83 114.26,159.22 114.26,169.63 115.09,170.45 115.09,174.56 108.98,180.67 108.98,195.59 109.78,196.39 109.78,197.3 109.48,197.59 109.48,203.77 111.63,205.92 111.63,209.39 114.15,211.91 114.15,215.03 116.94,217.82 129.61,217.82 v1(130.5,216.93)
  IN3 w0.089: v1(144.03,208.73) 144.03,209.14 136.98,216.19 133.67,216.19 132.65,217.21 130.79,217.21 v1(130.5,216.93)
DGPU_HOLD_RST#: length 114.9
  TOP w0.14: UG1.1 242.95,115.44 242.24,116.15 v1(242.24,116.25)
  IN3 w0.089: v1(242.24,116.25) 242.08,116.09 238.62,116.09 238.38,115.85 237.52,115.85 236.52,116.85 233.15,116.85 232.38,117.62 226.54,117.62 225.62,116.69 217.66,116.69 216.54,115.57 212.01,115.57 207.31,110.88 207.31,106.46 204.25,103.4 204.05,103.4 202.07,101.42 202.07,98.99 199.65,96.57 199.65,95.67 197.95,93.97 197.95,88.01 196.94,86.99 196.94,77.27 196.79,77.12 196.79,66.99 197.18,66.6 197.18,64.41 196.88,64.11 196.88,60.24 198.91,58.21 198.91,55.76 198.99,55.67 v1(198.99,54.55)
  BOTTOM w0.102: 198.96,53.63 198.96,54.27 198.99,54.31 v1(198.99,54.55) 199.53,55.09 200.79,55.09 201.4,54.48 203.39,54.48 203.92,55 204.88,55 205.23,55.35 205.23,55.77 205.55,56.08 205.55,56.54 205.67,56.66 205.75,56.7 205.94,56.88 U49.L46
  BOTTOM w0.14: 198.96,53.63 TP166.1 198.96,51.36 199.16,51.17 R1089.1
DGPU_OPP#: length 6.2
  TOP w0.14: U23.71 184.6,61.3 184.68,61.22 C472.1 R520.2 186.99,61.22 187.53,61.76 188.72,61.76 189.11,61.36 Q50.2
DGPU_OPP#_PROCHOT#: length 297.1
  TOP w0.14: v1(137.55,208.14) 137.55,208.63 138.12,209.2 Q8.3 ; Q50.3 188.9,62.5 v1(188.7,62.7)
  IN2 w0.089: v1(185,79) 185.44,78.56 186.02,78.56 195.49,78.56 198.27,81.34 199.51,81.34 199.99,80.87 201.22,80.87 201.71,81.35 203.39,81.35 v1(204.89,82.85) ; v1(137.55,208.14) 137.57,208.17 137.7,208.17 140.72,205.15 140.72,202.44 144.12,199.04 144.12,198.09 146.93,195.29 154.39,195.29 155.81,193.87 160.31,193.87 161.29,194.85 164.25,194.85 165.64,193.46 166.52,193.46 167.44,192.55 167.44,191.21 168.54,190.11 168.54,185.25 167.85,184.56 167.85,176.68 168.23,176.3 168.23,174.4 169.31,173.32 177.71,173.32 183.94,167.09 183.94,164.24 187.47,160.71 187.47,124.46 198.14,113.79 201.83,113.79 207,108.62 207,107.33 209.07,105.26 209.07,104.32 210.59,102.81 210.59,101.6 210.89,101.29 v1(210.89,99.92)
  IN3 w0.089: v1(265.78,115.83) 261.95,112 251.76,112 251.2,111.44 240.54,111.44 240.19,111.78 213.62,111.78 212.99,111.16 212.99,110.42 212.5,109.93 212.5,109.17 212.47,109.14 212.47,107.12 212.57,107.02 212.57,105.19 212.01,104.63 212.01,104.46 211.29,103.73 211.29,100.32 v1(210.89,99.92) 210.89,97.8 210.39,97.29 209.68,97.29 209.48,97.5 208.35,97.5 203.8,92.95 203.8,89.84 203.8,89.84 203.8,88.57 204.95,87.43 204.95,82.91 v1(204.89,82.85)
  BOTTOM w0.14: v1(188.7,62.7) 188.18,62.7 186.91,63.97 186.91,67.11 184.75,69.26 184.75,71.57 185.55,72.37 185.55,74.58 184.74,75.39 184.74,77.82 185,78.08 v1(185,79) ; v1(265.78,115.83) 265.78,114.92 265.51,114.66 262.28,114.66 261.68,115.26 QG24.3
DGPU_OVT#: length 25.2
  IN1 w0.086: v1(253.4,115.07) 255.16,115.07 256.59,116.5 259.05,116.5 259.42,116.86 v1(259.42,116.9)
  IN2 w0.089: v1(262.33,128.11) 260.7,126.47 260.7,125.32 261.63,124.39 261.63,122.91 261.84,122.7 261.84,122.06 261.31,121.53 261.31,118.47 259.72,116.88 259.44,116.88 v1(259.42,116.9)
  BOTTOM w0.14: v1(259.42,116.9) 259.4,116.88 259.35,116.88 258.84,116.38 QG20.3 ; v1(262.33,128.11) 262.73,127.71 QG19.3 263.04,128 v1(263.53,128.49) 263.73,128.49 263.91,128.31 RG130.1 ; v1(253.4,115.07) 253.41,115.05 DG6.1
DGPU_PWR_EN: length 152.5
  TOP w0.14: UG3.2 237.65,111.93 238,111.57 245.03,111.57 245.4,111.93 245.4,114.19 246,114.79 246,115.27 245.86,115.41 245.39,115.41 245.09,115.71 245.09,116.27 244.94,116.42 244.53,116.42 244.18,116.77 v1(244.18,118.01)
  IN3 w0.089: v1(194.36,55.39) 194.36,57.28 196.16,59.07 196.16,62.06 195.7,62.51 195.7,66.03 195.34,66.39 195.34,77.72 195.49,77.87 195.49,87.59 196.51,88.61 196.51,98.49 197.36,99.34 198.03,99.34 199.76,101.07 200.35,101.07 200.62,101.34 200.62,102.02 203.45,104.85 203.65,104.85 205.86,107.06 205.86,111.48 211.41,117.02 215.94,117.02 217.06,118.14 225.01,118.14 225.94,119.06 231.39,119.06 233.57,121.24 234.19,121.24 234.55,120.89 235.91,120.89 238.5,118.3 239.61,118.3 239.93,118.62 241.88,118.62 242.45,119.19 243.74,119.19 244.18,118.76 v1(244.18,118.01)
  BOTTOM w0.102: U49.K47 205.78,56.02 205.44,55.68 205.44,55.26 204.97,54.8 204.22,54.8 203.7,54.27 201.32,54.27 200.71,54.88 199.62,54.88 199.4,54.66 199.4,54.38 199.31,54.29 199.31,53.59 199.3,53.59 199.3,53.29
  BOTTOM w0.14: UG9.1 243.45,117.87 243.59,118.01 v1(244.18,118.01) 244.18,119.9 243.79,120.28 243.79,121.65 242.86,122.58 UG8.1 ; 199.3,53.29 199.3,52.2 199.42,52.08 199.42,51.63 199.7,51.35 199.7,49.75 R1124.1 198.74,49.52 TP175.1 198.24,49.55 194.36,53.43 v1(194.36,55.39)
DGPU_PWROK: length 5.7
  TOP w0.14: QG9.2 238.64,117.1 238.99,116.75 238.99,116.49 239.4,116.08 RG87.2 239.59,115.66 240.26,114.99 QG13.1 240.97,114.99 241.77,114.19 QG14.3
DGPU_PWROK_Q: length 117.6
  TOP w0.14: QG13.3 239.42,115.18 239.28,115.32 239.28,115.81 v1(238.53,116.56)
  IN3 w0.089: v1(238.53,116.56) 237.95,117.14 233.27,117.14 232.5,117.91 226.42,117.91 225.49,116.98 217.54,116.98 216.42,115.87 211.89,115.87 207.02,111 207.02,106.58 204.13,103.69 203.93,103.69 201.78,101.54 201.78,99.11 199.36,96.69 199.36,95.79 197.66,94.09 197.66,88.13 196.65,87.11 196.65,77.39 196.5,77.25 196.5,66.87 196.89,66.48 196.89,64.53 196.59,64.24 196.59,58.89 195.2,57.5 195.2,56.47 195.64,56.03 195.64,55.75 v1(195.74,55.65)
  BOTTOM w0.102: U49.K46 205.34,56.66 205.34,56.17 205.03,55.85 205.03,55.47 204.76,55.2 203.71,55.2 203.19,54.68 201.49,54.68 200.88,55.29 199.08,55.29 198.59,54.79 198.59,54.01
  BOTTOM w0.14: 198.59,54.01 198.59,53.22 198.37,53 198.37,51.66 198.58,51.45 R1088.1 197.72,51.17 TP168.1 195.23,53.66 195.23,54.97 195.64,55.37 195.64,55.54 v1(195.74,55.65)
DGPU_THER_ALERT#: length 148.1
  TOP w0.14: R344.1 170.69,77.18 170.18,77.69 v1(170.18,79.22)
  IN1 w0.086: v1(204.2,84.64) 205.53,85.97 207.09,85.97 207.35,85.71 210.96,85.71 214.52,89.27 214.52,92.04 213.86,92.7 213.86,94.44 214.16,94.74 214.16,95.25 213.23,96.19 210.52,96.19 209.21,97.5 209.21,98.89 209.69,99.37 209.69,101.56 210.28,102.15 210.28,103.99 211.12,104.84 211.12,109.47 211.27,109.61 211.27,110.47 212.87,112.08 246.13,112.08 249.54,115.49 251.22,115.49 251.51,115.77 251.51,119.39 252.31,120.19 252.31,122.31 252.65,122.65 252.65,124.47 254.32,126.14 256.52,126.14 257.85,127.47 259.17,127.47 261.97,130.26 v1(264.26,130.26)
  IN2 w0.089: v1(204.2,84.64) 203.99,84.64 203.58,84.23 203.58,83.66 202.18,82.27 201.34,82.27 201.09,82.51 201.09,84.49 200.93,84.66 200.17,84.66 195.96,80.46 192.38,80.46 191.57,81.27 190.1,81.27 188.86,80.03 170.99,80.03 v1(170.18,79.22)
  BOTTOM w0.14: v1(264.26,130.26) 264.01,130.01 QG18.3
DIMM1_EVENT#: length 5.1
  TOP w0.14: R294.1 155.15,80.1 155.09,80.16 Q33.1 154.42,82.61 v1(154.34,82.69)
  BOTTOM w0.14: v1(154.34,82.69) 154.53,82.5 JDIM2.134
DIMM2_EVENT#: length 8.4
  TOP w0.203: Q19.1 154.53,94.87 154.39,94.73 R158.1 153.54,94.73 153.34,94.94 153.34,97.11 154.4,98.17 v1(155.1,98.17)
  BOTTOM w0.14: JDIM1.134 154.58,97.65 v1(155.1,98.17)
DISP_ON: length 112.4
  TOP w0.14: TP4.1 284.54,191.81 v1(284.68,191.67)
  IN2 w0.089: v1(262.91,127) 262.93,127.03 263.13,127.03 265.94,129.84 273.69,129.84 274.61,128.91 277.65,128.91 278.58,129.84 278.58,131.5 279.17,132.09 279.17,135.89 281.47,138.19 281.47,151.71 283.87,154.11 283.87,165.28 285.82,167.24 285.82,171.11 284.51,172.42 284.01,172.42 277.82,178.61 277.82,179.97 278.38,180.54 279.82,180.54 280.92,181.63 280.92,187.15 283.61,189.84 284.68,190.92 v1(284.68,191.67)
  BOTTOM w0.14: U44.4 264.96,123.72 264.66,124.01 263.49,124.01 263.21,124.3 263.21,125.48 262.86,125.82 R814.2 262.86,126.76 262.92,126.81 262.92,126.99 v1(262.91,127)
  BOTTOM w0.254: v1(284.68,191.67) 285.9,192.88 Q84.2 287.05,194.45 287.05,205.23 286.72,205.55 R715.1
DMI_RCOMP_N: length 6.1
  TOP w0.14: R107.1 172.8,131 173.34,130.46 173.34,129.84 173.53,129.66 173.97,129.66 174.22,129.91 174.22,130.41 v2(174.72,130.91)
  BOTTOM w0.102: U42.C5 174.72,131.01 v2(174.72,130.91)
DMI_RCOMP_P: length 6.1
  TOP w0.14: R107.2 171.08,130.55 171.26,130.73 172.69,130.73 173.07,130.35 173.07,129.73 173.42,129.39 174.08,129.39 174.49,129.8 174.49,130.09 v2(174.62,130.22)
  BOTTOM w0.102: v2(174.62,130.22) 174.65,130.19 174.98,130.19 175.08,130.29 175.08,130.44 U42.C4
DMI_RXN0: length 85.1
  BOTTOM w0.079: 180.34,125.59 180.34,125.61 180.28,125.67 180.28,126.09 178.06,128.31 178.06,129.48 177.6,129.93 177.6,131.55 176.63,132.52 176.04,132.52 175.94,132.63 175.94,132.99 176.02,133.07 176.23,133.07 176.31,132.99 U42.A8
  BOTTOM w0.102: 197.87,64.61 197.87,64.61 197.9,64.64 199.02,63.51 200.53,63.51 201.1,64.08 201.75,64.08 201.83,64.16 201.83,64.27 201.9,64.34 202.11,64.34 202.21,64.24 U49.C32
  BOTTOM w0.14: 180.34,125.59 180.34,123.13 184.49,118.98 184.49,113.15 190.45,107.19 190.45,96.81 188.86,95.22 188.86,88.11 190.96,86.01 190.96,82.42 192.9,80.49 192.9,70.53 194.2,69.23 194.2,68.28 197.87,64.61
DMI_RXN1: length 85.4
  BOTTOM w0.079: 181.07,125.59 181.07,125.61 181.01,125.67 181.01,126.02 178.6,128.44 178.6,129.75 178.11,130.23 178.11,131.87 176.6,133.38 175.43,133.38 175.29,133.52 175.29,133.93 175.36,134.01 175.58,134.01 175.66,133.93 U42.B9
  BOTTOM w0.102: U49.C30 202.27,64.75 201.72,64.75 201.5,64.52 200.39,64.52 200.28,64.63 198.9,64.63 197.9,65.64 197.87,65.62 197.87,65.62
  BOTTOM w0.14: 181.07,125.59 181.07,123.44 185.2,119.31 185.2,113.57 191.22,107.55 191.22,96.44 189.58,94.8 189.58,88.51 191.75,86.34 191.75,82.7 193.61,80.85 193.61,71.01 196.22,68.4 196.22,67.27 197.87,65.62
DMI_RXN2: length 85.7
  BOTTOM w0.079: 181.61,126.32 181.6,126.33 181.52,126.33 179.13,128.72 179.13,129.97 178.59,130.51 178.59,132.02 177.41,133.2 177.41,133.92 177.09,134.24 176.56,134.24 176.45,134.13 176.1,134.13 175.94,134.29 175.94,134.56 176.02,134.64 176.21,134.64 176.31,134.55 U42.A10
  BOTTOM w0.102: U49.D30 202.81,65.13 202.88,65.2 202.88,65.28 202.79,65.37 202.6,65.37 202.43,65.2 202.07,65.2 202.02,65.15 201.5,65.15 201.34,64.99 200.57,64.99 200.2,65.36 199.8,65.36 199.2,65.95 198.66,65.95 198.08,66.54 198.08,66.59 198.06,66.6
  BOTTOM w0.14: 198.06,66.6 196.93,67.73 196.93,68.83 194.32,71.44 194.32,81.15 192.49,82.98 192.49,86.69 190.3,88.87 190.3,94.5 191.97,96.17 191.97,107.88 185.91,113.94 185.91,119.61 181.88,123.64 181.88,126.06 181.61,126.32
DMI_RXN3: length 85.8
  BOTTOM w0.079: U42.B11 175.66,135.3 175.58,135.38 175.33,135.38 175.29,135.33 175.29,135.11 175.25,135.08 175.25,134.97 175.33,134.89 175.74,134.89 175.81,134.96 176.57,134.96 176.75,134.78 177.3,134.78 177.92,134.16 177.92,133.35 179.07,132.2 179.07,130.77 179.71,130.13 179.71,129.07 181.4,127.38 181.54,127.38 181.59,127.43 181.61,127.43
  BOTTOM w0.102: 198.06,67.62 198.08,67.6 198.08,67.55 198.28,67.35 198.28,67.19 198.81,66.66 199.59,66.66 200.85,65.4 201.17,65.4 201.37,65.59 201.73,65.59 201.82,65.69 202.03,65.69 U49.B29
  BOTTOM w0.14: 181.61,127.43 181.93,127.43 182.65,126.71 182.65,123.94 186.62,119.97 186.62,114.43 192.7,108.36 192.7,95.76 191.07,94.14 191.07,89.2 193.3,86.98 193.3,83.34 195.07,81.57 195.07,71.81 197.66,69.22 197.66,68.02 198.06,67.62
DMI_RXN4: length 86.9
  BOTTOM w0.079: U49.D29 203.19,65.68 203.3,65.79 203.3,66.04 203.18,66.16 202.93,66.16 202.85,66.08 202.01,66.08 201.68,66.4 200.85,66.4 198.81,68.44 198.81,69.11 198.36,69.56 198.36,69.65 198.32,69.68 ; 181.61,128.36 181.59,128.36 181.54,128.31 181.24,128.31 180.19,129.36 180.19,130.29 179.56,130.93 179.56,132.34 178.3,133.6 178.3,134.64 177.24,135.7 175.14,135.7 175.12,135.68 174.07,135.68 173.97,135.77 173.97,135.9 174.05,135.98 U42.D13
  BOTTOM w0.14: 181.61,128.36 182.4,128.36 183.36,127.4 183.36,124.27 187.33,120.3 187.33,114.82 193.41,108.75 193.41,94.72 194.01,94.12 194.01,83.77 195.78,82 195.78,72.23 198.32,69.68
DMI_RXN5: length 84
  BOTTOM w0.079: 181.61,128.94 181.6,128.94 181.59,128.95 181.59,128.96 181.5,129.05 181.1,129.05 180.62,129.54 180.62,130.28 179.86,131.05 179.86,132.45 178.65,133.66 178.65,134.93 177.93,135.65 177.82,135.65 177.75,135.59 177.62,135.59 177.49,135.71 177.49,135.82 177.57,135.9 177.57,136.01 177.47,136.11 177.07,136.11 176.99,136.03 176.99,135.93 176.92,135.87 176.74,135.87 176.68,135.92 176.68,136.04 176.61,136.11 176.38,136.11 176.31,136.03 U42.A13
  BOTTOM w0.102: 198.73,69.95 198.75,69.94 198.79,69.94 199.11,69.62 199.11,68.45 200.91,66.65 201.95,66.65 202.07,66.54 202.39,66.54 202.44,66.49 202.44,66.35 202.37,66.28 202.24,66.28 U49.C27
  BOTTOM w0.14: 181.61,128.94 182.72,128.94 183.81,127.85 183.81,124.49 187.78,120.52 187.78,115.02 193.88,108.92 193.88,94.88 194.47,94.29 194.47,84.13 196.23,82.37 196.23,72.46 196.63,72.06 198.73,69.95
DMI_RXN6: length 87.1
  BOTTOM w0.079: 181.61,129.65 181.59,129.65 181.54,129.71 181.36,129.71 181.16,129.91 181.16,130.42 180.34,131.24 180.34,132.61 179.08,133.86 179.08,135.23 177.89,136.43 175.95,136.43 175.81,136.29 175.06,136.29 174.93,136.43 174.17,136.43 173.97,136.63 173.86,136.63 173.65,136.43 173.53,136.43 173.4,136.3 173.26,136.3 173.18,136.38 173.18,136.59 173.52,136.92 173.65,136.92 U42.E14
  BOTTOM w0.102: U49.C26 202.21,67.06 201.25,67.06 199.52,68.78 199.52,69.92 199.2,70.24 199.2,70.69 199,70.88 198.97,70.88
  BOTTOM w0.14: 181.61,129.65 183.12,129.65 184.52,128.25 184.52,124.82 188.49,120.85 188.49,115.32 194.69,109.12 194.69,95.17 195.2,94.66 195.2,84.43 196.96,82.67 196.96,72.9 198.97,70.88
DMI_RXN7: length 84.1
  BOTTOM w0.079: 181.42,130.79 181.41,130.81 181.41,130.88 180.82,131.47 180.82,132.91 179.6,134.13 179.6,135.43 178.03,137 177.78,137 177.45,137.33 177.03,137.33 176.85,137.15 175.51,137.15 175.31,136.95 175.31,136.76 175.39,136.68 175.58,136.68 175.66,136.76 U42.B14
  BOTTOM w0.102: U49.A25 201.59,67.5 201.69,67.6 201.69,67.79 201.58,67.91 201.48,67.91 200.16,69.22 200.16,69.81 199.97,70 199.97,71 199.04,71.93 198.99,71.93 198.97,71.95
  BOTTOM w0.14: 181.42,130.79 181.82,130.4 183.38,130.4 185.23,128.55 185.23,125.3 189.2,121.34 189.2,115.72 195.42,109.5 195.42,95.46 195.91,94.96 195.91,84.96 197.68,83.2 197.68,73.25 198.72,72.2 198.97,71.95
DMI_RXP0: length 85.1
  BOTTOM w0.079: U42.B8 175.78,132.57 175.98,132.37 176.56,132.37 177.45,131.48 177.45,129.86 177.9,129.41 177.9,128.25 180.13,126.02 180.13,125.67 180.07,125.61 180.07,125.59
  BOTTOM w0.102: 197.87,64.35 197.89,64.35 197.9,64.35 198.94,63.31 200.61,63.31 201.19,63.88 202.56,63.88 202.68,63.97 U49.D32
  BOTTOM w0.14: 197.87,64.35 197.76,64.35 193.93,68.17 193.93,69.12 192.63,70.42 192.63,80.38 190.7,82.31 190.7,85.9 188.6,88 188.6,95.33 190.19,96.92 190.19,107.08 184.28,112.99 184.22,113.04 184.22,118.87 180.08,123.01 180.08,123.05 180.07,123.06 180.07,125.59
DMI_RXP1: length 85.5
  BOTTOM w0.079: U42.C9 175.13,133.54 175.13,133.46 175.36,133.22 176.54,133.22 177.96,131.8 177.96,130.17 178.44,129.69 178.44,128.38 180.86,125.96 180.86,125.67 180.8,125.61 180.8,125.59
  BOTTOM w0.102: U49.D31 202.51,64.61 202.44,64.54 201.8,64.54 201.58,64.32 200.31,64.32 200.2,64.43 198.82,64.43 197.9,65.35 197.89,65.35 197.87,65.35
  BOTTOM w0.14: 197.87,65.35 197.76,65.35 195.95,67.16 195.95,68.29 193.34,70.9 193.34,80.74 191.48,82.59 191.48,86.23 189.31,88.4 189.31,94.91 190.95,96.55 190.95,107.44 184.93,113.46 184.93,119.2 180.8,123.33 180.8,125.59
DMI_RXP2: length 85.7
  BOTTOM w0.079: U42.B10 175.78,134.33 175.78,134.23 176.03,133.97 176.51,133.97 176.63,134.08 177.02,134.08 177.25,133.85 177.25,133.85 177.25,133.14 178.43,131.96 178.43,130.45 178.97,129.91 178.97,128.66 181.41,126.22 181.41,126.14 181.42,126.13
  BOTTOM w0.102: 197.87,66.42 197.89,66.4 197.93,66.4 198.58,65.75 199.12,65.75 199.71,65.15 200.11,65.15 200.48,64.78 201.42,64.78 201.59,64.95 202.1,64.95 202.15,65 202.45,65 202.55,64.91 202.93,64.91 203.25,65.23 U49.E30
  BOTTOM w0.14: 197.87,66.42 196.66,67.62 196.66,68.72 194.05,71.33 194.05,81.04 192.22,82.87 192.22,86.58 190.03,88.76 190.03,94.61 191.71,96.28 191.71,107.77 185.64,113.83 185.64,119.49 181.61,123.53 181.61,125.94 181.42,126.13
DMI_RXP3: length 85.9
  BOTTOM w0.079: U42.C11 175.01,135.23 175.09,134.9 175.26,134.73 175.81,134.73 175.88,134.8 176.51,134.8 176.68,134.62 177.24,134.62 177.76,134.1 177.76,133.28 178.92,132.13 178.92,130.7 179.56,130.06 179.56,129.01 181.34,127.22 181.54,127.22 181.59,127.17 181.61,127.17
  BOTTOM w0.102: U49.C29 202.58,65.58 202.31,65.46 202.21,65.41 202.16,65.4 201.81,65.4 201.75,65.39 201.45,65.39 201.26,65.2 200.76,65.2 199.5,66.46 198.72,66.46 198.07,67.11 198.07,67.27 197.93,67.41 197.89,67.41 197.87,67.43
  BOTTOM w0.14: 197.87,67.43 197.39,67.91 197.39,69.11 194.8,71.7 194.8,81.46 193.03,83.22 193.03,86.87 190.81,89.09 190.81,94.25 192.43,95.87 192.43,108.25 186.36,114.32 186.36,119.86 182.39,123.83 182.39,126.6 181.82,127.17 181.61,127.17
DMI_RXP4: length 86.9
  BOTTOM w0.079: U42.E13 173.82,135.86 173.82,135.71 174.01,135.52 175.18,135.52 175.2,135.54 177.18,135.54 178.14,134.57 178.14,133.53 179.4,132.28 179.4,130.86 180.03,130.23 180.03,129.29 181.17,128.15 181.54,128.15 181.59,128.09 181.61,128.09 ; U49.E28 203.54,65.81 203.22,65.49 202.96,65.49 202.84,65.6 202.84,65.7 202.66,65.88 202.63,65.92 201.95,65.92 201.62,66.24 200.78,66.24 198.65,68.38 198.65,69.05 198.22,69.47 198.16,69.47 198.14,69.5
  BOTTOM w0.14: 181.61,128.09 182.29,128.09 183.1,127.29 183.1,124.16 187.07,120.19 187.07,114.71 193.14,108.64 193.14,94.61 193.74,94.01 193.74,83.66 195.52,81.89 195.52,72.12 198.14,69.5
DMI_RXP5: length 84.1
  BOTTOM w0.079: U42.B13 176.15,136.27 177.53,136.27 177.66,136.15 178.81,135 178.81,133.72 180.01,132.52 180.01,131.11 180.78,130.35 180.78,129.6 181.17,129.21 181.61,129.21
  BOTTOM w0.102: 198.92,70.14 198.94,70.13 198.94,70.08 199.32,69.7 199.32,68.53 200.99,66.86 202.04,66.86 202.15,66.74 202.47,66.74 202.64,66.57 202.64,66.38 U49.D27
  BOTTOM w0.14: 198.92,70.14 196.49,72.57 196.49,82.48 194.73,84.25 194.73,94.4 194.15,94.99 194.15,109.03 188.04,115.14 188.04,120.63 184.08,124.6 184.08,127.97 182.83,129.21 181.61,129.21
DMI_RXP6: length 87.2
  BOTTOM w0.079: 181.61,129.92 181.59,129.92 181.54,129.87 181.43,129.87 181.32,129.98 181.32,130.48 180.5,131.31 180.5,132.67 179.24,133.93 179.24,135.3 177.95,136.59 175.88,136.59 175.75,136.45 175.13,136.45 174.99,136.59 174.24,136.59 174.04,136.78 173.95,137 173.92,137.05 173.82,137.15 173.62,137.15 U42.F14
  BOTTOM w0.102: U49.D26 202.83,66.81 202.38,67.26 201.33,67.26 199.72,68.87 199.72,70.01 199.4,70.33 199.4,70.77 199.16,71.01 199.16,71.07
  BOTTOM w0.14: 199.16,71.07 197.23,73.01 197.23,82.78 195.47,84.54 195.47,94.77 194.96,95.28 194.96,109.23 188.76,115.43 188.76,120.96 184.79,124.93 184.79,128.36 183.23,129.92 181.61,129.92
