# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on IN4 (solid shape): 219.79,49.37 219.79,47.89 219.24,47.34 215.56,47.34 215.49,47.42 215.49,49.05 216.62,50.18 218.98,50.18
GND on IN4 (solid shape): 33.53,83.05 33.53,81.29 33.42,81.11 33.39,80.91 33.42,80.71 33.53,80.54 33.53,79.77 33.3,79.54 32.64,79.54 32.31,79.87 30.79,79.87 30.31,79.39 29.7,79.39 28.91,80.18 28.91,82.46 29.23,82.78 29.23,83.26 29.91,83.94 32.64,83.94
GND on IN4 (solid shape): 259.46,121.42 259.46,118.96 259.34,118.83 257.85,118.83 257.75,118.88 257.65,118.9 257.55,118.88 257.45,118.83 255.78,118.83 255.68,118.74 255.66,118.72 255.62,118.73 255.46,118.77 255.29,118.74 255.26,118.73 255.23,118.75 255.15,118.83 255.15,119.47 255.64,119.97 255.64,121.75 255.78,121.88 259,121.88
GND on IN4 (solid shape): 38.1,100.73 38.1,98.2 38,98.03 37.96,97.83 38,97.63 38.1,97.46 38.1,97.14 38.09,97.11 38.05,97.09 37.82,97.09 37.79,97.1 37.77,97.13 37.43,97.4 37.08,97.13 37.06,97.1 37.03,97.09 36.93,97.09 36.88,97.14 35.36,97.14 35.31,97.09 35.09,97.09 35.06,97.1 35.04,97.13 34.69,97.4 34.35,97.13 34.33,97.1 34.3,97.09 33.84,97.09 33.48,97.45 33.48,100.69 33.87,101.08 37.76,101.08
GND on IN4 (solid shape): 277.51,171.03 277.52,171.01 277.76,170.73 278.12,170.82 278.22,170.85 278.29,170.79 278.46,170.6 278.71,170.57 278.79,170.55 278.83,170.47 278.83,168.85 278.82,168.82 278.79,168.8 278.49,168.45 278.79,168.1 278.82,168.08 278.83,168.05 278.83,166.62 278.82,166.58 278.79,166.57 278.5,166.3 278.64,165.93 278.66,165.89 278.63,165.85 278.5,165.48 278.79,165.21 278.82,165.19 278.83,165.16 278.83,155.34 278.68,155.19 277.11,155.19 276.61,155.69 276.61,168.95 276.61,168.95 276.61,170.27 277.4,171.06 277.49,171.06
GND on IN4 (solid shape): outline of 99 points within 224.16,175.63 226.64,179.11
GND on IN4 (solid shape): outline of 172 points within 0.51,0.51 298.62,67.27
GND on IN4 (solid shape): outline of 2262 points within 0.51,57.17 322.89,222.04
GND on SGND3 (solid shape): outline of 16567 points within 0.51,0.51 322.89,222.04
VCC3V3_FLASH on TOP (solid shape): 46.06,83.42 46.06,81.55 45.65,81.13 45.65,80.73 45.75,80.63 46.08,80.63 46.13,80.58 46.13,79.59 46.04,79.5 44.48,79.5 44.48,80.58 44.51,80.61 44.51,82.45 45.55,83.48 45.99,83.48
VCC3V3_FLASH on TOP (solid shape): 51.47,99.92 51.47,99.59 51.49,99.52 51.54,99.47 51.55,99.47 51.68,99.34 52.37,99.34 53.04,98.67 53.15,98.67 53.24,98.62 53.35,98.6 53.39,98.6 53.43,98.61 53.52,98.59 53.56,98.51 53.55,98.39 53.56,98.34 53.56,97.94 53.55,97.89 53.56,97.84 53.56,97.3 52.89,96.63 52.89,95.46 51.35,93.92 50.76,93.92 50.35,93.51 50.02,93.51 49.83,93.32 49.83,92.79 49.71,92.67 49.44,92.67 49.33,92.57 49.33,91.78 49.35,91.76 49.35,90.54 49.04,90.23 47.98,90.23 47.95,90.24 47.93,90.28 47.93,90.55 47.84,90.64 47.84,91.71 48.06,91.93 48.06,91.94 48.07,91.95 48.07,93.29 48.31,93.53 48.31,94.02 48.45,94.16 48.45,94.21 49.11,94.86 50.38,94.86 50.56,95.05 50.71,95.05 50.81,95.09 50.85,95.19 50.85,96 50.81,96.1 50.71,96.14 50.58,96.14 50.58,99.81 50.77,100 51.37,100
VCC3V3_FLASH on BOTTOM (solid shape): 54.34,98.64 54.41,98.64 54.45,98.64 54.69,98.64 54.83,98.51 54.83,97.52 54.72,97.41 54.66,97.42 53.29,97.42 53.25,97.41 53.21,97.39 53.2,97.39 51.84,97.39 51.82,97.39 51.78,97.41 51.74,97.42 50.37,97.42 50.33,97.41 50.29,97.39 50.28,97.39 50.24,97.39 50.21,97.35 50.12,97.44 50.12,98.44 50.32,98.64 54.3,98.64
VCC3V3_FLASH on BOTTOM (solid shape): outline of 93 points within 29.9,65.4 33.41,69.59
VCC3V3_FLASH on IN1 (solid shape): outline of 111 points within 34.41,81.1 46.18,84.68
VCC3V3_FLASH on IN2 (solid shape): outline of 915 points within 29.89,65.37 57.41,98.64
VCC3V3_FLASH_PD on TOP (solid shape): 74.02,80.61 74.02,76.95 73.23,76.16 63.2,76.16 62.79,76.57 62.79,77.76 62.87,77.84 63.63,77.84 63.93,78.14 67.8,78.14 68.94,77 72.93,77 72.98,77.05 72.98,77.59 72.9,77.66 72.49,77.66 72.42,77.74 72.42,78.93 72.49,79.01 72.88,79.01 73.1,79.24 73.1,80.56 72.98,80.68 72.52,80.68 72.42,80.79 72.42,80.96 72.62,81.17 73.46,81.17
VCC3V3_FLASH_PD on IN2 (solid shape): outline of 723 points within 62.11,76.17 68.73,94.41
VCCRTC_3 on BOTTOM (solid shape): 212.14,46.78 212.14,46.39 212.26,46.28 212.26,46.26 212.42,46.1 212.44,46.1 212.45,46.09 212.8,46.09 212.88,46.01 212.88,45.51 212.75,45.38 211.13,45.38 210.7,45.81 210.7,46.6 211.03,46.93 211.99,46.93
VCCRTC_4 on BOTTOM (solid shape): 213.74,46.54 213.74,46.32 213.67,46.24 212.47,46.24 212.4,46.32 212.4,47.25 212.47,47.33 212.96,47.33
VCCSTG_DIS1 on BOTTOM (solid shape): 204.66,186.28 204.66,185.8 204.47,185.61 203.98,185.61 203.77,185.4 203.77,184.67 203.67,184.57 202.22,184.57 202.05,184.74 202.05,185.35 202.14,185.44 203.05,185.44 203.1,185.49 203.1,185.6 203.04,185.66 202.17,185.66 202.07,185.77 202.07,186.01 202.17,186.11 203.06,186.11 203.3,185.87 203.66,185.87 203.93,186.14 203.93,186.33 204.02,186.41 204.52,186.41
VCCSTG_EN_2 on BOTTOM (solid shape): 202.98,182.07 202.98,180.73 202.32,180.07 200.9,180.07 200.88,180.09 200.88,181.34 200.62,181.6 200.62,181.78 200.68,181.84 201.08,181.84 201.16,181.76 202.39,181.76 202.46,181.84 202.46,182.05 202.59,182.18 202.88,182.18
VDD1V8 on BOTTOM (solid shape): 298.79,64.19 299.2,64.19 299.43,63.96 299.43,61.85 298.63,61.05 298.63,59.97 298.58,59.92 297.7,59.92 297.59,60.03 297.59,61.3 297.73,61.44 297.76,61.45 297.79,61.45 297.88,61.41 297.99,61.39 298.31,61.56 298.36,61.91 298.36,61.94 298.38,61.96 298.77,62.36 298.77,62.37 298.78,62.38 298.86,62.51 298.89,62.65 298.79,62.92 298.53,63.04 298.51,63.05 298.5,63.06 298.35,63.06 298.17,63.23 298.17,64.15 298.19,64.18 298.22,64.2 298.78,64.2
1P35V_LGATE on BOTTOM (solid shape): 118.27,48.27 118.27,47.79 117.2,46.72 116.97,46.72 116.94,46.75 116.94,47.66 117,47.71 117.38,47.71 117.71,48.05 117.71,48.22 117.86,48.38 118.16,48.38
1P35V_PHASE on BOTTOM (solid shape): 119.15,47.31 119.15,46.93 118.52,46.29 117.43,46.29 117.39,46.31 117.38,46.34 117.38,46.55 118.27,47.44 119.03,47.44
1P35V_PHASE on BOTTOM (solid shape): 126.38,47.41 126.38,47 127.33,46.04 131.42,46.04 131.83,45.63 131.83,45.61 131.82,45.56 131.82,45.51 131.82,45.45 131.83,45.4 131.83,41.7 131.63,41.49 128.37,41.49 127.94,41.92 127.94,42.89 126.14,44.69 121.36,44.69 121.13,44.92 121.13,47.59 121.22,47.68 126.11,47.68
1P35V_UGATE on BOTTOM (solid shape): 119.28,46.17 119.28,45.84 119.28,45.82 119.25,45.79 119.14,45.68 118.84,45.68 118.78,45.74 118.75,45.76 118.72,45.78 118.62,45.89 117.35,45.89 117.33,45.91 117.33,46.06 117.34,46.08 118.13,46.08 118.13,46.09 118.62,46.09 118.85,46.32 119.13,46.32
241_LX1 on BOTTOM (solid shape): 240.52,42.19 242.2,42.19 242.22,42.18 242.22,41.01 242.17,40.96 240.57,40.96 240.21,40.6 240.21,39.86 239.66,39.31 237.44,39.31 237.24,39.51 237.24,42.69 237.39,42.84 239.87,42.84
269_CSP on TOP (solid shape): 167.41,206.01 168.68,206.01 168.79,206.11 169.22,206.11 169.29,206.03 169.29,205.45 169.29,205.43 169.27,205.41 169.11,205.1 169.27,204.78 169.29,204.76 169.29,204.74 169.29,204.64 169.14,204.48 168.56,204.48 168.48,204.56 168.48,205.12 168.38,205.22 167.41,205.22 167.16,205.47 167.16,205.83 166.58,206.41 166.09,206.41 166.06,206.43 166.04,206.46 166.04,206.61 166.06,206.65 166.09,206.66 166.58,206.66 166.58,206.67 166.75,206.67
269_GH on TOP (solid shape): 165.43,206.19 165.43,205.35 165.64,205.14 166.02,205.14 166.05,205.14 166.28,204.91 166.28,204.52 166.15,204.39 165.66,204.39 165.61,204.44 165.61,204.86 165.26,205.22 165.26,206.21 165.41,206.21
269_GL on TOP (solid shape): 164.19,206.23 164.22,206.22 164.24,206.18 164.24,205.72 164.25,205.72 164.25,205.57 163.89,205.21 162.07,205.21 162.02,205.26 162.02,205.89 162.07,205.94 162.3,205.94 162.56,206.2 162.58,206.21 162.63,206.2 162.66,206.2 162.74,206.2 162.83,206.23
269_SWN on TOP (solid shape): 165.03,206.19 165.03,205.19 165.37,204.86 165.37,204.48 164.28,203.39 163.7,203.39 163.57,203.51 163.57,203.92 163.71,204.05 163.96,204.05 164.67,204.76 164.67,204.97 164.85,205.14 164.85,206.19 164.87,206.21 165,206.21
269_SWN on BOTTOM (solid shape): 173.37,194.19 174.36,194.19 174.49,194.07 174.49,191.14 174.17,190.82 171.54,190.82 171.5,190.84 171.47,190.84 171.09,190.84 171.06,190.84 171.02,190.82 169.01,190.82 168.46,191.37 168.46,192.9 169.32,193.76 169.32,195.01 169.37,195.06 172.49,195.06
5650_BSIN1 on BOTTOM (solid shape): 228.76,209.62 228.76,208.56 228.66,208.47 227.44,208.47 226.91,207.93 226.88,207.95 226.85,207.95 226.49,207.95 226.44,208 226.44,208.7 227.58,209.84 228.53,209.84
5650_SHN3 on TOP (solid shape): 233.06,213.5 233.14,213.42 233.14,212.94 233.08,212.88 230.99,212.88 230.91,212.95 230.91,213.03 230.93,213.06 230.97,213.08 231.54,213.08 231.54,213.28 230.97,213.28 230.93,213.29 230.91,213.33 230.91,213.37 231.05,213.51 233.05,213.51
5650_SHN3 on TOP (solid shape): 233.43,212.27 233.43,211.83 233.41,211.79 233.38,211.76 233.38,211.7 233.34,211.66 233.33,211.61 233.33,211.22 233.28,211.16 232.92,211.16 232.67,211.41 232.34,211.41 232.08,211.68 232.07,211.68 230.98,211.68 230.96,211.69 230.96,211.88 231.54,211.88 231.54,212.08 230.96,212.08 230.96,212.26 230.98,212.28 231.54,212.28 231.56,212.29 232.47,212.29 232.58,212.4 233.3,212.4
5650_SHO1 on TOP (solid shape): 227.24,210.68 227.77,210.68 227.79,210.66 227.79,210.48 227.74,210.43 227.74,210 227.33,209.59 226.8,209.59 226.62,209.77 226.62,210.17 227.14,210.68 227.24,210.68
8068LX_1.8V on TOP (solid shape): 262.54,66.64 262.54,65.23 262.52,65.21 262.52,64.85 261.82,64.85 261.82,64.6 262.52,64.6 262.52,64.35 261.82,64.35 261.82,64.1 262.52,64.1 262.52,63.93 262.46,63.87 259.64,63.87 259.24,64.28 259.24,66.61 259.36,66.74 262.44,66.74
8816ALGATE1 on BOTTOM (solid shape): 249.25,209.32 249.25,209.14 248.91,208.8 248.91,208.32 248.75,208.16 248.45,208.16 248.28,208.34 248.28,209.07 248.62,209.42 249.15,209.42
8816ALGATE2 on BOTTOM (solid shape): 254.56,203.45 254.77,203.45 254.93,203.29 254.93,201.8 254.77,201.65 253.97,201.65 253.11,202.51 253.11,203 253.56,203.45 254.55,203.45
8816ALGATE2 on BOTTOM (solid shape): 260.56,203.42 260.95,203.42 261.02,203.35 261.02,201.73 260.96,201.67 260.28,201.67 259.55,202.4 259.55,203.1 259.55,203.1 259.55,203.34 259.65,203.43 260.55,203.43
8816ALGATE2 on BOTTOM (solid shape): 250.48,209.48 250.87,209.48 251.3,209.05 251.63,209.05 251.83,208.85 251.83,208.66 251.67,208.5 250.96,208.5 250.16,209.3 250.16,209.43 250.21,209.48 250.47,209.48
8816APHASE1 on BOTTOM (solid shape): 249.11,210.56 249.11,209.9 248.89,209.68 248.18,209.68 247.66,209.16 247.43,209.16 247.27,209.32 247.27,209.67 248.28,210.68 249,210.68
8816APHASE1 on BOTTOM (solid shape): 242.5,201.12 243.46,201.12 243.74,201.41 243.74,202.02 243.91,202.18 246.98,202.18 247.25,201.91 247.25,200.42 246.64,199.81 242.18,199.81 238.88,196.51 238.88,193.86 237.96,192.95 234.3,192.95 233.01,194.24 233.01,197.72 234.81,199.52 236.76,199.52 237.6,200.37 237.6,201.78 238.02,202.2 241.43,202.2
8816APHASE2 on BOTTOM (solid shape): 252.7,209.89 252.7,209.52 252.89,209.33 252.89,209.09 252.66,208.86 252.29,208.86 251.42,209.72 251.25,209.72 251.25,209.72 250.59,209.72 250.53,209.79 250.53,210.57 250.62,210.67 251.91,210.67
8816APHASE2 on BOTTOM (solid shape): outline of 99 points within 255.21,193.94 266.49,203.91
8816APVCC on BOTTOM (solid shape): 249.94,208.78 249.94,206.85 250.15,206.64 250.15,205.7 250.08,205.63 249.32,205.63 249.23,205.71 249.23,208.81 249.43,209.01 249.71,209.01
8816AUGATE1 on BOTTOM (solid shape): 247.42,211.03 247.42,210.92 247.13,210.64 247.13,210.63 246.49,209.99 246.38,209.99 245.58,209.19 245.43,209.19 245.43,209.19 245.24,209.19 244.79,209.65 244.79,209.74 245.88,210.83 246.46,210.83 246.83,211.2 247.25,211.2
8816AUGATE2 on BOTTOM (solid shape): 252.8,211.32 253.5,211.32 253.77,211.04 254.59,211.04 254.9,210.73 254.9,210.31 254.65,210.06 253.95,210.06 253.92,210.06 253.9,210.05 253.8,210.05 253.6,210.25 253.04,210.25 252.21,211.07 252.21,211.32 252.31,211.41 252.7,211.41
9512_CSP4 on TOP (solid shape): 256.39,75.81 256.39,75.24 256.35,75.2 256.19,75.2 256.16,75.23 256.16,75.65 256.08,75.73 255.91,75.73 255.71,75.73 255.65,75.73 255.6,75.68 255.58,75.68 254.94,75.68 254.74,75.48 254.74,75.22 254.71,75.2 254.56,75.2 254.53,75.21 254.51,75.25 254.51,75.71 254.69,75.88 255.4,75.88 255.5,75.99 256.21,75.99
9512_PSI on TOP (solid shape): 267.09,80.17 267.09,79.64 267.14,79.59 267.26,79.59 267.27,79.6 267.29,79.6 267.3,79.59 268.07,79.59 268.2,79.72 268.2,79.85 268.28,79.92 268.61,79.92 268.66,79.87 268.66,79.54 268.5,79.38 267.27,79.38 267.17,79.28 267.17,78.93 267.13,78.88 266.89,78.88 266.86,78.92 266.86,80.07 266.86,80.08 266.86,80.12 266.92,80.17 267.08,80.17
9619_SW1 on BOTTOM (solid shape): 222.91,98.97 222.91,94.5 222.61,94.2 218.47,94.2 217.81,94.86 217.81,98.85 218.54,99.58 222.3,99.58
9619_SW2 on BOTTOM (solid shape): 234.23,99.15 234.23,97.52 232.8,96.09 232.8,94.53 232.79,94.53 232.79,94.45 232.54,94.2 227.97,94.2 227.59,94.58 227.59,99.28 227.84,99.53 233.85,99.53
9619_SW3 on BOTTOM (solid shape): 243.72,99.2 243.72,97.27 242.64,96.19 242.64,94.35 242.42,94.14 237.61,94.14 237.37,94.39 237.37,96.9 237.37,96.94 237.38,96.97 237.38,97.25 237.37,97.28 237.37,97.31 237.37,97.68 237.37,97.72 237.38,97.75 237.38,98.03 237.37,98.06 237.37,98.09 237.37,98.42 237.38,98.52 237.37,98.62 237.37,99.28 237.62,99.53 243.39,99.53
9619_SW4 on BOTTOM (solid shape): 253.18,99.19 253.18,97.34 252.34,96.5 252.34,94.36 252.17,94.2 247.53,94.2 247.15,94.58 247.15,99.28 247.4,99.53 252.83,99.53
9619_SW5 on BOTTOM (solid shape): 262.8,99.16 262.8,96.97 262.16,96.33 262.16,94.48 261.88,94.2 257.31,94.2 256.59,94.91 256.59,99.12 257,99.53 262.44,99.53
9619_SW6 on BOTTOM (solid shape): 272.33,99.03 272.33,97.06 271.91,96.64 271.91,94.37 271.72,94.17 266.54,94.17 265.78,94.93 265.78,99.2 266.1,99.51 267.7,99.51 267.72,99.53 271.83,99.53
9619_SW7 on BOTTOM (solid shape): 281.92,99.13 281.92,94.58 281.77,94.43 277.16,94.43 275.71,95.88 275.71,99.41 275.83,99.53 281.52,99.53
9619_SW8 on BOTTOM (solid shape): 293.12,98.9 293.12,95.6 293.06,95.54 291.92,95.54 291.67,95.29 291.67,94.47 291.59,94.39 287.26,94.39 286.02,95.63 285.5,95.63 285.21,95.93 285.21,99.36 285.38,99.53 292.48,99.53
24780_DL on TOP (solid shape): 41.53,42.1 41.7,42.1 41.75,42.05 41.75,41.58 41.63,41.46 41.05,41.46 40.9,41.61 40.9,41.8 40.84,41.86 39.98,41.86 39.93,41.92 39.93,42.03 39.97,42.06 40.78,42.06 40.82,42.1 41.53,42.1
24780_LX on TOP (solid shape): 50.77,45.16 50.77,39.46 50.6,39.29 50.6,38.25 50.47,38.12 47.82,38.12 47.69,38.19 47.54,38.2 45.31,40.43 45.31,41.6 45.46,41.76 46.75,41.76 46.94,41.57 47.81,41.57 47.98,41.75 47.98,43.55 47.86,43.68 47.07,43.68 46.92,43.83 46.92,45.3 47.07,45.45 50.47,45.45
24780_LX on BOTTOM (solid shape): 50.67,45.02 50.67,39.93 50.51,39.76 49.53,39.76 49.03,39.26 49.03,38.65 48.85,38.47 45.44,38.47 45.18,38.73 45.18,41.65 45.28,41.75 46.76,41.75 46.94,41.57 47.81,41.57 47.98,41.75 47.98,43.55 47.86,43.68 47.07,43.68 46.92,43.83 46.92,45.3 47.07,45.45 50.23,45.45
51225_DH1 on TOP (solid shape): 156.26,57.65 156.26,56.88 156.16,56.78 155.81,56.78 155.63,56.96 155.63,57.52 155.48,57.67 154.92,57.67 154.9,57.69 154.9,57.9 154.93,57.94 155.71,57.94 155.72,57.95 155.96,57.95
51225_DH1 on BOTTOM (solid shape): 164.28,54.61 164.28,54.21 164.29,54.2 164.29,54.15 164.86,53.58 165.24,53.58 165.28,53.54 165.28,52.92 165.1,52.75 164.39,52.75 163.79,53.35 163.79,53.56 163.31,54.05 163.31,54.56 163.43,54.69 164.19,54.69
51225_DH2 on TOP (solid shape): 152.67,57.94 152.71,57.9 152.71,57.16 152.61,57.06 152.15,57.06 151.9,56.81 151.46,56.81 151.34,56.94 151.34,57.39 151.87,57.92 151.88,57.93 151.9,57.94
51225_DH2 on BOTTOM (solid shape): 149.38,50.02 149.38,48.43 149.23,48.28 148.16,48.28 148.01,48.43 148.01,50.1 148.05,50.14 149.26,50.14
51225_DL1 on TOP (solid shape): 154.92,57.47 154.92,57.04 155.07,56.88 155.43,56.88 155.5,56.81 155.5,56.35 155.43,56.27 154.64,56.27 154.5,56.41 154.5,57.53 154.5,57.54 154.85,57.54
51225_DL1 on BOTTOM (solid shape): 159.7,54.6 159.7,52.82 159.63,52.75 158.84,52.75 158.71,52.87 158.71,53.62 158.71,53.74 158.71,54.59 158.74,54.62 158.76,54.62 158.83,54.7 159.6,54.7
51225_DL2 on TOP (solid shape): 153.09,57.52 153.09,56.73 152.66,56.3 152.23,56.3 152.1,56.43 152.1,56.78 152.24,56.92 152.66,56.92 152.68,56.94 152.81,56.94 152.89,57.01 152.89,57.52 152.91,57.54 153.06,57.54
51225_DL2 on BOTTOM (solid shape): 154.7,50.01 154.7,48.25 154.58,48.13 153.87,48.13 153.74,48.26 153.74,50.01 153.78,50.05 154.67,50.05
51225_SW1 on TOP (solid shape): 157.03,59.7 157.03,59.14 156.42,58.54 155.69,58.54 154.92,58.54 154.89,58.56 154.89,58.71 154.92,58.74 155.69,58.74 155.78,58.74 155.88,58.84 155.88,59.09 156.57,59.78 156.95,59.78
51225_SW1 on BOTTOM (solid shape): 162.56,53.67 162.56,47.92 162.81,47.67 162.81,39.89 162.51,39.59 157.46,39.59 157.46,39.59 157.15,39.59 156.7,40.04 156.7,45.1 156.95,45.35 159.05,45.35 159.71,46.01 159.71,52.55 159.87,52.71 159.87,53.78 159.96,53.87 162.36,53.87
51225_SW2 on TOP (solid shape): 150.68,59.64 150.68,59.49 151.43,58.74 151.91,58.74 152.68,58.74 152.71,58.71 152.71,58.56 152.68,58.54 151.91,58.54 151.76,58.54 151.72,58.49 151.66,58.46 151.61,58.43 151.16,57.98 150.75,57.98 150.5,58.22 150.5,58.51 150.08,58.93 150.08,59.64 150.14,59.69 150.63,59.69
51225_SW2 on BOTTOM (solid shape): 153.6,53.72 153.6,46.07 154.31,45.36 156.34,45.36 156.47,45.23 156.47,40.17 156.01,39.71 151.23,39.71 151.22,39.73 150.87,39.73 150.62,39.98 150.62,53.83 150.83,54.04 153.27,54.04
+CORE_PLLVDD on TOP (solid shape): 267.21,137.2 267.21,135.93 267.01,135.73 266.3,135.73 266.17,135.85 266.17,137.33 266.27,137.43 266.98,137.43
+CORE_PLLVDD on TOP (solid shape): 242.97,134.09 242.97,133.72 242.9,133.65 242.65,133.65 242.63,133.63 242.63,133.17 242.5,133.04 241.83,133.04 241.67,133.2 241.67,134.25 241.68,134.27 242.79,134.27
+CORE_PLLVDD on TOP (solid shape): 255.45,138.34 255.45,137.55 255.27,137.38 253.8,137.38 252.12,135.7 251.95,135.7 251.79,135.55 251.79,134.63 251.56,134.41 250.55,134.41 250.29,134.66 250.29,136.67 250.75,137.12 251.79,137.12 252.48,137.81 252.86,137.81 253.6,138.55 255.25,138.55
+CORE_PLLVDD on IN1 (solid shape): outline of 558 points within 241.82,132.29 251.79,136.3
+CORE_PLLVDD on IN1 (solid shape): outline of 1199 points within 234.18,127.43 241.85,135.91
+CORE_PLLVDD on IN2 (solid shape): outline of 2269 points within 236.4,127.56 251.66,135.05
+FBA_PLL_AVDD on TOP (solid shape): 226.14,137.77 226.71,137.77 226.71,137.77 226.83,137.77 226.87,137.73 226.87,137.32 226.64,137.09 226.64,135.74 226.64,135.53 226.45,135.34 226.45,134.54 226,134.09 226,133.53 225.79,133.31 225.37,133.31 225.22,133.46 225.22,134.32 225.5,134.6 225.5,135.45 225.93,135.88 225.93,137 225.62,137.31 225.62,137.32 225.59,137.35 225.59,137.71 225.74,137.86 226.05,137.86
+FBA_PLL_AVDD on IN1 (solid shape): 226.62,138.27 226.62,137.38 226.44,137.2 225.76,137.2 225.56,137.41 225.56,137.78 225.66,137.88 225.87,137.88 225.99,138 225.99,138.36 226.01,138.38 226.51,138.38
+FBA_PLL_AVDD on IN1 (solid shape): outline of 313 points within 225.55,141.93 249.67,158.63
+FBA_PLL_AVDD on IN2 (solid shape): outline of 393 points within 225.43,135.88 249.66,158.61
+FBA_PLL_AVDD on IN4 (solid shape): outline of 665 points within 225.54,137.13 249.65,158.69
+FBVDDQ_MEM on TOP (solid shape): outline of 909 points within 235.18,170.13 241.6,177.28
+FBVDDQ_MEM on TOP (solid shape): outline of 59961 points within 196.5,125.97 276.95,196.53
+FBVDDQ_MEM on BOTTOM (solid shape): 256.46,198.05 257.63,196.89 257.63,194.89 258.55,193.96 258.55,191.44 258.1,190.99 240.86,190.99 240,191.84 240,197.14 240.84,197.97 247.35,197.97 248.07,198.69 255.82,198.69
+FBVDDQ_MEM on BOTTOM (solid shape): outline of 82 points within 224.64,136.23 226.13,142.67
+FBVDDQ_MEM on BOTTOM (solid shape): outline of 147 points within 260.73,138.91 267.59,142.12
+FBVDDQ_MEM on BOTTOM (solid shape): outline of 162 points within 256.42,169.52 259.89,176.66
+FBVDDQ_MEM on BOTTOM (solid shape): outline of 192 points within 260.73,138.47 277.78,169.19
+FBVDDQ_MEM on BOTTOM (solid shape): outline of 141 points within 224.65,155.54 232.65,159.56
+FBVDDQ_MEM on BOTTOM (solid shape): outline of 191 points within 224.6,142.95 226.29,155.45
+FBVDDQ_MEM on BOTTOM (solid shape): outline of 429 points within 232.95,139.28 250.32,159.43
+FBVDDQ_MEM on BOTTOM (solid shape): outline of 3631 points within 197.32,124.81 263.36,186.38
+FBVDDQ_MEM on IN1 (solid shape): 224.53,139.22 224.58,139.31 224.69,139.31 224.72,139.28 224.76,139.26 224.81,139.21 224.81,139.14 224.79,139.08 224.79,139.01 224.88,138.78 225.12,138.68 225.28,138.72 225.4,138.85 225.48,138.89 225.56,138.86 225.81,138.6 225.81,138.08 225.71,137.98 225.62,137.98 225.46,137.82 225.46,137.76 225.45,137.76 225.43,137.63 225.45,137.51 225.46,137.5 225.46,137.36 225.5,137.32 225.51,137.3 225.57,137.18 225.67,137.09 225.68,137.09 225.8,136.97 225.8,136.59 225.69,136.48 225.4,136.48 225.26,136.62 225.26,136.71 225.28,136.78 225.29,136.85 225.26,136.98 225.19,137.09 225.15,137.16 225.18,137.23 225.24,137.33 225.27,137.45 225.17,137.69 224.94,137.78 224.89,137.78 224.84,137.77 224.72,137.77 224.51,137.98 224.51,138.06 224.53,138.12 224.53,138.17 224.48,138.34 224.34,138.47 224.32,138.48 224.32,139.01
+FBVDDQ_MEM on IN1 (solid shape): outline of 88 points within 247.66,149.71 250.35,158.82
+FBVDDQ_MEM on IN1 (solid shape): outline of 124 points within 248.9,139.28 249.9,148.34
+FBVDDQ_MEM on IN1 (solid shape): outline of 1207 points within 224.4,139.32 244.93,159.44
+FBVDDQ_MEM on IN2 (solid shape): 258.55,197.07 258.55,191.71 257.94,191.1 238.51,191.1 237.52,192.09 237.52,196.25 238.05,196.79 247.04,196.79 248.47,198.21 257.41,198.21
+FBVDDQ_MEM on IN2 (solid shape): 224.54,139.41 224.63,139.37 224.68,139.31 224.76,139.26 224.81,139.21 224.81,139.13 224.79,139.07 224.79,139.01 224.88,138.78 225.12,138.68 225.24,138.7 225.34,138.77 225.36,138.78 225.4,138.78 225.81,138.37 225.81,138.08 225.73,138 225.68,138 225.62,137.93 225.52,137.86 225.46,137.77 225.45,137.76 225.45,137.74 225.43,137.69 225.43,137.63 225.43,137.58 225.45,137.52 225.45,137.35 225.57,137.23 225.59,137.19 225.63,137.15 225.63,137.13 225.8,136.96 225.8,136.65 225.71,136.56 225.7,136.55 225.68,136.55 225.45,136.55 225.33,136.66 225.32,136.69 225.32,136.72 225.33,136.77 225.34,136.83 225.31,136.98 225.21,137.1 225.17,137.17 225.19,137.24 225.25,137.34 225.27,137.45 225.22,137.63 225.08,137.75 224.98,137.82 224.85,137.85 224.81,137.84 224.77,137.85 224.74,137.87 224.54,138.07 224.53,138.09 224.51,138.29 224.44,138.4 224.44,139.34 224.46,139.37
+FBVDDQ_MEM on IN2 (solid shape): 249.72,148.68 249.76,148.67 249.77,148.63 249.8,148.53 249.87,148.43 249.87,148.41 249.87,148.24 249.87,148.22 249.86,148.2 249.77,147.97 249.86,147.74 249.87,147.73 249.87,147.7 249.87,147.68 249.85,147.66 249.68,147.37 249.85,147.09 249.87,147.07 249.87,147.04 249.87,146.83 249.86,146.8 249.79,146.7 249.77,146.58 249.79,146.46 249.87,146.34 249.87,146.33 249.87,146.11 249.8,145.99 249.77,145.87 249.79,145.78 249.83,145.69 249.84,145.66 249.82,145.63 249.64,145.45 249.64,145.28 249.64,145.24 249.64,140.9 249.49,140.75 249.15,140.75 249.07,140.83 249.07,141.37 249.15,141.57 249.07,141.78 249.07,143.77 249.08,143.85 249.07,143.93 249.07,144.07 249.06,144.08 248.9,144.25 248.9,144.6 249.07,144.77 249.07,145.58 249.1,145.66 249.11,145.72 249.1,145.79 249.07,145.87 249.07,146.37 249.09,146.43 249.09,146.49 249.09,146.54 249.07,146.6 249.07,147.07 249.12,147.12 249.12,148.58 249.22,148.68
+FBVDDQ_MEM on IN2 (solid shape): outline of 119 points within 247.71,149.72 250.33,158.82
+FBVDDQ_MEM on IN2 (solid shape): outline of 472 points within 224.4,139.73 244.84,159.49
+FBVDDQ_MEM on SVCC (solid shape): outline of 1745 points within 197.11,125.19 276.82,196.81
+FBVDDQ_MEM on SVCC1 (solid shape): outline of 607 points within 197.11,125.19 276.82,197.83
+FBVDDQ_MEM on IN3 (solid shape): outline of 84452 points within 197.56,125.64 276.48,198.08
+FBVDDQ_MEM on IN4 (solid shape): 249.8,148.15 249.8,148.12 249.8,148.11 249.77,148.04 249.77,147.97 249.79,147.85 249.86,147.74 249.87,147.73 249.87,147.7 249.87,147.68 249.85,147.66 249.68,147.37 249.85,147.09 249.87,147.07 249.87,147.04 249.87,146.97 249.83,146.93 249.74,146.79 249.7,146.63 249.74,146.46 249.83,146.32 249.85,146.27 249.83,146.22 249.75,146.09 249.72,145.93 249.74,145.8 249.8,145.68 249.82,145.61 249.78,145.54 249.68,145.43 249.64,145.28 249.69,145.11 249.82,144.98 249.84,144.95 249.87,144.92 249.87,144.73 249.87,144.71 249.8,144.6 249.77,144.49 249.77,144.47 249.66,144.36 249.66,142.18 249.46,141.98 249.46,141.39 249.61,141.25 249.71,141.14 249.71,140.9 249.71,140.88 249.7,140.87 249.55,140.72 249.32,140.72 249.07,140.96 249.07,141.37 249.15,141.57 249.07,141.78 249.07,143.77 249.08,143.85 249.07,143.93 249.07,144.07 248.9,144.25 248.9,144.6 249.07,144.77 249.07,145.58 249.1,145.66 249.11,145.72 249.1,145.79 249.07,145.87 249.07,146.37 249.09,146.43 249.09,146.49 249.09,146.54 249.07,146.6 249.07,147.07 249.12,147.12 249.12,148.22 249.2,148.3 249.65,148.3
+FBVDDQ_MEM on IN4 (solid shape): outline of 119 points within 247.71,149.68 250.36,158.82
+FBVDDQ_MEM on IN4 (solid shape): outline of 1032 points within 224.34,136.47 244.87,159.4
+PCH_AUX on TOP (solid shape): 65.28,49.4 65.28,48.26 65.16,48.14 63.15,48.14 62.97,48.32 62.97,49.38 63.11,49.53 65.16,49.53
+PCH_AUX on TOP (solid shape): 227.33,44.97 227.33,41.77 227,41.44 223.85,41.44 223.48,41.81 223.48,44.19 224.65,44.19 224.65,44.13 224.66,44.07 224.68,44.02 224.7,43.97 224.73,43.92 224.77,43.88 224.81,43.84 224.86,43.81 224.91,43.79 224.96,43.77 225.02,43.76 225.08,43.76 225.13,43.77 225.19,43.79 225.24,43.81 225.28,43.84 225.33,43.88 225.36,43.92 225.39,43.97 225.42,44.02 225.43,44.07 225.44,44.13 225.44,44.19 225.43,44.24 225.42,44.3 225.39,44.35 225.36,44.4 225.33,44.44 225.28,44.48 225.24,44.51 225.19,44.53 225.13,44.54 225.08,44.55 225.02,44.55 224.96,44.54 224.91,44.53 224.86,44.51 224.81,44.48 224.77,44.44 224.73,44.4 224.7,44.35 224.68,44.3 224.66,44.24 224.65,44.19 223.48,44.19 223.48,44.81 223.8,45.12 227.18,45.12
+PCH_AUX on TOP (solid shape): outline of 131 points within 210.48,55.88 215.02,61.68
+PCH_AUX on BOTTOM (solid shape): 214.45,61.05 214.45,58.04 214.21,57.8 211.74,57.8 211.28,58.26 211.28,60.96 211.48,61.16 214.34,61.16
+PCH_AUX on BOTTOM (solid shape): 241.06,47.23 241.06,47.08 241.54,46.61 241.79,46.61 241.93,46.48 241.93,46.02 241.89,45.98 241.58,45.98 241.39,45.98 240.5,46.87 240.5,47.25 240.64,47.39 240.9,47.39
+PCH_AUX on SVCC (solid shape): 216.89,59.2 216.89,59.18 216.99,58.99 217.18,58.9 217.2,58.89 221.9,54.19 221.88,54.15 221.84,54.06 221.82,53.96 221.93,53.7 222.18,53.6 222.28,53.61 222.37,53.66 222.41,53.68 227.84,48.25 227.84,43.12 227.49,42.76 223.75,42.76 216.89,49.62 216.92,49.66 216.97,49.76 216.99,49.87 216.88,50.12 216.63,50.22 216.52,50.2 216.42,50.15 216.39,50.13 211.42,55.09 211.43,55.12 211.44,55.17 211.45,55.22 211.42,55.37 211.33,55.49 211.33,60.31 211.81,60.8 215.29,60.8
+PCH_AUX on IN4 (solid shape): outline of 3394 points within 210.25,42.75 231.37,64.33
+SMDDR_VREF_DQ0 on TOP (solid shape): 164.99,82.19 164.99,81.62 164.88,81.51 163.1,81.51 162.87,81.28 162.87,80.54 162.72,80.38 161.99,80.38 161.82,80.55 161.82,81.53 162.47,82.19 163.91,82.19 164,82.27 164.91,82.27
+SMDDR_VREF_DQ1 on TOP (solid shape): 163.81,98.31 163.81,98.01 163.71,97.91 163.22,97.91 163.07,97.75 163.07,97.69 163.07,97.68 163.03,97.51 163.07,97.34 163.07,97.33 163.07,96.56 163.43,96.2 163.43,94.25 163.6,94.07 163.94,94.07 164.04,93.97 164.04,93.46 163.94,93.36 163.15,93.36 162.33,94.17 162.33,98.03 162.77,98.46 163.65,98.46
+SMDDR_VREF_DQ1 on TOP (solid shape): 168.67,93.31 168.67,92.88 168.71,92.83 168.71,92.71 168.71,92.7 168.71,92.26 168.72,91.87 168.7,91.85 168.62,91.64 168.6,91.43 168.6,90.31 168.62,90.1 168.7,89.89 168.72,89.87 168.72,89.43 168.64,89.36 168.35,89.36 168.29,89.35 168.23,89.33 168.22,89.32 167.88,89.32 167.77,89.43 167.77,89.45 167.77,90.67 167.77,90.69 167.78,90.71 168.06,90.98 168.06,91.12 168.09,91.17 168.09,91.21 168.09,91.59 168.09,91.63 168.06,91.69 168.06,91.79 168.08,91.81 168.08,91.86 168.09,91.9 168.09,91.92 168.09,92.3 168.09,92.33 168.08,92.37 168.08,92.45 168.06,92.47 168.06,92.63 167.8,92.88 167.8,93.35 167.89,93.43 168.54,93.43
+TPVDD on TOP (solid shape): 203.45,46.2 203.45,44.91 203.45,44.9 204.18,44.9 204.33,44.76 204.33,44.32 204.2,44.19 202.61,44.19 202.59,44.19 202.58,44.2 202.49,44.29 202.49,44.67 202.5,44.68 202.5,46.18 202.61,46.28 203.37,46.28
+TPVDD on TOP (solid shape): 199.52,41.38 200.79,41.38 200.79,41.38 201.56,41.38 201.56,41.38 202.82,41.38 202.85,41.36 202.87,41.33 202.87,41.18 202.87,41.17 202.88,41.14 202.87,41.13 202.85,41.11 202.83,41.1 201.56,41.1 200.79,41.1 199.52,41.1 199.52,41.09 199.39,41.09 198.9,40.6 198.9,39.15 198.65,38.9 196.98,38.9 196.83,39.05 196.83,40.4 197.81,41.38 198.79,41.38 198.79,41.38 199.52,41.38
+TPVDD on BOTTOM (solid shape): 206.4,46.29 206.4,45.08 205.79,44.47 205.79,43.88 204.54,42.63 204.51,42.62 204.48,42.62 204.39,42.66 204.29,42.67 204.11,42.64 203.96,42.51 203.94,42.51 203.13,42.51 203.08,42.46 203.07,42.46 202.95,42.37 202.86,42.25 202.86,42.24 199.39,38.77 196.65,38.77 196.47,38.95 196.47,40.09 198.55,42.18 199.67,42.18 201.56,44.06 201.57,44.07 201.66,44.11 201.74,44.17 201.76,44.18 201.83,44.18 201.84,44.17 201.96,44.11 202.09,44.08 202.37,44.2 202.49,44.48 202.47,44.59 202.42,44.69 202.41,44.71 202.42,44.74 202.67,45 204.6,45 204.9,45.3 204.9,46.52 205.01,46.62 206.07,46.62
+USBPWR3 on TOP (solid shape): 21.42,56.76 22.59,56.76 23.15,56.2 23.15,54.46 23.02,54.32 21.72,54.32 21.45,54.05 21.45,53.24 21.44,53.2 21.4,53.19 20.54,53.19 20.46,53.23 20.38,53.24 20.08,53.24 20.03,53.24 20.01,53.26 19.92,53.35 19.92,53.84 19.93,53.87 20.2,54.14 20.2,54.23 20.21,54.29 20.21,54.34 20.21,54.4 20.2,54.5 20.12,54.59 20.12,55.44 20.19,55.55 20.21,55.68 20.19,55.8 20.13,55.9 20.12,55.91 20.12,55.95 20.14,55.98 20.15,55.98 20.26,56.07 20.34,56.19 20.34,56.2 20.6,56.46 20.6,56.96 20.7,57.06 21.11,57.06
+USBPWR3 on BOTTOM (solid shape): outline of 411 points within 15.88,53.95 21.6,59.4
+USBPWR3 on IN1 (solid shape): outline of 339 points within 15.94,53.73 21.54,58
+USBPWR3 on SVCC (solid shape): outline of 122 points within 15.83,54.32 21.59,58.51
+USBPWR3 on SVCC1 (solid shape): outline of 122 points within 15.83,54.32 21.59,58.51
+USBPWR_DB1 on TOP (solid shape): 321.26,99.4 321.26,96.64 321.18,96.56 321.09,96.56 321.05,96.6 320.61,96.6 320.59,96.61 319.74,96.61 319.71,96.58 319.39,96.58 319.36,96.61 319.36,98.26 319.71,98.62 319.71,98.95 319.72,98.95 319.72,99.34 320.11,99.74 320.92,99.74
+USBPWR_DB1 on BOTTOM (solid shape): outline of 474 points within 312.52,89.35 321.31,99.43
+USBPWR_DB2 on TOP (solid shape): 314.88,98.78 314.88,98.53 315.22,98.2 316.06,97.36 316.06,96.61 315.86,96.42 315.62,96.42 315.33,96.12 315.01,96.12 314.56,96.57 314.25,96.57 314.22,96.6 313.51,96.6 313.45,96.59 313.38,96.57 313.03,96.57 312.97,96.62 312.97,96.94 313.44,97.4 313.44,98.74 313.57,98.87 314.79,98.87
+USBPWR_DB2 on BOTTOM (solid shape): 315.82,97.6 315.84,97.59 315.86,97.58 315.94,97.5 316.03,97.44 316.04,97.43 316.18,97.3 316.18,95.49 314.63,93.94 313.08,93.94 312.94,94.08 312.94,96.72 313.01,96.79 314.73,96.79 314.81,96.86 314.81,97.3 315.12,97.6
+VGPU_SRC_R on TOP (solid shape): outline of 657 points within 189.77,176.9 226.38,202.32
+VGPU_SRC_R on BOTTOM (solid shape): 192.66,186.65 192.66,176.95 192.51,176.8 190.38,176.8 190.27,176.9 190.27,178.32 190,178.6 189.23,178.6 188.95,178.88 188.95,186.81 189,186.86 192.46,186.86
+VGPU_SRC_R on BOTTOM (solid shape): 225.98,203.47 225.98,202.94 226.38,202.55 226.38,197.12 225.63,196.36 225.63,192.5 225.44,192.32 221.77,192.32 221.23,192.86 220.32,192.86 220.22,192.96 220.22,194.39 220.11,194.51 220.09,194.51 219.68,194.92 219.68,195.77 221.41,197.51 221.41,202.2 221.53,202.32 224.05,202.32 225.35,203.62 225.83,203.62
+VGPU_SRC_R on SVCC1 (solid shape): outline of 115 points within 178,177.26 226.19,219.74
+WL_VDD on TOP (solid shape): 284.18,76.06 284.18,75.63 283.77,75.22 282.73,75.22 282.63,75.12 282.63,74.64 283.47,73.8 283.47,73.14 283.44,73.11 282.56,73.11 281.98,73.68 281.98,75.28 281.87,75.4 281.87,75.96 282.04,76.14 284.1,76.14
+WL_VDD on TOP (solid shape): outline of 250 points within 271.12,59.94 277.88,80.66
+WL_VDD on BOTTOM (solid shape): 273.66,75.77 273.66,75.75 273.76,75.59 273.92,75.48 273.95,75.47 273.96,75.44 273.96,75.17 273.88,75.1 273.88,75.09 273.84,75.05 273.39,75.05 273.2,75.25 273.2,75.63 272.95,75.88 272.86,75.88 272.85,75.89 272.77,75.89 272.72,75.94 272.72,76.27 272.79,76.34 273.09,76.34
+WL_VDD on BOTTOM (solid shape): 276.36,79.85 276.36,79.15 276.34,79.12 276.3,79.1 274.71,79.1 274.71,78.88 276.3,78.88 276.34,78.86 276.36,78.83 276.36,78.7 276.25,78.6 274.58,78.6 274.21,78.22 274.21,77.67 273.33,76.79 272.8,76.79 272.71,76.88 272.71,77.2 272.79,77.27 273.14,77.27 273.38,77.51 273.38,77.89 272.82,78.46 272.82,79.79 273.13,80.1 276.1,80.1
+WL_VDD on BOTTOM (solid shape): 273.26,61.89 274.49,61.89 274.59,61.99 274.62,61.99 274.65,61.98 274.67,61.97 274.7,61.95 274.71,61.92 274.71,61.88 276.3,61.88 276.34,61.86 276.36,61.83 276.36,61.65 276.34,61.62 276.3,61.6 274.71,61.6 274.71,61.38 276.3,61.38 276.34,61.36 276.36,61.33 276.36,60.97 276.3,60.91 276.3,60.56 276.13,60.39 272.27,60.39 272.14,60.52 272.14,61.76 272.37,61.99 273.17,61.99
ADOGND on TOP (solid shape): 300.32,63.4 300.32,62.43 300.35,62.41 300.35,61.57 300.19,61.42 300.18,61.42 300.14,61.39 300.12,61.35 300.11,61.34 300.08,61.3 300.08,61 299.67,60.59 299.67,59.98 299.57,59.89 299.55,59.87 299.52,59.87 299.46,59.89 299.39,59.89 299.31,59.89 299.22,59.86 299.09,59.86 298.99,59.96 298.99,60.77 299.6,61.38 299.6,61.63 300.13,62.17 300.13,63.41 300.18,63.46 300.26,63.46
ADOGND on TOP (solid shape): 315.32,71.2 315.37,71.2 315.41,71.2 315.46,71.21 315.48,71.2 315.55,71.13 315.55,69.05 315.39,68.9 315.17,68.9 315.04,69.03 314.48,69.03 314.45,69.06 314.45,70.03 314.42,70.03 314.39,70.05 314.38,70.08 314.38,70.19 314.73,70.55 314.74,70.55 314.86,70.61 314.93,70.73 314.94,70.75 314.94,71.01 315.14,71.21 315.27,71.21
ADOGND on TOP (solid shape): outline of 629 points within 298.96,57.71 322.89,69.34
ADOGND on BOTTOM (solid shape): outline of 668 points within 298.96,57.71 322.89,71.28
ADOGND on SGND (solid shape): outline of 114 points within 298.96,57.71 322.89,74.38
ADOGND on IN1 (solid shape): outline of 970 points within 298.96,57.71 322.89,74.38
ADOGND on SGND1 (solid shape): outline of 120 points within 298.96,57.71 322.89,74.38
ADOGND on IN2 (solid shape): outline of 811 points within 298.96,57.71 322.89,74.38
ADOGND on SVCC (solid shape): outline of 116 points within 298.96,59.23 321.37,74.38
ADOGND on SVCC1 (solid shape): outline of 116 points within 298.96,59.23 321.37,74.38
ADOGND on IN3 (solid shape): outline of 824 points within 298.96,57.71 322.89,74.38
ADOGND on SGND2 (solid shape): outline of 117 points within 298.96,57.71 322.89,74.38
ADOGND on IN4 (solid shape): outline of 837 points within 298.96,57.71 322.89,73.74
ADOGND on SGND3 (solid shape): outline of 113 points within 298.96,57.71 322.89,74.38
ADP2_DET on BOTTOM (solid shape): 228.53,204.97 228.53,204.56 229.09,204 229.09,203.44 229.03,203.39 228.78,203.39 228.73,203.44 228.73,203.98 228.37,204.33 228.12,204.33 227.97,204.48 227.97,205.04 228.07,205.14 228.35,205.14
AFS on TOP (solid shape): 273.04,211.33 273.04,211.16 273.02,211.15 273.02,211.07 273.35,210.74 273.35,210.58 273.34,210.53 273.34,210.48 273.34,210.44 273.35,210.38 273.35,210.23 273.46,210.11 273.6,210.11 273.67,210.09 273.73,210.09 273.79,210.09 273.86,210.11 273.91,210.11 274.04,209.98 274.04,209.44 273.95,209.35 272.73,209.35 272.65,209.43 272.65,210.05 272.71,210.11 272.71,210.24 272.72,210.3 272.73,210.36 272.72,210.41 272.71,210.47 272.71,210.53 272.27,210.98 271.7,210.98 271.64,211.03 271.64,211.32 271.73,211.41 272.95,211.41
B_CTL on TOP (solid shape): 36.43,37.1 36.43,36.16 36.3,36.03 34.82,36.03 34.8,36.06 34.8,36.29 34.63,36.46 33.85,36.46 33.79,36.53 33.79,37.06 33.88,37.16 36.37,37.16
B_CTL on TOP (solid shape): 246.66,218.66 246.66,218.53 246.84,218.35 247.83,218.35 247.86,218.33 247.86,218 247.78,217.92 244.73,217.92 244.55,217.74 244.55,217.72 244.39,217.55 243.57,217.55 243.35,217.78 243.35,218.08 243.48,218.22 243.79,218.22 244.35,218.78 246.54,218.78
BAT-V on TOP (solid shape): 69.98,45.68 69.98,44.16 70.18,43.96 70.21,43.96 70.51,43.65 70.51,42.74 70.39,42.61 59.57,42.61 59.36,42.81 59.36,44.13 60.03,44.79 60.03,45.31 60.12,45.4 60.83,46.12 61.53,46.12 61.8,46.39 69.27,46.39
BAT-V on BOTTOM (solid shape): outline of 142 points within 56.88,43.16 68.94,50.49
BEEP2 on TOP (solid shape): 321.19,72.71 321.19,72.45 321.15,72.42 321.14,72.42 321,72.28 320.83,72.28 320.75,72.2 320.75,70.19 320.75,70.15 320.75,69.79 320.65,69.69 320.17,69.69 320.12,69.74 320.12,72.27 320.58,72.73 321.16,72.73
BFS on TOP (solid shape): 274.42,211.35 274.42,211.11 274.53,211 274.53,209.98 274.86,209.64 274.88,209.63 274.96,209.63 274.96,209.63 275.96,209.63 276.06,209.53 276.06,209.35 275.98,209.27 274.36,209.27 274.19,209.45 274.19,210.07 274.13,210.13 274.13,210.66 273.79,211.01 273.28,211.01 273.2,211.09 273.2,211.39 273.23,211.41 274.36,211.41
BI_GATE on TOP (solid shape): 257.42,57.45 257.42,56.62 257.36,56.56 257.36,56.06 257.47,55.95 257.5,55.95 257.5,55.94 257.95,55.94 257.95,55.95 258.37,55.95 258.48,55.84 258.48,55.82 258.53,55.66 258.64,55.54 258.64,54.62 258.28,54.26 258.24,54.26 258.15,54.23 258.1,54.16 258.09,54.14 258.09,53.66 258.2,53.55 258.2,53.38 258.2,52.78 258.34,52.64 258.44,52.64 258.79,52.29 258.79,51.01 257.97,50.19 257.97,50.08 257.39,49.5 257.08,49.5 256.7,49.88 256.7,51.09 256.42,51.36 256.42,51.98 256.49,52.05 257.17,52.05 257.3,51.92 257.3,51.46 257.62,51.14 258.12,51.14 258.37,51.39 258.37,52.19 258.36,52.19 258.36,52.27 257.56,53.07 257.56,54.41 258.09,54.95 258.09,54.97 258.11,54.98 258.11,55.46 258.09,55.47 258.09,55.53 257.97,55.65 257.49,55.65 257.12,56.02 257.12,56.64 256.96,56.8 256.58,56.8 256.47,56.91 256.48,56.98 256.48,57.06 256.47,57.11 256.47,57.45 256.59,57.56 257.31,57.56
BI_GATE on BOTTOM (solid shape): 253.76,57.25 253.76,55.21 253.14,54.59 253.14,51.89 253.71,51.32 253.71,51.31 254.24,50.77 254.24,50.02 254.51,49.75 255.72,49.75 256.01,49.46 256.01,49.15 256.29,48.87 256.66,48.87 257.06,49.26 257.06,50.16 257.19,50.29 257.77,50.29 257.85,50.21 257.85,48.89 257.25,48.29 253.12,48.29 252.37,49.05 252.37,52.17 252.4,52.21 252.4,55.62 252.4,55.63 252.4,57.35 253.65,57.35
BSTAUX1 on TOP (solid shape): 238.73,45.21 238.73,44.48 239.1,44.1 239.1,43.27 239.03,43.19 238.5,43.19 238.4,43.29 238.4,43.83 238.27,43.96 237.72,43.96 237.62,44.05 237.62,45.19 237.69,45.26 238.67,45.26
BSTAUX2 on TOP (solid shape): 238.11,39.02 238.11,36.99 238.04,36.92 237.31,36.92 237.25,36.98 237.25,38.98 237.32,39.05 238.08,39.05
CCD_PWR on TOP (solid shape): 269.27,185.97 270.54,185.97 270.62,185.89 270.62,185.8 270.54,185.72 268.88,185.72 268.69,185.91 268.23,185.91 267.87,185.55 267.87,184.98 268.14,184.71 268.64,184.71 268.69,184.66 268.69,184.5 268.64,184.45 268.23,184.45 268.01,184.24 267.11,184.24 266.83,183.96 266.83,183.45 266.68,183.3 266.07,183.3 265.95,183.42 265.95,185.16 266.37,185.58 266.37,186.07 266.64,186.33 268.91,186.33
CTL0_DP on BOTTOM (solid shape): 27.06,24.62 27.26,24.62 27.33,24.54 27.33,23.74 27.25,23.66 26.62,23.66 26.41,23.86 25.66,23.86 25.43,24.09 25.12,24.09 25.02,23.99 24.03,23.99 24.01,24.02 24.01,24.12 24.06,24.17 24.9,24.17 25.02,24.3 25.02,24.47 25.17,24.63 27.05,24.63
CTL1_DP on TOP (solid shape): 27.24,24.79 27.24,24.17 27.18,24.11 27.06,24.11 26.68,24.11 26.66,24.11 25.98,24.11 25.98,24.11 25.65,24.11 25.5,23.97 25.5,23.57 25.49,23.54 25.45,23.52 25.41,23.52 25.33,23.43 25.3,23.42 25.05,23.42 24.92,23.55 24.92,23.82 24.85,23.89 24.39,23.89 24.31,23.98 24.31,24.27 24.37,24.33 24.98,24.33 25.51,24.86 27.18,24.86
DDR1_VREF_CA0 on BOTTOM (solid shape): 127.68,141.48 127.68,141.23 127.58,141.13 127.17,141.13 126.82,140.77 126.46,140.77 126.36,140.87 126.36,141.28 126.67,141.59 127.58,141.59
DDR_VTT on TOP (solid shape): 188.49,98.08 188.63,98.08 188.64,98.08 188.8,98.05 188.96,98.08 188.97,98.08 189.27,98.08 189.42,97.93 189.42,97.36 189.04,96.98 189.04,95.53 189.51,95.06 189.51,94.53 189.44,94.45 187.02,94.45 186.95,94.53 186.95,94.68 187.35,95.09 187.35,97.28 187.69,97.62 187.69,98.22 187.86,98.38 188.19,98.38
DDR_VTT on TOP (solid shape): 189.13,83.48 189.13,81.87 189.12,81.81 189.12,81.77 189.12,81.47 189.12,81.42 189.12,81.39 189.11,81.37 188.88,81.14 187.97,81.14 187.82,81.29 187.82,81.56 187.74,81.64 187.25,81.64 187.24,81.65 187.24,82.39 187.24,82.41 187.39,82.57 187.43,82.76 187.4,82.91 187.31,83.04 187.28,83.11 187.29,83.18 187.35,83.28 187.36,83.4 187.34,83.55 187.25,83.67 187.23,83.74 187.25,83.81 187.33,83.94 187.36,84.08 187.36,84.12 187.36,84.14 187.37,84.16 187.46,84.24 188.37,84.24
DDR_VTT on TOP (solid shape): outline of 710 points within 103.29,42.56 119.18,66.42
DDR_VTT on BOTTOM (solid shape): 119.08,44.26 119.08,42.69 118.88,42.48 117.25,42.48 117,42.73 116.98,42.76 116.91,42.82 116.86,42.89 116.54,43.21 116.54,44.39 116.59,44.44 116.72,44.44 116.73,44.42 116.73,43.68 116.74,43.68 116.74,43.6 116.79,43.55 116.84,43.55 116.84,43.54 117.27,43.54 117.27,43.57 117.33,43.63 117.33,44.84 117.35,44.87 118.47,44.87
DDR_VTT on BOTTOM (solid shape): 188.45,98.41 188.45,98.39 188.56,98.18 188.78,98.08 188.81,98.07 188.83,98.03 188.83,97.42 188.69,97.29 188.25,97.29 188.13,97.17 187.86,97.17 187.76,97.07 187.76,97.06 187.73,97.03 187.7,97.03 187.7,95.26 187.69,95.23 187.65,95.21 187.5,95.21 187.46,95.23 187.45,95.26 187.45,97.03 187.43,97.03 187.4,97.06 187.4,98.31 187.53,98.44 188.42,98.44
DDR_VTT on BOTTOM (solid shape): 188.55,84.11 188.55,83.1 187.76,82.31 187.76,82.28 187.74,82.24 187.71,82.23 187.65,82.23 187.65,80.47 187.68,80.47 187.73,80.44 187.72,80.39 187.68,80.35 187.4,80.35 187.37,80.39 187.36,80.41 187.36,80.44 187.37,80.46 187.39,80.47 187.4,80.47 187.4,82.23 187.35,82.23 187.32,82.24 187.3,82.28 187.3,82.52 187.39,82.76 187.3,83 187.3,83.27 187.32,83.34 187.33,83.4 187.32,83.46 187.3,83.53 187.3,83.97 187.32,84.03 187.32,84.08 187.31,84.16 187.32,84.18 187.4,84.27 188.39,84.27
DDR_VTT on IN4 (solid shape): outline of 736 points within 106.38,64.74 189.51,98.76
EDP_HPD_PANEL on TOP (solid shape): 279.58,187.52 279.58,187.1 279.52,187.03 278.72,187.03 278.68,187.07 278.68,187.46 278.51,187.64 277.21,187.64 276.2,186.62 275.12,186.62 275.09,186.64 275.07,186.68 275.07,187.15 275.21,187.29 276.18,187.29 276.81,187.92 279.18,187.92
FAN2_PWM_Q on TOP (solid shape): 293.36,80.57 293.36,80.21 291.73,78.59 289.65,78.59 289.09,78.02 287.94,78.02 287.86,78.11 287.86,78.53 288.95,79.62 290.3,79.62 291.29,80.61 293.32,80.61
FAN2_PWM_Q on BOTTOM (solid shape): 293.27,80.31 293.29,80.28 293.29,80.24 293.06,79.86 293.16,79.8 293.18,79.78 293.19,79.75 293.19,79.67 292.81,79.29 292.81,79.26 292.69,79.13 292.69,78.93 292.28,78.53 291.54,78.53 291.37,78.7 291.37,79.21 291.82,79.67 291.82,79.87 292.24,80.29 292.27,80.3 292.3,80.29 292.38,80.25 292.6,80.63 292.62,80.65 292.65,80.66 292.67,80.66
FB_VREF_PROBE on TOP (solid shape): 224.96,153.16 224.96,152.96 224.88,152.89 224.35,152.89 224.25,152.79 223.79,152.79 223.62,152.61 223.4,152.61 223.23,152.78 223.23,152.98 223.39,153.14 224.2,153.14 224.29,153.22 224.89,153.22
G5719LX2.5V on BOTTOM (solid shape): 200.23,92.48 200.23,91.81 200.43,91.61 202.36,91.61 202.62,91.35 202.62,90.18 202.49,90.06 199.32,90.06 199.16,90.22 199.16,92.46 199.28,92.59 200.13,92.59
G_CTL_MCU on BOTTOM (solid shape): 156.17,205.93 156.17,202.35 156.16,202.32 155.96,202.16 155.89,201.94 155.9,201.83 155.95,201.73 155.96,201.71 155.95,201.68 155.92,201.64 153.64,201.64 153.37,201.91 153.37,202.41 153.83,202.86 153.83,203.26 153.48,203.61 151.86,203.61 151.83,203.64 151.83,203.94 151.87,203.98 152.76,203.98 152.8,203.93 155.18,203.93 155.56,204.31 155.56,205.32 155.34,205.54 152.5,205.54 152.28,205.33 151.82,205.33 151.79,205.36 151.79,205.8 152.18,206.19 155.9,206.19
GPIO24_IFPF_HPD_Q on TOP (solid shape): 285.74,140.34 285.74,139.86 285.27,139.39 285.27,138.72 284.94,138.39 283.98,138.39 283.75,138.62 283.75,139.26 283.75,139.26 283.75,139.37 283.76,139.38 283.8,139.48 283.82,139.59 283.8,139.71 283.75,139.82 283.75,140.07 284.2,140.52 285.56,140.52
IN1_EQ0 on TOP (solid shape): 274.68,215.45 274.68,215.21 274.45,214.98 274.45,214.69 274.37,214.25 274.28,214.16 272.96,214.16 272.94,214.18 272.94,214.43 272.97,214.46 273.94,214.46 274.15,214.67 274.15,214.7 274.18,214.73 274.18,215 274.14,215.04 274.14,215.5 274.23,215.6 274.54,215.6
IN1_EQ1 on TOP (solid shape): 274,215.04 274,214.99 274.03,214.95 274.03,214.78 274.01,214.76 274.01,214.73 273.89,214.61 272.9,214.61 272.79,214.5 272.79,214.2 272.76,214.16 271.5,214.16 271.4,214.06 270.97,214.06 270.87,214.16 270.87,214.5 270.94,214.57 272.36,214.57 272.68,214.9 273.45,214.9 273.69,215.14 273.89,215.14
IN1_EQ2 on TOP (solid shape): 275.22,215.57 275.22,215.09 275.68,214.63 275.68,214.22 275.63,214.17 274.57,214.17 274.51,214.22 274.51,214.54 274.6,214.63 274.6,214.91 274.84,215.15 274.84,215.55 274.89,215.6 275.18,215.6
L_SPK+ on TOP (solid shape): 312.4,74.82 312.4,71.65 312.4,71.61 312.65,71.36 312.65,70.1 312.65,70.1 312.65,69.23 312.63,69.19 312.6,69.18 312.5,69.18 312.46,69.19 312.45,69.23 312.45,70.03 312.44,70.03 312.44,70.08 312.4,70.13 312.4,71.18 311.92,71.67 311.92,74.11 311.64,74.38 310.52,74.38 310.44,74.46 310.44,74.99 310.57,75.12 312.09,75.12
L_SPK+ on BOTTOM (solid shape): 265.89,48.59 265.89,47.32 265.89,47.3 265.87,47.28 264.92,47.28 264.75,47.45 264.75,48.6 264.77,48.63 264.85,48.63 264.86,48.63 265.85,48.63
L_SPK+ on IN4 (solid shape): 266.32,48.93 266.32,47.49 265.92,47.08 265.31,47.08 264.85,47.54 264.85,48.98 265.08,49.21 266.04,49.21
L_SPK+ on IN4 (solid shape): 311.86,75.02 311.86,74.55 311.7,74.38 310.24,74.38 310.15,74.4 310.06,74.41 310.01,74.41 309.97,74.43 309.96,74.46 309.96,75.05 310.09,75.17 311.71,75.17
L_SPK+_C on BOTTOM (solid shape): 264.98,46.83 265,46.82 265.03,46.82 265.89,46.82 265.89,46.14 265.56,45.81 265.56,44.24 265.41,44.08 264.9,44.08 264.77,44.21 264.77,46.67 264.94,46.84
L_SPK- on TOP (solid shape): 311.76,73.93 311.76,71.62 312.25,71.14 312.25,70.03 312.25,69.23 312.23,69.19 312.2,69.18 312.1,69.18 312.06,69.19 312.05,69.23 312.05,70.03 311.97,70.11 311.97,70.89 311.31,71.56 311.31,73.06 311.08,73.29 310.65,73.29 310.47,73.47 310.47,73.95 310.67,74.16 311.53,74.16
L_SPK- on BOTTOM (solid shape): 264.49,48.58 264.49,47.42 264.33,47.25 263.45,47.25 263.3,47.41 263.3,48.6 263.34,48.64 264.44,48.64
L_SPK- on IN4 (solid shape): 264.47,48.93 264.47,47.28 263.99,46.8 263.25,46.8 263.02,47.03 263.02,48.93 263.25,49.16 264.24,49.16
L_SPK- on IN4 (solid shape): 311.75,73.98 311.75,73.38 311.64,73.27 309.98,73.27 309.88,73.37 309.88,74.05 309.96,74.13 310.11,74.13 310.16,74.13 310.21,74.14 311.59,74.14
L_SPK-_C on BOTTOM (solid shape): 264.49,46.8 264.49,44.29 264.32,44.11 263.83,44.11 263.71,44.24 263.71,45.91 263.45,46.17 263.45,46.77 263.47,46.8 263.5,46.82 264.32,46.82 264.36,46.82 264.4,46.84 264.43,46.86
LANVCC on BOTTOM (solid shape): 314.81,99.61 314.81,99.28 314.58,99.05 313.03,99.05 312.9,98.91 312.9,98.51 312.43,98.04 312.43,97.97 312.34,97.88 311.2,97.88 310.72,97.4 310.44,97.4 310.34,97.5 310.34,97.85 310.92,98.44 312.17,98.44 312.35,98.62 312.35,99.26 312.83,99.73 314.68,99.73
LCDVCC on TOP (solid shape): 270.92,209.88 270.92,209.03 270.73,208.83 268.12,208.83 267.75,208.46 266.03,208.46 265.74,208.17 265.18,208.17 265.02,208.34 265.02,209.01 265.07,209.05 265.87,209.05 265.99,209.17 265.99,209.57 266.2,209.78 269.84,209.78 270.05,209.99 270.05,210.14 270.21,210.29 270.3,210.31 270.49,210.31
LCDVCC on BOTTOM (solid shape): 284.3,202.09 284.3,199.31 284.09,199.1 281.05,199.1 280.84,199.31 280.84,201.64 280.94,201.74 281.53,201.74 281.71,201.92 281.71,202.42 281.84,202.55 283.83,202.55
LCDVCC on BOTTOM (solid shape): 286.34,188.82 286.34,186.83 286.24,186.73 285.93,186.73 285.83,186.83 285.83,188.61 285.27,189.17 284.86,189.17 284.61,189.42 284.86,189.68 285.48,189.68
LCDVCC on IN1 (solid shape): outline of 1164 points within 267.82,199.96 283.7,210.99
LCDVCC_CONN on TOP (solid shape): 267.87,208.01 267.87,206.9 268,206.77 268.94,206.77 269.38,206.33 269.38,206.3 270.38,205.31 270.38,205.04 270.75,204.67 270.75,201.93 270.55,201.72 269.25,201.72 269.02,201.72 268.94,201.8 268.94,202.16 268.94,202.16 268.94,203.8 268.56,204.18 268.56,204.7 268.56,204.72 268.57,204.73 268.67,204.83 268.67,205.18 268.51,205.34 266.44,205.34 266.42,205.31 266.26,205.31 266.17,205.4 266.17,206.63 266.09,206.7 266.09,208.01 266.19,208.11 266.22,208.11 267.59,208.11 267.62,208.12 267.77,208.12
LED_PWR_CTL_TURBO on TOP (solid shape): 148.5,203.62 148.52,203.66 148.57,203.66 148.67,203.66 148.76,203.57 148.76,203.2 148.77,203.19 148.77,203.17 148.91,202.96 149.16,202.88 149.41,202.97 149.55,203.21 149.55,203.23 149.85,203.54 149.93,203.53 149.96,203.53 151.51,203.53 151.6,203.44 151.6,202.87 151.6,202.72 151.58,202.69 151.22,202.69 151.11,202.81 150.77,202.81 150.75,202.81 150.59,202.92 150.43,202.96 150.17,202.86 150.04,202.61 150.04,202.59 149.8,202.36 149.69,202.36 149.67,202.37 149.43,202.45 149.19,202.37 149.18,202.36 149.12,202.36 149.09,202.32 148.69,202.32 148.49,202.53 148.49,202.6 148.5,202.6
LED_PWR_CTL_TURBO on BOTTOM (solid shape): 268.7,193.17 268.97,193.17 269,193.17 270.42,193.17 270.55,193.05 270.55,192.81 270.55,192.8 270.55,192.06 270.4,191.91 269.88,191.91 269.73,192.06 269.73,192.6 269.42,192.91 267.46,192.91 267.4,192.97 266.21,192.97 265.99,192.74 264.67,192.74 264.15,192.23 263.96,192.23 263.81,192.38 263.81,192.66 264.35,193.2 265.19,193.2 265.22,193.19 265.26,193.19 265.46,193.25 265.6,193.4 265.69,193.48 267.14,193.48 267.26,193.42 267.39,193.4 267.44,193.4 267.57,193.42 267.69,193.49 268.39,193.49
