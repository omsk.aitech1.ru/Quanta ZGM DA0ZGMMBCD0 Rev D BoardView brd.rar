# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM (solid shape): 231.52,115.74 231.52,115.13 231.63,115.02 232.29,115.02 232.59,115.33 232.99,115.33 233.02,115.31 233.04,115.28 233.04,115.12 233.01,115.1 233.01,115.07 232.95,115 232.62,115 232.57,114.95 232.57,114.54 232.51,114.49 229.52,114.49 229.14,114.87 229.14,115.71 229.34,115.91 231.35,115.91
GND on BOTTOM (solid shape): 132.95,196.38 132.95,195.28 133.25,194.97 136.46,194.97 137.04,194.4 138.31,194.4 138.43,194.27 138.43,192.24 138.31,192.11 135.9,192.11 135.14,192.88 131.49,192.88 131.45,192.92 131.45,194.06 131.47,194.08 132.2,194.08 132.28,194.17 132.28,194.7 132.16,194.83 131.65,194.83 131.42,195.06 131.42,196.41 131.47,196.46 132.87,196.46
GND on BOTTOM (solid shape): 137.18,216.14 137.18,215.54 137.29,215.43 138,215.43 138.1,215.33 138.99,215.33 139.18,215.15 139.18,213.26 138.79,212.87 137.56,212.87 135.19,215.24 133.05,215.24 132.98,215.31 132.98,215.96 133.01,215.99 135.49,215.99 135.72,216.23 137.09,216.23
GND on BOTTOM (solid shape): 304.27,76.04 304.27,74.52 303.95,74.2 303.95,74.06 303.61,73.73 303.36,73.73 303.26,73.62 303.23,73.6 303.1,73.47 303.1,73.03 302.99,72.92 299.16,72.92 299.04,73.04 299.04,73.85 299.12,73.93 299.39,73.93 299.73,74.27 303.11,74.27 303.33,74.49 303.33,76.14 303.38,76.19 304.12,76.19
GND on BOTTOM (solid shape): 16.11,30.19 16.11,30.05 16.1,29.99 16.1,29.94 16.1,29.89 16.11,29.83 16.11,29.03 16.1,28.98 16.1,28.92 16.1,28.87 16.11,28.75 16.02,28.66 15.52,28.66 14.96,29.22 14.96,29.97 15.24,30.25 16.05,30.25
GND on BOTTOM (solid shape): 116.73,47.48 116.73,46.59 116.87,46.45 117.11,46.45 117.13,46.43 117.13,45.11 117.13,45.11 117.13,44.77 117.07,44.71 115.38,44.71 115.36,44.73 115.36,46.21 115.36,46.21 115.36,46.43 115.38,46.45 116.37,46.45 116.53,46.61 116.53,46.64 116.53,46.64 116.53,47.44 116.55,47.48 116.58,47.49 116.72,47.49
GND on BOTTOM (solid shape): 140.16,217.56 140.16,216.7 140.27,216.59 140.27,216.31 140.2,216.24 139.41,216.24 139.28,216.37 139.28,216.68 139.19,216.76 139.19,217.13 139.2,217.13 139.2,217.31 139.12,217.39 138.61,217.39 138.23,217.01 137.37,217.01 137.37,217.69 137.42,217.74 139.98,217.74
GND on BOTTOM (solid shape): 207.65,175.78 207.65,175.55 207.55,175.46 207.54,175.46 207.24,175.16 207.24,175.14 207.14,175.05 207.14,174.71 207.32,174.54 207.95,174.54 208,174.49 208,173.72 207.78,173.5 205.77,173.5 205.64,173.62 205.64,174.46 205.26,174.84 205.26,175.25 205.39,175.38 206.76,175.38 206.83,175.45 206.85,175.45 207.15,175.74 207.15,175.76 207.29,175.91 207.52,175.91
GND on BOTTOM (solid shape): 242.04,48.43 242.04,47.09 241.9,46.95 241.43,46.95 241.21,47.17 241.21,47.61 241.21,47.62 240.54,47.62 240.31,47.38 240.31,46.84 240.86,46.29 240.86,45.91 240.78,45.83 238.55,45.83 238.4,45.99 238.4,46.46 238.51,46.58 238.97,46.58 239.54,47.14 239.54,47.28 240.79,48.53 241.94,48.53
GND on BOTTOM (solid shape): 283.63,81.35 283.63,80.09 283.92,79.8 283.92,79.38 283.88,79.35 282.2,79.35 282.2,79.35 282.05,79.35 281.96,79.26 281.71,79.26 281.59,79.37 281.59,79.8 281.47,79.92 280.94,79.92 280.89,79.97 280.89,80.6 280.84,80.65 279.15,80.65 279.1,80.7 279.1,81.33 279.17,81.4 283.58,81.4
GND on BOTTOM (solid shape): 285.32,89.53 285.92,89.53 285.95,89.5 285.95,88.83 285.9,88.78 285.46,88.78 285.12,88.44 285.12,88 284.99,87.87 283.9,87.87 283.88,87.88 283.57,88.19 283.57,88.57 283.48,88.66 283.44,88.72 283.38,88.76 283.02,89.12 283.02,89.78 283.09,89.84 285.01,89.84
GND on BOTTOM (solid shape): 117.23,217.06 117.23,216.5 117.27,216.47 117.27,215.39 117.67,214.98 117.81,214.98 117.89,214.9 117.89,214.6 117.99,214.49 117.99,214.47 117.94,214.42 117.87,214.42 117.86,214.42 117.59,214.42 117.54,214.41 117.39,214.41 117.34,214.46 117.34,214.69 117.25,214.79 116.85,214.79 116.32,215.32 116.32,216.99 116.45,217.12 117.16,217.12
GND on BOTTOM (solid shape): 152.25,196.38 152.25,195.06 152.35,194.96 155.78,194.96 156.34,194.4 157.61,194.4 157.74,194.27 157.74,192.24 157.61,192.11 155.21,192.11 154.45,192.88 150.73,192.88 150.7,192.9 150.7,194.05 150.75,194.1 151.4,194.1 151.52,194.22 151.52,194.76 151.45,194.83 150.83,194.83 150.73,194.93 150.73,196.41 150.78,196.46 152.17,196.46
GND on BOTTOM (solid shape): 237.14,121.58 237.14,121.48 237.13,121.48 237.13,117.01 237.12,116.98 237.08,116.96 235.86,116.96 235.14,117.68 235.14,118.56 235.14,118.84 234.91,119.07 234.91,120.54 235.42,121.04 235.68,121.04 236.27,121.63 237.09,121.63
GND on BOTTOM (solid shape): 123.32,196.43 123.32,195.27 123.56,195.03 126.75,195.03 127.38,194.4 128.65,194.4 128.78,194.27 128.78,192.24 128.65,192.11 126.29,192.11 125.53,192.88 121.79,192.88 121.76,192.9 121.76,194.05 121.8,194.09 122.38,194.09 122.43,194.14 122.43,194.64 122.29,194.78 121.79,194.78 121.7,194.88 121.7,196.35 121.86,196.52 123.24,196.52
GND on BOTTOM (solid shape): 142.6,196.36 142.6,195.22 142.85,194.96 146.12,194.96 146.69,194.4 147.96,194.4 148.09,194.27 148.09,192.24 147.96,192.11 145.54,192.11 144.78,192.88 141.13,192.88 141.06,192.94 141.06,194.02 141.13,194.09 141.86,194.09 141.96,194.18 141.96,194.73 141.86,194.83 141.28,194.83 141.07,195.03 141.07,196.36 141.15,196.43 142.52,196.43
GND on BOTTOM (solid shape): 235.97,89.75 235.97,88.8 235.97,88.8 235.97,88.73 236.08,88.48 236.33,88.38 236.63,88.38 236.64,88.38 236.73,88.29 236.73,88.29 236.73,87.89 236.6,87.77 234.51,87.77 234.28,88 234.28,88.39 233.68,88.99 233.68,89.62 233.94,89.88 235.84,89.88
GND on BOTTOM (solid shape): 247.23,204.68 247.24,204.68 247.52,204.4 248.7,204.4 248.8,204.29 248.8,203.31 248.73,203.25 248.21,203.25 247.42,202.45 243.76,202.45 243.67,202.54 243.67,203.25 243.32,203.61 242.08,203.61 240.95,202.48 237.71,202.48 237.64,202.54 237.64,203.2 237.31,203.53 236.64,203.53 236.35,203.83 236.35,204.84 236.59,205.09 246.82,205.09
GND on BOTTOM (solid shape): 245.75,94.7 245.75,93.56 245.62,93.43 243.5,93.43 243.28,93.21 243.28,92.12 242.85,91.69 240.41,91.69 240.33,91.61 240.33,91.61 240.28,91.56 240.28,89.35 240.23,89.3 238.37,89.3 238.33,89.33 238.33,91.44 238.36,91.46 238.95,91.46 239.09,91.6 239.09,92.18 238.91,92.36 237.45,92.36 237.41,92.4 237.41,93.9 237.46,93.96 242.71,93.96 243.59,94.83 245.62,94.83
GND on BOTTOM (solid shape): 268.26,55.62 268.26,51.9 268.08,51.71 267.6,51.71 267.51,51.63 267.51,51.59 267.5,51.57 267.41,51.45 267.37,51.31 267.37,51.29 267.27,51.2 267.1,51.2 267.09,51.2 267,51.23 266.9,51.24 266.76,51.24 266.29,51.71 266.28,51.71 266.15,51.84 266.15,55.2 266.15,55.2 266.15,55.64 266.28,55.77 268.11,55.77
GND on BOTTOM (solid shape): 303.07,95.31 303.07,93.8 303.06,93.76 303.02,93.75 299.86,93.75 299.43,94.18 298.95,94.18 298.78,94.34 298.78,94.82 298.91,94.95 299.34,94.94 299.38,94.94 299.43,94.94 299.47,94.95 299.68,94.95 300.54,95.8 302.57,95.8
GND on BOTTOM (solid shape): 167.55,199.54 167.55,198.65 168.1,198.1 172.5,198.1 172.62,197.98 172.62,196.84 173.23,196.23 175.72,196.23 175.8,196.15 175.8,195.64 175.78,195.63 175.78,194.67 175.54,194.43 173.41,194.43 173.05,194.78 173.05,195.24 172.82,195.47 169.17,195.47 169.09,195.56 169.09,196.47 168.99,196.56 166.85,196.56 166.47,196.94 166.47,198.68 166.16,199 166.16,199.72 166.2,199.76 167.33,199.76
GND on BOTTOM (solid shape): 235.97,94.7 235.97,93.37 235.86,93.26 233.65,93.26 233.48,93.09 233.48,91.95 233.21,91.67 230.61,91.67 230.5,91.56 230.5,89.76 230.5,89.76 230.5,89.32 230.48,89.3 228.56,89.3 228.52,89.34 228.52,91.42 228.56,91.46 229.21,91.46 229.32,91.58 229.32,92.21 229.17,92.36 227.67,92.36 227.61,92.41 227.61,93.95 227.64,93.98 232.96,93.98 233.81,94.83 235.84,94.83
GND on BOTTOM (solid shape): 255.53,94.7 255.53,93.4 255.43,93.3 254.23,93.3 254.22,93.31 253.42,93.31 253,92.88 253,92.01 252.67,91.68 250.14,91.68 250.1,91.64 250.1,89.34 250.06,89.3 248.14,89.3 248.09,89.35 248.09,91.44 248.1,91.46 248.83,91.46 248.92,91.55 248.92,92.16 248.71,92.38 247.22,92.38 247.19,92.4 247.19,93.93 247.24,93.97 252.51,93.97 253.37,94.83 255.4,94.83
GND on BOTTOM (solid shape): 42.81,38.97 42.81,38.61 42.71,38.51 42.67,38.51 42.55,38.58 42.41,38.6 42.37,38.6 42.33,38.59 42.3,38.6 42.28,38.61 42.13,38.76 42.13,38.77 42.03,38.93 41.87,39.03 41.86,39.03 41.63,39.26 41.63,39.49 41.7,39.56 42.22,39.56
GND on BOTTOM (solid shape): 115.32,213.42 115.32,210.74 115.57,210.48 115.57,210.43 115.56,210.38 115.56,210 115.57,209.91 115.5,209.84 115.37,209.84 115.12,209.59 115.12,209.13 115.06,209.08 114.94,209.08 114.9,209.03 114.21,209.03 113.8,209.44 113.8,211.05 114.08,211.33 114.08,211.68 114.27,211.87 114.27,212.27 114.57,212.56 114.57,213.42 114.69,213.55 115.19,213.55
GND on BOTTOM (solid shape): 265.31,94.7 265.31,93.63 265.18,93.51 263.32,93.51 262.82,93.01 262.82,92.11 262.38,91.66 260,91.66 259.85,91.51 259.85,89.35 259.8,89.29 257.92,89.29 257.87,89.34 257.87,91.42 257.91,91.46 258.53,91.46 258.68,91.61 258.68,91.73 258.68,91.74 258.68,92.19 258.51,92.35 257.03,92.35 256.97,92.41 256.97,93.97 257.01,94 262.31,94 263.15,94.83 265.18,94.83
GND on BOTTOM (solid shape): 113.62,196.46 113.62,195.31 113.95,194.98 117.15,194.98 117.73,194.4 119,194.4 119.13,194.27 119.13,192.24 119,192.11 116.64,192.11 115.88,192.88 112.16,192.88 112.09,192.94 112.09,194.04 112.14,194.09 112.89,194.09 112.96,194.16 112.96,194.72 112.93,194.76 111.26,194.76 111.23,194.78 111.23,195.04 111.24,195.05 111.96,195.05 112.09,195.19 112.09,196.41 112.17,196.48 113.59,196.48
GND on BOTTOM (solid shape): 161.9,196.38 161.9,195.16 162.07,194.99 165.4,194.99 165.99,194.4 167.26,194.4 167.39,194.27 167.39,192.24 167.39,192.24 167.39,192.02 167.08,191.71 164.85,191.71 164.65,191.9 164.65,192.53 164.44,192.74 160.55,192.74 160.4,192.88 160.4,194.02 160.46,194.08 161,194.08 161.18,194.26 161.18,194.73 161.13,194.78 160.48,194.78 160.4,194.86 160.4,196.38 160.48,196.46 161.83,196.46
GND on BOTTOM (solid shape): 202.95,100.65 202.95,99.67 202.95,99.66 202.85,99.51 202.82,99.36 202.93,99.08 203.21,98.97 203.23,98.97 203.43,98.77 203.43,97.73 203.28,97.58 202.24,97.58 202.11,97.7 202.11,100.62 202.24,100.75 202.85,100.75
GND on BOTTOM (solid shape): 297.54,104.18 297.54,103.85 297.97,103.42 298.45,103.42 298.94,102.93 298.94,101.97 298.67,101.71 298.67,99.24 299.04,98.87 299.04,97.2 297.92,96.08 296.81,96.08 296.74,96.16 296.74,101 296.95,101.22 297.63,101.22 297.7,101.22 297.97,101.22 298.11,101.36 298.11,102.49 297.83,102.78 297.5,102.78 297.43,102.85 297.43,102.99 296.78,103.64 296.78,104.2 296.9,104.33 297.39,104.33
GND on BOTTOM (solid shape): 285.94,93.98 285.94,93.64 285.79,93.49 285.3,93.49 284.99,93.18 282.83,93.18 282.29,92.64 282.29,92.02 282.22,91.95 279.89,91.95 279.67,91.74 279.67,89.63 279.61,89.56 277.74,89.56 277.69,89.61 277.69,91.66 277.73,91.7 278.49,91.7 278.55,91.76 278.55,92.57 278.5,92.62 278.12,92.62 278.12,92.61 276.82,92.61 276.78,92.66 276.78,94.18 276.81,94.21 282.08,94.21 282.95,95.07 284.85,95.07
GND on BOTTOM (solid shape): 20.89,66.32 20.92,66.32 21.3,66.32 21.36,66.25 21.36,65.66 20.74,65.04 20.74,62.83 20.75,62.82 20.75,62.38 20.59,62.22 18.73,62.22 18.59,62.36 17.79,62.36 17.63,62.53 17.63,65.8 17.66,65.84 18.85,65.84 19.17,66.16 19.17,66.18 19.19,66.21 19.22,66.23 19.46,66.23 19.58,66.25 19.69,66.32 19.71,66.33 20.86,66.33
GND on BOTTOM (solid shape): 290.5,86.82 290.81,86.82 291.14,86.48 291.14,86.42 291.13,86.36 291.12,86.3 291.13,86.24 291.14,86.18 291.14,86.05 291.31,85.89 291.31,85.46 291.11,85.26 291.11,85.26 289.64,82.72 289.62,82.7 289.6,82.69 288.59,82.69 287.53,83.75 287.53,85.55 287.95,85.97 288.17,85.97 288.37,85.76 288.72,85.76 288.95,85.99 288.95,86.4 288.78,86.58 288.78,86.83 289,87.06 290.26,87.06
GND on BOTTOM (solid shape): 106.62,103.39 106.62,102.48 106.4,102.26 106.4,102.2 106.39,102.2 106.39,101.75 106.38,101.72 106.34,101.7 105.66,101.7 105.62,101.72 105.61,101.75 105.61,102.2 105.59,102.22 104.54,102.22 104.51,102.2 104.5,102.2 104.5,98.5 104.51,98.5 104.51,98.14 104.51,98.14 104.51,98.04 104.49,98.02 104.39,98.02 104.38,98.01 102.55,98.01 101.54,99.02 101.54,99.69 101.96,100.11 101.96,102.5 102.94,103.49 106.53,103.49
GND on BOTTOM (solid shape): 277.52,130.1 277.61,130.04 277.71,130.02 277.75,130 277.76,129.97 277.76,127.82 277.74,127.79 277.71,127.77 276.6,127.77 276.58,127.76 274.95,127.76 274.77,127.94 274.77,128.7 274.75,128.73 274.75,129.9 274.93,130.08 276.91,130.08 277,130.04 277.11,130.03 277.22,130.04 277.33,130.1
GND on BOTTOM (solid shape): 312.26,99.85 312.26,99.39 312.2,99.34 312.2,98.76 312.14,98.69 310.8,98.69 310.59,98.49 310.11,98.49 309.91,98.69 307.5,98.69 307.34,98.54 307.34,97.98 307.09,97.73 305.72,97.73 305.49,97.96 305.49,98.19 305.51,98.25 305.51,98.32 305.51,98.39 305.49,98.46 305.49,98.49 305.87,98.87 306.63,98.87 306.96,99.2 309.86,99.2 310.01,99.05 310.47,99.05 310.87,99.45 310.87,99.71 311.03,99.86 311.2,99.86 311.23,99.84 311.76,99.84 311.92,99.99 312.12,99.99
GND on BOTTOM (solid shape): 117.15,42.22 117.15,40.74 117.06,40.66 111.53,40.66 111.45,40.74 111.45,41.87 111.54,41.96 114.14,41.96 114.22,41.91 114.31,41.89 115.15,41.89 115.21,41.9 115.26,41.93 115.26,41.94 115.3,41.96 116.08,41.96 116.39,42.28 116.43,42.24 116.46,42.22 116.5,42.21 116.88,42.21 116.94,42.23 116.98,42.28 116.99,42.31 117.06,42.31
GND on BOTTOM (solid shape): 245.75,89.75 245.75,88.79 245.88,88.66 245.88,88.65 245.94,88.56 246.02,88.51 246.04,88.49 246.11,88.49 246.41,88.49 246.51,88.39 246.51,88.29 246.51,88.29 246.51,87.87 246.47,87.83 244.25,87.83 244.15,87.94 244.15,88.38 244.11,88.41 244.11,88.42 244.07,88.52 243.98,88.56 243.97,88.56 243.58,88.95 243.58,89.74 243.72,89.88 245.62,89.88
GND on BOTTOM (solid shape): 61.31,84.77 61.31,84.15 61.42,84.15 61.42,83.9 61.62,83.7 61.62,83.69 61.72,83.52 61.89,83.42 61.9,83.42 61.92,83.4 62.25,83.4 62.3,83.37 62.31,83.35 62.45,83.19 62.66,83.13 62.68,83.13 62.89,82.92 62.89,81.39 62.61,81.11 61.59,81.11 61.46,81.23 61.46,82.08 61.44,82.11 61.44,82.19 60.65,82.98 60.65,84.61 60.88,84.83 61.25,84.83
GND on BOTTOM (solid shape): 266.17,205.27 266.17,204.36 266.06,204.25 265.31,204.25 265.12,204.07 265.12,203.26 264.66,202.79 261.36,202.79 261.35,202.79 261.28,202.86 261.28,203.48 261.03,203.73 259.47,203.73 259.26,203.53 259.26,202.93 259.16,202.82 258.55,202.82 258.55,202.82 255.25,202.82 255.2,202.87 255.2,203.73 255.03,203.9 253.57,203.9 253.16,203.5 252.14,203.5 251.88,203.76 251.88,204.37 252.03,204.52 253.03,204.52 253.86,205.36 266.08,205.36
GND on BOTTOM (solid shape): 275.47,94.84 275.57,94.68 275.73,94.58 275.97,94.34 275.97,93.56 275.85,93.44 275.12,93.44 274.88,93.19 272.83,93.19 272.29,92.65 272.29,91.76 272.22,91.69 269.79,91.69 269.59,91.49 269.59,89.37 269.55,89.33 267.7,89.33 267.68,89.35 267.68,91.41 267.69,91.43 268.19,91.43 268.47,91.72 268.47,92.17 268.3,92.35 266.81,92.35 266.72,92.44 266.72,93.91 266.79,93.97 272.07,93.97 272.93,94.83 273.84,94.83 274.04,95.04 275.28,95.04
GND on BOTTOM (solid shape): 218.39,93.82 223.02,93.82 224.03,94.83 226.06,94.83 226.19,94.7 226.19,93.56 226.06,93.43 223.65,93.43 223.4,93.18 223.4,92.04 223.14,91.78 220.81,91.78 220.7,91.68 220.7,89.4 220.63,89.32 218.85,89.32 218.77,89.4 218.77,91.38 218.87,91.48 219.41,91.48 219.59,91.66 219.59,92.29 219.46,92.42 218.06,92.42 217.94,92.55 217.94,93.33 217.53,93.74 217.53,93.94 217.25,94.22 216.82,94.22 216.59,93.99 216.59,93.36 216.79,93.16 217.07,93.16 217.2,93.03 217.2,92.62 217.12,92.55 216.33,92.55 215.78,93.1 215.78,94.65 216.16,95.04 217.17,95.04
GND on BOTTOM (solid shape): 299.07,76.12 299.18,76.07 299.29,76.05 299.41,76.07 299.52,76.12 299.87,76.12 300.1,75.9 300.15,75.89 301.69,75.89 301.73,75.85 301.73,75.67 301.71,75.63 301.68,75.62 300.15,75.62 300.15,75.39 301.68,75.39 301.71,75.38 301.73,75.34 301.73,75.15 301.7,75.12 300.07,75.12 300.07,75.12 299.68,75.12 299.22,75.58 298.94,75.58 298.81,75.71 298.81,76.01 298.92,76.12
GND on BOTTOM (solid shape): 137.91,53.18 137.91,51.92 138.14,51.7 138.82,51.7 138.92,51.6 138.92,50.83 138.74,50.65 137.76,50.65 137.6,50.49 137.6,49.15 137.5,49.06 137.19,49.06 137.16,49.08 136.27,49.08 136.16,48.98 136.16,46.57 136.06,46.48 135.65,46.48 135.54,46.59 135.54,46.8 135.56,46.87 135.57,46.94 135.56,47.01 135.64,47.09 135.64,49.68 135.45,49.87 134.19,49.87 134.06,50 134.06,50.49 133.83,50.72 133.83,52.19 134.01,52.36 134.78,52.36 135.26,52.85 135.26,53.14 135.49,53.37 135.79,53.37 135.8,53.38 137.72,53.38
GND on BOTTOM (solid shape): 279.9,44.59 279.9,44.58 281.04,44.58 281.13,44.49 281.13,44.37 281.12,44.34 281.08,44.32 279.9,44.32 279.9,44.08 281.08,44.08 281.12,44.06 281.13,44.03 281.13,43.87 281.12,43.84 281.08,43.82 279.9,43.82 279.9,43.58 281.08,43.58 281.12,43.56 281.13,43.53 281.13,43.4 281.06,43.32 279.9,43.32 279.9,43.3 279.89,43.26 279.85,43.24 279,43.24 278.77,43.47 278.77,44.11 279.28,44.62 279.87,44.62
GND on BOTTOM (solid shape): 261.47,123.43 261.47,122.93 261.57,122.83 261.6,122.75 261.65,122.69 261.71,122.63 261.71,122.39 261.73,122.29 261.78,122.19 261.79,122.18 261.79,122.1 261.83,122.06 262.21,122.06 262.36,122.21 262.36,122.57 262.39,122.59 262.56,122.59 262.59,122.57 262.59,122.14 262.2,121.76 262.18,121.73 262.18,121.55 262.16,121.53 261.1,121.53 261.07,121.56 261.07,122.83 261.06,122.91 261.01,122.98 260.99,123 260.99,123.46 261.04,123.51 261.39,123.51
GND on BOTTOM (solid shape): 299.8,92.9 300.15,92.9 300.15,92.89 301.7,92.89 301.7,92.9 303.04,92.9 303.07,92.87 303.07,92.85 304.09,91.84 304.09,91.02 303.61,90.55 300.1,90.55 299.98,90.66 299.98,90.86 300,90.88 300.92,90.88 300.95,90.88 301,90.89 301.03,90.89 301.7,90.89 301.7,90.9 301.73,90.9 301.84,91.01 301.84,91.39 301.84,91.96 301.7,92.1 301.7,92.12 301.68,92.12 301.01,92.12 300.92,92.13 300.03,92.13 299.86,92.3 299.66,92.3 299.56,92.39 301.7,92.39 301.7,92.62 300.15,92.62 300.15,92.39 299.56,92.39 299.36,92.6 299.2,92.6 298.92,92.88 298.92,93.12 299.03,93.22 299.47,93.22
GND on BOTTOM (solid shape): 170.51,167.28 170.57,167.21 170.64,167.16 170.89,166.91 170.89,165.77 170.72,165.6 170.19,165.6 170.02,165.78 170.02,166.12 169.95,166.18 169.23,166.18 168.97,166.44 168.96,166.45 168.91,166.52 168.83,166.54 168.45,166.54 168.41,166.54 168.09,166.54 167.93,166.7 167.93,166.99 168.06,167.13 169.01,167.13 169.12,167.23 169.38,167.23 169.38,167.16 169.42,167.07 169.52,167.03 170.23,167.03 170.33,167.07 170.37,167.16 170.37,167.28
GND on BOTTOM (solid shape): 198.64,96.7 199.54,96.7 199.6,96.64 199.6,93.29 198.91,92.6 198.91,91.18 198.79,91.07 198.08,91.07 197.95,91.19 197.95,92.57 197.8,92.72 197.56,92.72 197.46,92.83 197.46,95.92 197.52,95.98 197.55,95.99 197.57,95.98 197.65,95.95 197.74,95.94 198.02,96.05 198.14,96.33 198.07,96.55 197.9,96.69 197.89,96.7 197.87,96.72 197.87,96.86 197.89,96.93 197.9,97 197.9,97.02 198,97.12 198.22,97.12
GND on BOTTOM (solid shape): 201.74,58.84 201.88,58.84 201.93,58.79 201.93,58.43 201.85,58.35 201.49,58.35 201.36,58.21 201.36,57.99 201.48,57.87 201.69,57.87 201.76,57.8 201.76,57.34 202.28,56.82 202.28,56.55 202.45,56.38 202.74,56.38 202.86,56.5 202.86,56.67 202.95,56.75 203.36,56.75 203.47,56.64 203.47,56.4 203.18,56.11 203.18,55.34 202.91,55.07 201.65,55.07 201.1,55.63 201.04,55.67 200.96,55.68 200.54,55.68 200.51,55.7 200.49,55.73 200.49,55.88 200.64,56.03 200.74,56.17 200.77,56.34 200.77,58.45 201.3,58.98 201.59,58.98
GND on BOTTOM (solid shape): 246.82,146.67 246.82,146.59 246.97,146.45 246.97,146.44 247.1,146.29 247.29,146.24 247.44,146.27 247.57,146.37 247.71,146.37 247.75,146.32 247.8,146.28 247.8,146.13 247.82,146.11 248.05,146.11 248.19,146.25 248.19,146.28 248.29,146.37 248.41,146.37 248.5,146.28 248.5,146.16 248.41,146.07 248.39,146.07 248.24,145.92 248.24,145.78 248.1,145.65 247.91,145.65 247.72,145.83 247.53,145.83 247.53,145.78 247.39,145.64 247.2,145.64 246.75,146.1 246.17,146.1 246.1,146.17 246.1,146.35 246.37,146.61 246.37,146.67 246.51,146.81 246.69,146.81
GND on BOTTOM (solid shape): 241.15,155.1 241.18,155.07 241.22,155.04 241.35,154.92 241.35,154.91 241.48,154.72 241.69,154.65 241.85,154.69 241.98,154.8 242.1,154.8 242.2,154.7 242.2,154.57 241.82,154.2 241.6,154.2 241.27,154.52 240.82,154.52 240.74,154.44 240.59,154.44 240.46,154.57 240.43,154.61 240.19,154.61 240.19,154.6 240.14,154.6 239.99,154.45 239.92,154.45 239.8,154.57 239.8,154.71 239.85,154.75 239.89,154.8 240,154.8 240.04,154.75 240.09,154.72 240.18,154.63 240.4,154.63 240.43,154.64 240.89,155.1
GND on BOTTOM (solid shape): 249.76,121.37 249.76,121.27 249.76,121.07 249.63,120.94 249.63,120.38 249.79,120.23 249.79,120 249.63,119.85 249.43,119.85 249.28,120 249.28,120.07 248.87,120.48 247.82,120.48 247.67,120.33 247.19,120.33 247.09,120.43 246.56,120.43 246.56,120.44 244.91,120.44 244.86,120.49 244.86,120.62 244.88,120.64 245.99,120.64 246.11,120.75 246.16,120.92 246.15,121.1 246.15,121.1 246.15,121.21 246.19,121.26 246.21,121.3 246.23,121.32 246.26,121.32 246.43,121.32 246.89,120.87 247.91,120.87 247.98,120.79 249.13,120.79 249.25,120.92 249.25,121.35 249.38,121.48 249.66,121.48
GND on BOTTOM (solid shape): 203.06,80.84 203.06,80.28 203.29,80.05 203.29,79.52 203.28,79.5 203.23,79.43 203.2,79.36 203.2,79.34 202.93,79.07 202.93,78.7 202.88,78.65 202.45,78.65 202.35,78.55 202.35,78.44 202.34,78.4 202.33,78.36 202.34,78.32 202.35,78.25 202.41,78.18 202.59,78 202.59,77.79 202.4,77.6 202.4,77.26 202.53,77.13 203.19,77.13 203.28,77.03 203.28,76.49 203.07,76.28 202.5,76.28 201.86,76.92 201.86,77.59 201.67,77.78 201.54,77.78 201.11,78.21 201.11,78.88 201.41,79.18 201.41,81.1 201.52,81.21 202.7,81.21
GND on BOTTOM (solid shape): 223.79,214.36 223.8,214.28 223.83,214.19 223.83,214.18 223.83,212.95 224.02,212.76 225.02,212.76 225.08,212.7 225.08,212.1 225.07,212.09 225.07,211.46 224.56,210.95 224.56,210.39 224.44,210.27 224.23,210.27 224.01,210.04 224.01,209.85 224.01,209.6 224.17,209.44 224.41,209.44 224.46,209.39 224.46,206.08 224.39,206.01 223.17,206.01 223.12,206.06 223.12,206.38 223.24,206.52 223.28,206.69 223.28,206.7 223.17,206.97 222.89,207.09 222.47,207.51 222.47,209.45 222.52,209.5 223.04,209.5 223.26,209.72 223.26,214.38 223.29,214.42 223.74,214.42
GND on BOTTOM (solid shape): 170.33,169.99 170.33,169.32 170.28,169.27 169.51,169.27 169.37,169.41 169.3,169.41 169.25,169.45 169.18,169.5 169.1,169.52 167.44,169.52 167.35,169.5 167.29,169.45 166.92,169.09 166.11,169.09 166.02,169.07 165.96,169.02 165.76,169.02 165.61,168.87 162.08,168.87 162.04,168.88 161.66,168.88 161.62,168.87 161.25,168.87 161.2,168.89 161.17,168.89 160.46,168.89 160.43,168.89 160.39,168.87 160.09,168.87 160.08,168.89 157.45,168.89 157.44,168.87 153.38,168.87 151.51,167.01 151.51,166.26 151.06,165.8 149.86,165.8 149.57,166.09 149.57,168.84 149.58,168.84 149.58,169.56 150.13,170.12 170.21,170.12
GND on BOTTOM (solid shape): 303.39,62.96 303.39,62.53 303.9,62.02 304.4,62.02 304.4,61.55 304.88,61.08 305.84,61.08 306.23,60.69 306.23,60.44 306.12,60.34 304.35,60.34 304.19,60.49 304.19,60.82 304.07,60.95 303.38,60.95 303.17,60.75 302.81,60.75 302.78,60.78 302.78,61.2 302.83,61.25 303.2,61.25 303.23,61.28 303.51,61.28 303.61,61.38 303.61,61.86 303.4,62.07 303.33,62.08 303.31,62.1 302.82,62.1 302.16,62.76 302.16,62.82 302.17,62.82 302.17,63.6 302.16,63.6 302.03,63.73 301.05,63.73 301.03,63.73 301,63.75 300.33,63.75 300.23,63.85 300.23,64.1 300.33,64.2 302.15,64.2
GND on BOTTOM (solid shape): 295.02,94.95 295.02,94.83 295.02,94.83 295.02,94.7 294.93,94.61 294.87,94.61 294.64,94.38 294.64,94.05 294.87,93.82 294.9,93.82 295.02,93.7 295.02,93.31 294.9,93.18 294.23,93.18 294.15,93.26 294.15,93.53 294.09,93.59 292.66,93.59 292.28,93.21 292.28,92.09 292.14,91.95 289.7,91.95 289.59,91.84 289.59,89.65 289.51,89.56 287.64,89.56 287.58,89.62 287.58,91.68 287.64,91.75 288.29,91.75 288.44,91.9 288.44,92.46 288.28,92.62 286.76,92.62 286.66,92.71 286.66,94.12 286.74,94.2 291.98,94.2 292.41,94.63 294.22,94.63 294.22,94.63 294.39,94.63 294.47,94.72 294.47,94.87 294.5,94.92 294.52,94.97 294.63,95.08 294.89,95.08
GND on BOTTOM (solid shape): 312.83,74.01 312.83,71.82 313.03,71.62 313.03,68.87 313.28,68.63 313.69,68.63 313.73,68.62 313.74,68.58 313.74,68.55 314.52,68.55 314.56,68.55 314.63,68.48 314.63,64.2 314.58,64.16 313.9,64.16 313.88,64.18 313.1,64.18 313.08,64.16 312.81,64.16 312.6,63.95 312.6,63.34 312.54,63.28 310.57,63.28 310.41,63.45 310.41,65.71 310.07,66.05 309.89,66.05 308.54,67.4 307.25,67.4 307.14,67.4 306.12,67.4 305.5,66.77 305.18,66.77 305.18,66.77 305.07,66.77 304.85,66.55 299.83,66.55 299.75,66.63 299.75,69.14 300.23,69.62 304.91,69.62 304.91,69.62 305.68,69.62 305.89,69.41 310.18,69.41 311.26,70.49 311.26,71.9 311.26,72.04 311.26,72.28 311.97,72.99 311.97,73.83 312.23,74.09 312.75,74.09
GND on BOTTOM (solid shape): 313.6,87.49 313.73,87.34 313.92,87.27 313.94,87.27 314.2,87.01 314.2,86.58 313.59,85.97 313.59,84.59 313.38,84.24 313.59,83.89 313.59,83.43 312.98,82.82 311.28,82.82 311.15,82.94 311.15,83.94 311.2,83.99 311.91,83.99 312.03,83.92 312.17,83.89 312.42,83.99 312.56,84.23 312.56,84.25 312.93,84.62 312.93,85.96 313,86.03 313.09,86.18 313.13,86.35 313.08,86.56 312.93,86.72 312.93,87.36 313.08,87.52 313.59,87.52
GND on BOTTOM (solid shape): 291.04,117.95 291.72,117.95 292,117.67 292,117.39 290.55,115.94 290.55,111.93 289.92,111.29 288.85,111.29 288.67,111.11 287.61,111.11 287.35,111.37 287.35,112.57 288.34,112.57 288.34,112.51 288.35,112.45 288.36,112.4 288.39,112.35 288.42,112.3 288.45,112.26 288.5,112.22 288.54,112.19 288.6,112.17 288.65,112.15 288.71,112.15 288.76,112.15 288.82,112.15 288.87,112.17 288.92,112.19 288.97,112.22 289.01,112.26 289.05,112.3 289.08,112.35 289.1,112.4 289.12,112.45 289.13,112.51 289.13,112.57 289.12,112.62 289.1,112.68 289.08,112.73 289.05,112.78 289.01,112.82 288.97,112.85 288.92,112.89 288.87,112.91 288.82,112.92 288.76,112.93 288.71,112.93 288.65,112.92 288.6,112.91 288.54,112.89 288.5,112.85 288.45,112.82 288.42,112.78 288.39,112.73 288.36,112.68 288.35,112.62 288.34,112.57 287.35,112.57 287.35,112.7 288.13,113.48 288.17,113.49 288.23,113.51 288.27,113.54 288.32,113.58 288.36,113.62 288.39,113.67 288.41,113.72 288.42,113.76 288.51,113.86 288.51,114.69 288.52,114.69 288.52,116.93 289.82,118.23 290.76,118.23
GND on BOTTOM (solid shape): 242.84,133.77 242.86,133.76 242.87,133.75 243.26,133.37 243.28,133.37 243.3,133.36 243.35,133.27 243.3,133.18 243.2,133.1 243.15,132.98 243.15,132.96 243.13,132.94 242.91,132.88 242.8,132.78 242.79,132.77 242.72,132.7 242.72,132.46 242.91,132.27 242.91,132.16 242.82,132.07 242.68,132.07 242.42,132.32 242.32,132.32 242.15,132.49 242.15,132.64 242.32,132.81 242.46,132.81 242.56,132.91 242.57,132.94 242.65,133.04 242.69,133.13 242.72,133.2 242.73,133.28 242.69,133.42 242.6,133.54 242.56,133.61 242.59,133.69 242.66,133.76 242.68,133.77
GND on BOTTOM (solid shape): 15.16,47.69 16.47,47.69 17.14,47.03 17.14,45.93 17.51,45.55 17.51,44.5 17.15,44.13 13.1,44.13 12.59,43.62 12.59,39.79 12.33,39.54 10.3,39.54 10.2,39.64 10.2,40.8 9.45,41.77 8.32,41.31 2.71,41.31 2.71,44.31 0.51,44.31 0.51,45.19 13.8,45.19 14.77,45.94 14.31,47.07 14.31,47.6 14.4,47.7 15.16,47.7
GND on BOTTOM (solid shape): outline of 87 points within 192.68,127.24 197.81,171.49
GND on BOTTOM (solid shape): 20.29,59.65 20.38,59.6 20.37,59.49 20.31,59.37 20.28,59.25 20.4,58.97 20.68,58.85 20.83,58.88 20.95,58.96 21.02,58.99 21.09,58.96 21.22,58.88 21.37,58.85 21.65,58.97 21.76,59.24 21.74,59.37 21.68,59.49 21.67,59.6 21.76,59.65 22.03,59.65 22.21,59.47 22.21,58.89 21.61,58.28 21.57,58.26 21.53,58.28 21.52,58.29 19.87,58.29 19.86,58.31 19.86,59.33 19.83,59.35 19.83,59.57 19.91,59.65
GND on BOTTOM (solid shape): 247.11,153.29 247.11,153.24 247.18,153.17 247.38,153.17 247.6,153.39 248.42,153.39 248.5,153.31 248.5,153.14 248.25,152.89 247.65,152.89 247.4,152.64 247.21,152.64 247.07,152.78 246.82,152.78 246.82,152.78 246.68,152.63 246.5,152.63 246.36,152.77 246.12,152.77 245.99,152.65 245.8,152.65 245.68,152.76 245.63,152.76 245.55,152.77 245.47,152.76 245.41,152.76 245.29,152.64 245.11,152.64 244.96,152.78 244.73,152.78 244.6,152.65 244.39,152.65 244.09,152.95 243.37,152.95 243.23,152.81 242.65,152.81 242.52,152.68 242.29,152.68 242.17,152.8 242.17,152.88 241.89,153.16 241.88,153.16 241.85,153.18 241.85,153.19 241.85,153.22 241.86,153.25 241.99,153.37 242.12,153.37 242.31,153.19 242.51,153.19 242.69,153.37 242.82,153.37 242.94,153.25 243.27,153.25 243.39,153.37 243.53,153.37 243.59,153.31 244.01,153.31 244.07,153.37 244.22,153.37 244.41,153.18 244.59,153.18 244.77,153.36 244.92,153.36 245.06,153.22 245.33,153.22 245.48,153.37 245.62,153.37 245.69,153.3 245.69,153.29 245.77,153.21 246.02,153.21 246.26,153.45 246.95,153.45
GND on BOTTOM (solid shape): 39.92,39.06 39.92,38.35 39.91,38.34 39.91,36.78 39.64,36.78 39.64,36.33 39.63,36.3 39.59,36.28 38.91,36.28 38.87,36.3 38.86,36.33 38.86,36.78 38.39,36.78 38.39,36.33 38.38,36.3 38.34,36.28 37.66,36.28 37.62,36.3 37.61,36.33 37.61,36.78 36.47,36.78 36.24,37.01 36.24,37.7 36.5,37.97 36.78,37.97 36.89,37.91 37.02,37.89 37.18,37.92 37.31,38.01 37.39,38.04 37.46,38.01 37.59,37.92 37.75,37.89 38.02,38.01 38.14,38.28 38.08,38.5 37.91,38.64 37.85,38.72 37.88,38.81 38.09,39.02 39.2,39.02 39.29,39.11 39.87,39.11
GND on BOTTOM (solid shape): 23.81,24.45 23.81,21.74 23.74,21.67 23.61,21.67 23.59,21.68 23.42,21.77 23.22,21.81 23.11,21.8 23.02,21.77 22.92,21.8 22.82,21.81 22.61,21.77 22.42,21.67 22.41,21.67 22.22,21.77 22.02,21.81 21.91,21.8 21.82,21.77 21.72,21.8 21.62,21.81 21.41,21.77 21.22,21.67 21.21,21.67 21.02,21.77 20.82,21.81 20.71,21.8 20.62,21.77 20.52,21.8 20.42,21.81 20.21,21.77 20.02,21.67 20.01,21.67 19.82,21.77 19.62,21.81 19.51,21.8 19.42,21.77 19.32,21.8 19.22,21.81 19.16,21.8 19.11,21.8 19.03,21.82 19,21.9 19,24.47 19.01,24.48 23.78,24.48
GND on BOTTOM (solid shape): 247.16,58 247.16,57.98 247.29,57.73 247.55,57.64 247.68,57.66 247.79,57.71 247.8,57.72 247.94,57.72 247.98,57.67 248.13,57.58 248.3,57.54 248.45,57.57 248.59,57.64 248.62,57.65 248.65,57.64 248.79,57.56 248.95,57.53 249.13,57.56 249.28,57.67 249.32,57.69 249.35,57.68 249.47,57.62 249.6,57.59 249.63,57.6 249.67,57.6 249.75,57.58 249.79,57.5 249.79,55.8 248.95,54.96 248.95,54.46 248.93,54.44 248.93,52.9 248.92,52.86 248.88,52.85 247.88,52.85 247.01,51.98 247.01,51.22 245.82,50.02 241.5,50.02 241.44,50.08 241.44,53.41 241.51,53.48 246.22,53.48 247.52,54.78 247.52,57.02 247.36,57.19 247.17,57.19 247.17,57.2 246.64,57.2 246.62,57.19 246.43,57.19 246.33,57.3 246.33,57.95 246.35,57.99 246.38,58 246.5,58 246.52,58.02 247.13,58.02
GND on BOTTOM (solid shape): 240.67,131.61 240.74,131.58 240.79,131.53 240.81,131.47 240.78,131.41 240.69,131.28 240.66,131.12 240.69,130.97 240.77,130.84 241.07,130.54 241.2,130.46 241.35,130.43 241.4,130.43 241.47,130.41 241.5,130.35 241.5,130.04 241.43,129.97 241.29,129.97 241.15,130.1 241.09,130.12 241.02,130.13 240.85,130.08 240.72,129.96 240.64,129.92 240.57,129.97 240.53,130.04 240.47,130.1 240.46,130.11 240.45,130.13 240.45,130.15 240.45,130.17 240.59,130.31 240.63,130.47 240.63,130.5 240.54,130.73 240.32,130.84 240.27,130.86 240.25,130.88 240.25,130.89 240.22,130.95 240.19,131.01 240.19,131.36 240.33,131.51 240.52,131.51 240.56,131.54 240.61,131.59
GND on BOTTOM (solid shape): 143.65,205.41 143.65,204.11 143.56,204.02 143.25,204.02 142.97,203.73 142.97,202.66 142.95,202.58 142.94,202.51 142.95,202.44 142.97,202.37 142.97,202.1 142.89,201.87 142.97,201.63 142.97,201.33 142.86,201.22 141.72,201.22 141.33,201.6 141.33,201.96 141.36,202.03 141.44,202.06 141.83,202.46 141.44,202.85 141.36,202.88 141.33,202.95 141.33,203.28 141.36,203.35 141.44,203.38 141.67,203.46 141.81,203.66 141.86,203.72 141.93,203.73 141.97,203.72 142.01,203.72 142.29,203.84 142.4,204.12 142.35,204.31 142.2,204.47 142.2,204.49 142.2,205.46 142.3,205.56 143.51,205.56
GND on BOTTOM (solid shape): outline of 99 points within 107.22,67.53 110.65,76.01
GND on BOTTOM (solid shape): 123.75,151.33 124.32,151.33 124.32,150.7 124.68,150.34 124.68,149.94 124.69,149.89 124.69,149.86 124.67,149.75 124.6,149.66 124.52,149.47 124.6,149.29 124.67,149.2 124.69,149.09 124.61,148.91 124.42,148.83 124.32,148.85 124.24,148.9 124.06,148.97 123.89,148.89 123.83,148.84 123.76,148.81 123.56,148.81 123.5,148.84 123.45,148.88 123.28,148.94 123.11,148.88 123.06,148.84 123,148.81 122.8,148.81 122.65,148.92 122.59,149.09 122.62,149.21 122.68,149.31 122.75,149.47 122.68,149.64 122.64,149.7 122.61,149.76 122.6,149.8 122.12,150.28 122.11,150.3 122.1,150.31 122.1,150.48 122.07,150.59 121.98,150.66 121.97,150.66 121.95,150.69 121.95,151.35 123.72,151.35
GND on BOTTOM (solid shape): 7.78,90.22 7.82,90.18 7.82,89.71 8.03,89.51 8.07,88.96 8.46,88.59 8.52,88.53 8.66,88.53 8.78,88.52 8.9,88.53 9.22,88.53 9.46,88.29 9.46,83.64 9.17,83.35 9.12,83.35 8.28,83.25 8.03,82.45 7.82,82.24 7.82,81.53 7.78,81.49 7.2,81.49 7.19,81.5 7.19,83.64 6.44,84.62 5.31,84.15 1.51,84.15 1.51,87.8 5.31,87.8 6.44,87.33 7.19,88.3 7.19,90.18 7.22,90.22 7.66,90.22
GND on BOTTOM (solid shape): 237.75,148.06 237.75,147.94 238.06,147.63 238.35,147.63 238.57,147.85 239.95,147.85 240.14,147.66 240.17,147.63 240.45,147.63 240.63,147.82 240.67,147.82 240.86,147.63 241.13,147.63 241.15,147.63 241.31,147.8 241.39,147.8 241.52,147.67 241.7,147.62 241.88,147.67 242.01,147.81 242.13,147.81 242.22,147.72 242.22,147.47 241.95,147.21 241.95,147.21 241.86,147.16 241.8,147.09 241.6,147.09 241.53,147.16 241.44,147.21 241.43,147.21 241.41,147.24 241.41,147.33 241.14,147.6 240.85,147.6 240.72,147.47 240.57,147.47 240.43,147.61 240.13,147.61 239.94,147.42 239.23,147.42 239.05,147.61 239.04,147.61 238.99,147.66 238.8,147.66 238.56,147.42 238.52,147.42 238.48,147.47 238.43,147.51 238.43,147.52 238.35,147.6 238.04,147.6 237.89,147.45 237.79,147.45 237.48,147.62 237.18,147.42 235.7,147.42 235.63,147.49 235.63,147.75 235.97,148.1 236.25,148.1 236.45,148.02 236.65,148.1 236.95,148.1 237.09,148.02 237.25,148.03 237.42,148.2 237.61,148.2
GND on BOTTOM (solid shape): outline of 119 points within 225.97,144.23 248.5,145.41
GND on BOTTOM (solid shape): 241.07,133.5 241.07,133.5 241.16,133.39 241.28,133.32 241.3,133.32 241.31,133.3 241.33,133.27 241.31,133.23 241.3,133.22 241.29,133.22 241.11,133.11 241.05,132.92 241.14,132.71 241.35,132.62 241.42,132.62 241.44,132.62 241.5,132.55 241.5,132.17 241.41,132.08 241.38,132.07 241.34,132.08 241.33,132.1 241.2,132.18 241.05,132.21 240.89,132.18 240.76,132.08 240.69,132.05 240.63,132.08 240.6,132.11 240.57,132.14 240.54,132.2 240.56,132.26 240.64,132.38 240.66,132.52 240.61,132.71 240.48,132.85 240.44,132.92 240.48,133 240.6,133.12 240.65,133.3 240.55,133.54 240.31,133.65 240.29,133.65 240.25,133.68 240.24,133.7 240.21,133.79 240.14,133.86 240.13,133.87 240.12,133.9 240.12,134.02 240.27,134.17 240.4,134.17
GND on BOTTOM (solid shape): outline of 101 points within 226.78,135.04 239.42,136.58
GND on BOTTOM (solid shape): outline of 129 points within 116.74,70.97 123.01,76.04
GND on BOTTOM (solid shape): 255.35,133.24 255.39,133.28 255.44,133.26 255.58,133.12 256.21,133.12 256.24,133.11 256.26,133.1 256.26,132.82 256.22,132.78 256.21,132.77 256.19,132.77 254.92,132.77 254.69,132.53 254.65,132.52 254.49,132.48 254.36,132.33 254.33,132.32 254.26,132.32 254.23,132.34 254.23,132.35 253.95,132.52 253.67,132.35 253.67,132.34 253.64,132.32 253.57,132.32 253.54,132.33 253.53,132.35 253.39,132.49 253.2,132.52 253.18,132.52 253.16,132.53 253.13,132.56 253.12,132.58 253.13,132.63 253.13,132.67 253.12,132.76 253.08,132.85 253.07,132.92 253.11,132.98 253.15,133.02 253.18,133.06 253.25,133.09 253.6,132.92 253.95,133.09 254.3,132.92 254.65,133.09 254.72,133.06 254.84,132.96 255,132.92 255.23,133.01 255.35,133.22
GND on BOTTOM (solid shape): outline of 134 points within 209.97,38.63 220.93,44.44
GND on BOTTOM (solid shape): 297.37,82.2 297.54,82.16 297.71,82.2 297.72,82.21 297.98,82.21 298.14,82.05 298.14,82.03 298.26,81.78 298.51,81.67 298.52,81.67 298.78,81.41 298.78,80.79 298.75,80.71 298.74,80.63 298.75,80.56 298.78,80.48 298.78,79.97 298.83,79.92 298.85,79.88 298.83,79.84 297.52,78.54 297.31,78.54 296.6,77.83 296.6,75.37 296.36,75.13 293.67,75.13 293.67,75.13 293.39,75.13 293.29,75.23 293.29,76.64 293.03,76.9 289.43,76.9 289.2,77.13 289.2,77.98 289.49,78.27 292.42,78.27 293.07,78.92 293.07,79.19 293.44,79.56 293.44,79.59 293.69,80.01 293.72,80.04 293.76,80.03 294.35,79.69 294.37,79.66 294.37,79.62 294.14,79.23 294.63,78.95 294.68,78.87 294.63,78.78 294.5,78.64 294.45,78.45 294.57,78.17 294.85,78.05 294.99,78.08 295.11,78.15 295.18,78.18 295.24,78.15 295.37,78.08 295.51,78.05 295.9,78.45 295.51,78.84 295.45,78.84 295.39,78.83 295.28,78.86 295.27,78.97 296.95,81.88 296.94,81.89 296.93,81.91 296.93,82.02 297.12,82.21 297.36,82.21
GND on BOTTOM (solid shape): outline of 152 points within 227.19,142.84 248.5,144
GND on BOTTOM (solid shape): outline of 155 points within 226.02,152.63 241.55,154.79
GND on BOTTOM (solid shape): outline of 176 points within 226.49,151.21 248.51,152.4
GND on BOTTOM (solid shape): outline of 98 points within 239.8,134.57 247.8,136.87
GND on BOTTOM (solid shape): outline of 148 points within 226.45,149.83 248.5,151.01
GND on BOTTOM (solid shape): outline of 85 points within 235.6,145.64 242.19,146.74
GND on BOTTOM (solid shape): outline of 188 points within 226.99,156.84 247.8,158.14
GND on BOTTOM (solid shape): 7.82,76.2 7.82,75.91 8.08,75.65 8.22,74.75 9.11,74.59 9.25,74.59 9.46,74.38 9.46,73.89 6.73,71.15 6.73,69.26 6.13,66.98 4,65.98 3.52,65.98 3.52,64.49 4.02,63.99 4.02,61.42 4.23,60.92 13.8,60.92 13.9,60.92 17.15,60.92 17.45,60.62 17.45,59.72 17.18,59.46 16.52,59.46 15.82,58.76 15.67,58.12 15.32,57.57 15.32,57.27 15.27,57.18 15.17,57.19 14.98,57.27 14.77,57.3 14.61,57.28 14.45,57.23 14.36,57.24 14.31,57.32 14.31,58.03 14.77,59.16 13.8,59.91 0.51,59.91 0.51,60.94 0.71,61.14 2.31,61.14 3.01,61.84 3.01,63.57 2.51,64.07 2.51,66.89 2.61,66.99 4,66.99 5.76,68.75 4,70.51 2.61,70.51 2.51,70.61 2.51,71.66 1.81,72.36 0.71,72.36 0.51,72.56 0.51,73.8 5.31,73.8 6.44,73.33 7.19,74.3 7.19,76.18 7.23,76.23 7.79,76.23
GND on BOTTOM (solid shape): outline of 194 points within 218.14,136.86 279,187.29
GND on BOTTOM (solid shape): outline of 93 points within 228.48,128.74 229.69,132.94
GND on BOTTOM (solid shape): outline of 251 points within 225.8,155.42 248.52,156.7
GND on BOTTOM (solid shape): outline of 191 points within 227.18,137.23 247.8,137.97
GND on BOTTOM (solid shape): outline of 203 points within 227.19,138.64 248.23,139.81
GND on BOTTOM (solid shape): outline of 161 points within 0.51,0.51 298.62,68.26
GND on BOTTOM (solid shape): outline of 215 points within 226.5,141.44 248.5,142.61
GND on BOTTOM (solid shape): outline of 231 points within 227.2,140.04 247.09,141.19
GND on BOTTOM (solid shape): outline of 1948 points within 0.51,70.01 322.89,222.04
GND on BOTTOM (solid shape): outline of 1625 points within 240.45,127.82 257,135.37
GND on SGND (solid shape): outline of 17268 points within 0.51,0.51 322.89,222.04
GND on IN1 (solid shape): 245.68,97.8 236.29,97.8 236.29,104 245.68,104
GND on IN1 (solid shape): 255.4,97.8 246.07,97.8 246.07,104 255.4,104
GND on IN1 (solid shape): 265.81,97.8 255.78,97.8 255.78,104 265.81,104
GND on IN1 (solid shape): 275.34,97.8 266.2,97.8 266.2,104 275.34,104
GND on IN1 (solid shape): 284.86,97.8 275.72,97.8 275.72,104 284.86,104
GND on IN1 (solid shape): 235.91,97.8 225.16,97.8 224.88,98.09 224.88,102.76 226.12,104 235.91,104
GND on IN1 (solid shape): 291.92,103.62 291.92,98.28 291.44,97.8 285.25,97.8 285.25,104 291.54,104
GND on IN1 (solid shape): 38.1,100.67 38.1,97.04 37.87,96.81 37.21,96.81 36.88,97.14 35.36,97.14 34.88,96.66 34.27,96.66 33.48,97.45 33.48,100.54 34.06,101.12 37.65,101.12
GND on IN1 (solid shape): 211.66,85.26 211.66,84.8 212.2,84.26 212.2,84.07 211.53,83.4 209.12,83.4 208.94,83.58 208.94,84.19 208.44,84.7 208.44,85.03 208.77,85.36 211.56,85.36
GND on IN1 (solid shape): 219.76,49.11 219.76,48.17 218.94,47.34 215.56,47.34 215.49,47.42 215.49,49.05 215.56,49.12 218.5,49.12 218.96,49.58 219.29,49.58
GND on IN1 (solid shape): 33.53,83.51 33.53,79.77 33.3,79.54 32.64,79.54 32.31,79.87 30.79,79.87 30.31,79.39 29.7,79.39 28.91,80.18 28.91,82.43 28.93,82.45 28.97,82.5 28.98,82.55 28.98,82.69 29.24,82.96 29.24,83.21 30.04,84.01 33.03,84.01
GND on IN1 (solid shape): 225.34,104 225.43,103.94 225.41,103.83 224.55,102.97 224.51,102.91 224.5,102.83 224.5,98.01 224.5,97.97 224.51,97.94 224.5,97.85 224.41,97.8 217.35,97.8 215.93,99.23 215.93,103.7 216.23,104
GND on IN1 (solid shape): 259.46,121.76 259.46,118.96 259.34,118.83 257.85,118.83 257.75,118.88 257.65,118.9 257.55,118.88 257.45,118.83 255.78,118.83 255.68,118.74 255.66,118.72 255.62,118.73 255.46,118.77 255.29,118.74 255.26,118.73 255.23,118.75 255.15,118.83 255.15,119.47 255.53,119.85 255.53,121.63 255.78,121.88 259.34,121.88
GND on IN1 (solid shape): 242.8,183.83 242.8,183.57 242.67,183.45 241.99,183.45 241.68,183.14 241.67,183.14 241.5,183.02 241.43,182.82 241.44,182.79 241.44,182.75 241.41,182.7 241.35,182.69 241.31,182.69 241.2,182.66 241.11,182.6 240.91,182.4 240.9,182.4 240.79,182.35 240.71,182.26 240.63,182.21 240.54,182.26 240.49,182.32 240.43,182.36 240.39,182.45 240.43,182.54 240.54,182.63 240.59,182.76 240.59,182.78 241.01,183.2 241.12,183.2 241.5,183.58 241.5,183.79 241.63,183.92 241.65,183.93 241.67,183.94 242.69,183.94
GND on IN1 (solid shape): 273.38,150.46 273.47,150.41 273.5,150.37 273.54,150.33 273.58,150.24 273.53,150.16 273.42,150.05 273.38,149.89 273.41,149.76 273.48,149.65 273.56,149.56 273.67,149.51 273.68,149.5 274.02,149.16 274.02,148.96 273.89,148.83 273.67,148.83 273.64,148.84 273.6,148.89 273.34,149.14 273.34,149.16 273.22,149.33 273.02,149.4 272.97,149.4 272.94,149.44 272.93,149.48 272.78,149.63 272.78,149.97 273.04,150.22 273.2,150.29 273.29,150.41
GND on IN1 (solid shape): 273.38,158.2 273.47,158.15 273.57,158.04 273.71,157.98 273.73,157.98 273.99,157.72 274.08,157.66 274.19,157.63 274.24,157.62 274.25,157.52 274.31,157.32 274.48,157.2 274.5,157.2 274.52,157.18 274.6,157.18 274.87,156.9 274.87,155.83 274.76,155.71 274.51,155.71 274.42,155.79 274.42,156.56 274.1,156.88 274.1,156.89 273.98,157.08 273.78,157.15 273.73,157.15 273.69,157.14 273.65,157.18 273.64,157.23 273.64,157.25 273.61,157.37 273.55,157.46 273.38,157.64 273.37,157.65 273.33,157.72 273.27,157.79 273.23,157.82 273.19,157.85 273.13,157.94 273.18,158.03 273.24,158.08 273.29,158.15
GND on IN1 (solid shape): 200.5,151.91 200.53,151.84 200.53,151.24 200.55,151.13 200.62,151.03 200.92,150.73 200.93,150.7 201.05,150.54 201.24,150.48 201.3,150.48 201.33,150.48 201.36,150.46 201.37,150.44 201.37,150.4 201.39,150.28 201.46,150.19 201.65,149.99 201.66,149.98 201.74,149.84 201.87,149.75 201.89,149.72 201.91,149.69 201.9,149.66 201.87,149.63 201.78,149.58 201.71,149.49 201.62,149.43 201.53,149.48 201.48,149.54 201.42,149.59 201.35,149.62 201.1,149.88 201.01,149.94 200.89,149.96 200.86,149.96 200.79,149.99 200.76,150.07 200.76,150.08 200.73,150.22 200.64,150.33 200.58,150.38 200.51,150.42 200.28,150.65 200.27,150.67 200.26,150.69 200.26,151.84 200.29,151.9 200.35,151.94 200.44,151.94
GND on IN1 (solid shape): 202.29,136.36 202.29,136.2 202.54,135.96 202.69,135.96 202.71,135.96 202.73,135.95 202.97,135.71 202.97,134.94 203.44,134.47 203.47,134.39 203.43,134.32 203.28,134.25 203.19,134.12 203.11,134.1 203.04,134.15 202.99,134.22 202.93,134.27 202.84,134.31 202.75,134.33 202.42,134 202.75,133.66 202.8,133.67 202.85,133.68 202.96,133.74 203.04,133.84 203.11,133.89 203.19,133.87 203.31,133.72 203.5,133.66 203.55,133.67 203.6,133.68 203.75,133.78 203.83,133.94 203.87,134.01 203.95,134.02 203.98,134.02 204.01,134.02 204.22,134.02 204.32,133.92 204.32,133.54 204.29,133.51 202.1,133.51 201.83,133.78 201.83,134.28 201.9,134.34 201.93,134.42 202,134.45 202.01,134.45 202.24,134.55 202.33,134.78 202.33,134.82 202.3,134.98 202.19,135.1 202.14,135.19 202.19,135.27 202.3,135.39 202.34,135.55 202.3,135.71 202.18,135.83 202.11,135.86 201.96,136.01 201.96,136.02 201.78,136.2 201.78,136.48 201.88,136.57 202.08,136.57
GND on IN1 (solid shape): outline of 135 points within 254.76,179.56 258.07,183.83
GND on IN1 (solid shape): outline of 292 points within 233.34,172.6 236.73,176.67
GND on IN1 (solid shape): outline of 148 points within 224.46,179.57 229.05,182.76
GND on IN1 (solid shape): outline of 159 points within 221.56,149.36 224.31,156.22
GND on IN1 (solid shape): outline of 353 points within 249.96,146.76 253.99,151
GND on IN1 (solid shape): outline of 392 points within 220.03,140.15 224.63,145.75
GND on IN1 (solid shape): outline of 189 points within 249.96,152.36 253.41,156.93
GND on IN1 (solid shape): outline of 176 points within 0.51,0.51 298.62,67.27
GND on IN1 (solid shape): outline of 496 points within 234.37,159.46 239.52,164.94
GND on IN1 (solid shape): outline of 1079 points within 247.49,157.26 257.87,165.41
GND on IN1 (solid shape): outline of 2164 points within 0.51,57.17 322.89,222.04
GND on IN1 (solid shape): outline of 7700 points within 194.85,126.42 280.79,186.51
GND on SGND1 (solid shape): outline of 14572 points within 0.51,0.51 322.89,222.04
GND on IN2 (solid shape): 292.1,103.44 292.1,98.46 291.44,97.8 217.35,97.8 215.93,99.23 215.93,103.7 216.23,104 291.54,104
GND on IN2 (solid shape): 38.1,100.94 38.1,97.04 37.87,96.81 37.21,96.81 36.88,97.14 35.36,97.14 34.88,96.66 34.27,96.66 33.48,97.45 33.48,100.68 33.97,101.17 37.87,101.17
GND on IN2 (solid shape): 211.66,85.26 211.66,84.8 212.15,84.31 212.15,84.04 211.51,83.4 209.44,83.4 208.94,83.9 208.94,84.19 208.44,84.7 208.44,85.03 208.77,85.36 211.56,85.36
GND on IN2 (solid shape): 219.74,49.42 219.74,48.14 218.94,47.34 215.56,47.34 215.49,47.42 215.49,49.05 215.56,49.12 215.83,49.12 216.31,49.6 216.31,49.95 216.51,50.15 219,50.15
GND on IN2 (solid shape): 33.53,83.51 33.53,79.77 33.3,79.54 32.64,79.54 32.31,79.87 30.79,79.87 30.31,79.39 29.7,79.39 28.91,80.18 28.91,81.93 29.52,82.54 29.59,82.66 29.62,82.79 29.62,83.08 29.62,83.1 29.63,83.11 29.71,83.19 29.79,83.31 29.82,83.44 29.82,83.85 30.04,84.07 32.97,84.07
GND on IN2 (solid shape): 259.39,121.52 259.39,119.37 258.86,118.83 257.85,118.83 257.75,118.88 257.65,118.9 257.55,118.88 257.45,118.83 255.78,118.83 255.68,118.74 255.66,118.72 255.62,118.73 255.46,118.77 255.29,118.74 255.26,118.73 255.23,118.75 255.15,118.83 255.15,119.47 255.53,119.85 255.53,121.63 255.78,121.88 259.03,121.88
GND on IN2 (solid shape): outline of 88 points within 249.78,142.86 253.84,146.11
GND on IN2 (solid shape): outline of 250 points within 222.38,144.25 224.31,151
GND on IN2 (solid shape): outline of 281 points within 230.95,158.94 236.43,162.17
GND on IN2 (solid shape): outline of 126 points within 221.46,158.58 225.48,161.98
GND on IN2 (solid shape): outline of 146 points within 225.04,157.91 230.1,162.14
GND on IN2 (solid shape): outline of 162 points within 220.24,154.83 224.77,158.43
GND on IN2 (solid shape): outline of 432 points within 247.5,157.61 253.06,162.16
GND on IN2 (solid shape): outline of 167 points within 0.51,0.51 298.62,67.27
GND on IN2 (solid shape): outline of 565 points within 240.03,158.91 249.39,165.14
GND on IN2 (solid shape): outline of 2192 points within 0.51,57.17 322.89,222.04
GND on SVCC (solid shape): outline of 242 points within 304.07,84.04 321.37,103.35
GND on SVCC (solid shape): outline of 153 points within 108.93,180.94 203.32,219.68
GND on SVCC (solid shape): outline of 697 points within 205.69,125.57 269.73,179.03
GND on SVCC (solid shape): outline of 1834 points within 100.14,70.7 188.51,142.18
GND on SVCC (solid shape): outline of 2961 points within 3.89,2.03 82.86,104.58
GND on SVCC1 (solid shape): outline of 333 points within 118.62,71.76 186.11,130.23
GND on SVCC1 (solid shape): outline of 110 points within 108.93,191.04 176.99,219.71
GND on SVCC1 (solid shape): outline of 577 points within 4.03,55.97 49.77,67.91
GND on SVCC1 (solid shape): outline of 1391 points within 118.62,113.12 179.67,142.18
GND on SVCC1 (solid shape): outline of 1413 points within 3.89,2.03 28.92,54.19
GND on SVCC1 (solid shape): outline of 1743 points within 220.48,138.06 287.57,219.73
GND on IN3 (solid shape): 121.8,212.05 121.8,209.13 121.54,208.88 118.62,208.88 118.37,209.13 118.37,212.05 118.49,212.18 121.67,212.18
GND on IN3 (solid shape): 211.66,85.09 211.66,84.8 212.22,84.24 212.22,84.11 211.51,83.4 209.12,83.4 208.94,83.58 208.94,84.19 208.44,84.7 208.44,85.03 208.69,85.28 211.46,85.28
GND on IN3 (solid shape): 292.1,103.44 292.1,100.29 291.79,99.97 291.76,99.93 291.75,99.87 291.75,98.11 291.44,97.8 217.35,97.8 215.93,99.23 215.93,103.7 216.23,104 291.54,104
GND on IN3 (solid shape): 33.53,83.05 33.53,79.77 33.3,79.54 32.64,79.54 32.31,79.87 30.79,79.87 30.31,79.39 29.7,79.39 28.91,80.18 28.91,82.42 28.98,82.49 28.98,82.69 29.24,82.96 29.24,83.15 29.94,83.84 32.73,83.84
GND on IN3 (solid shape): 219.61,49.42 219.61,48.82 219.07,48.27 219.07,47.66 218.86,47.46 217.94,47.46 217.83,47.34 215.67,47.34 215.55,47.47 215.55,49.02 215.65,49.12 218.29,49.12 218.89,49.72 219.31,49.72
GND on IN3 (solid shape): 38.1,100.89 38.1,99.05 37.95,98.9 37.92,98.85 37.91,98.8 37.91,96.85 37.87,96.81 37.21,96.81 36.88,97.14 35.36,97.14 34.98,96.76 34.17,96.76 33.48,97.45 33.48,100.77 33.84,101.13 37.86,101.13
GND on IN3 (solid shape): 259.46,121.76 259.46,119.27 259.03,118.83 257.85,118.83 257.75,118.88 257.65,118.9 257.55,118.88 257.45,118.83 255.78,118.83 255.68,118.74 255.66,118.72 255.62,118.73 255.46,118.77 255.29,118.74 255.26,118.73 255.23,118.75 255.15,118.83 255.15,119.36 255.52,119.74 255.52,119.84 255.53,119.85 255.53,121.63 255.78,121.88 259.34,121.88
GND on IN3 (solid shape): outline of 167 points within 0.51,0.51 298.62,67.27
GND on IN3 (solid shape): outline of 2314 points within 0.51,57.17 322.89,222.04
GND on SGND2 (solid shape): outline of 16667 points within 0.51,0.51 322.89,222.04
GND on IN4 (solid shape): 292.1,103.44 292.1,98.46 291.44,97.8 217.35,97.8 215.93,99.23 215.93,103.7 216.23,104 291.54,104
GND on IN4 (solid shape): 211.66,85.26 211.66,84.8 212.22,84.24 212.22,83.91 211.71,83.4 209.12,83.4 208.94,83.58 208.94,84.19 208.44,84.7 208.44,85.03 208.77,85.36 211.56,85.36
