# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
5650_DIFFN: length 4.3
  TOP w0.14: PR13.1 233.16,215.32 232.31,215.32 232.22,215.41 231.38,215.41 230.9,214.93 230.69,214.93 229.99,214.23 PU2.19
5650_DIFFP: length 4
  TOP w0.14: PU2.20 229.59,214.23 230.57,215.21 230.78,215.21 231.28,215.7 PR8.1
5650_EN: length 5.8
  TOP w0.203: PU2.28 226.64,212.18 226.14,211.67 225.48,211.67 224.84,211.04 224.54,211.04 224.43,210.93 PR49.2 R32.2 223.45,210.93 223.24,210.73 223.24,210.53 223.52,210.25 Q7.3
5650_MUX: length 1.9
  TOP w0.203: PR54.2 226.08,211.04 226.82,211.78 PU2.29
5650_SHN1: length 3.9
  TOP w0.178: PU2.1 227.99,209.49
  TOP w0.203: 227.99,209.49 227.68,209.17 227.3,209.17 226.67,208.55 226.67,208.2 PC16.2 226.47,208.1 226.01,208.56 PR69.1
5650_SHN2: length 3.3
  TOP w0.203: PU2.4 229.19,209.08 229.01,208.9 229.01,208.54 PC15.2 228.55,207.84 228.79,207.6 PR79.1
5650_SHN3: length 2.3
  TOP w0.14: PR47.1 233.22,211.42 PR42.1
  IN4 w0.508: v2(232.39,211.69) 232.37,211.71 232.37,213.02 v1(232.49,213.14)
5650_SHO1: length 5.8
  TOP w0.381: PR86.2 226.1,206.57 PC24.2 v1(225.19,206.37)
  IN1 w0.381: v1(225.19,206.37) 226.89,208.07 v1(226.89,209.86)
5650_SHO2: length 3.5
  TOP w0.203: PU2.7 230.39,209.34 230.88,208.85 v1(231.22,208.85) 231.07,208.7 PR72.2
  BOTTOM w0.508: v1(231.22,208.85) 231.22,208.98 PC309.2
5650_SHO3: length 4.2
  TOP w0.14: PU2.10 231.98,210.98 232.66,210.3 v1(232.66,210.16) 232.66,209.75 232.73,209.69 PR64.2
  BOTTOM w0.203: v1(232.66,210.16) 232.22,210.6 232.22,210.95 PC303.2
5650_SHO4: length 23.1
  TOP w0.14: PR6.1 226.42,216.47 226.11,216.78 224.66,216.78 224.23,216.35 222.32,216.35 v1(222.21,216.24) ; PU2.17 230.79,214.19 230.98,214.37 232.12,214.37 232.14,214.35 PR24.2 233.03,214.35 233.19,214.5 PC2.2 233.95,214.06 v1(233.95,213.29)
  IN4 w0.086: v1(222.21,216.24) 223.22,216.24 223.3,216.33 228.78,216.33 230.08,215.03 232.32,215.03 232.53,215.25 233.01,215.25 233.29,214.96 233.29,214.49 233.95,213.83 v1(233.95,213.29)
5650_SHP1: length 4.8
  TOP w0.203: PR78.1 226.37,207.12 PC16.1 226.73,207.32 227.08,207.67 227.08,208.44 227.46,208.81 227.88,208.81 228.39,209.33 PU2.2
5650_SHP2: length 2.5
  TOP w0.203: PU2.5 229.59,208.77 v1(229.54,208.73)
  BOTTOM w0.203: PR399.1 229,208.39 229.34,208.73 v1(229.54,208.73)
5650_SKIP: length 5.7
  TOP w0.178: PU2.25 226.8,213.38 v2(226.73,213.45)
  TOP w0.203: v2(226.73,213.45) 226.6,213.32 225.49,213.32 225.19,213.02 224.3,213.02 PR40.2
  BOTTOM w0.203: PR386.2 227.37,212.81 v1(227.21,212.97) 226.74,213.45 v2(226.73,213.45)
8068EN_1.8V: length 3.2
  TOP w0.203: PU14.5 262.18,62.12 v1(262.22,62.08)
  BOTTOM w0.14: v1(262.22,62.08) v1(262.22,62.83)
  BOTTOM w0.203: PR617.1 261.82,61.87 262.02,62.08 v1(262.22,62.08) 262.22,61.6 PC487.1
8068FB_1.8V: length 5.1
  TOP w0.14: PC211.2 265.45,61.7 v1(265.94,62.19)
  TOP w0.203: PU14.6 265.18,62.57 265.05,62.45 PC211.2 265.05,61.64 264.85,61.44 PR291.2 263.7,61.44 263.43,61.17 263.43,61.02 263.22,60.82 PR290.1
8068FB_1.8V_S: length 14
  TOP w0.203: PC211.1 264.22,60.92 PR291.1 263.95,60.27 263.96,60.26 v1(263.96,59.86)
  BOTTOM w0.203: PR616.1 255.09,62.61 255.62,62.09 255.62,60.24 256,59.85 259.89,59.85 260.56,59.18 263.29,59.18 v1(263.96,59.86)
8068LX_1.8V: length 0.9
  TOP w0.14: 261.24,66.51 v1(261.24,67.4)
8068NC_1.8V: length 2
  TOP w0.203: PU14.7 265.62,63.48 v1(266.02,63.08)
  BOTTOM w0.203: v1(266.02,63.08) 266.28,62.82 PC486.1
8068PG_1.8V: length 2.5
  TOP w0.203: PU14.4 261.68,63.48 261.48,63.27 261.48,62.45 261.18,62.15 PR285.1
8068SVIN_1.8V: length 4.2
  TOP w0.203: v1(266.04,63.77) 265.83,63.98 PU14.8
  BOTTOM w0.14: v1(266.58,64.35) 266.04,63.82 v1(266.04,63.77)
  BOTTOM w0.203: v1(266.04,63.77) 265.13,63.77 PR615.2 265.05,62.78 PC484.1
8816ABOOT1: length 2.4
  BOTTOM w0.178: PU19.1 247.91,210.96 247.63,210.68
  BOTTOM w0.203: PC314.2 246.75,209.8 247.63,210.68
8816ABOOT2: length 3.3
  BOTTOM w0.14: v1(253.24,208.88) 253.11,209.01 PC310.2
  BOTTOM w0.178: PU19.15 251.94,210.96 PC310.2
8816AEN: length 29.7
  TOP w0.203: PR20.1 263.4,214.31 263.75,213.96 v1(264.29,213.96) 264.29,213.42 264.37,213.34 v1(264.37,212.1) ; PR50.1 247.05,211.56 v1(247.15,211.66)
  IN2 w0.089: v1(247.15,211.66) 247.65,212.16 247.65,213.07 247.04,213.68 247.04,214.08 247.35,214.39 248.95,214.39 249.16,214.6 253.39,214.6 253.7,214.91 253.7,215.6 254.46,216.36 255.39,216.36 257.84,213.91 258.26,213.91 258.62,214.27 259.24,214.27 260.14,213.37 261.39,213.37 262.66,212.1 v1(264.37,212.1)
  BOTTOM w0.203: PC302.1 246.64,211.49 246.8,211.66 v1(247.15,211.66) 247.25,211.76 PU19.3
8816ALGATE1: length 21.1
  IN2 w0.508: v1(241.9,202.53) v1(235.63,202.53)
  IN4 w0.508: v1(241.9,202.53) 241.9,204.7 242.78,205.58 245.7,205.58 248.29,208.17 248.29,208.67 v1(248.59,208.98)
  BOTTOM w0.203: PU19.19 249.42,209.62 248.95,209.16
  BOTTOM w0.508: PQ44.8 236.65,202.53 v1(235.63,202.53) ; v1(241.9,202.53) 242.14,202.3 PQ43.8
8816ALGATE2: length 15.4
  IN1 w0.508: v1(251.64,208.8) 251.56,208.8 250.83,208.07 250.83,205.35 v1(253.51,202.67) 253.86,202.32 259.57,202.32 v1(259.8,202.56)
  BOTTOM w0.203: 250.46,209.13 250.22,209.38 PU19.17
  vias: v1(250.7,209)
8816APG: length 4.8
  BOTTOM w0.14: PR383.1 254.19,213.21 v1(254.08,213.32)
  BOTTOM w0.203: PR383.1 254.19,212.33 PR388.1 254.15,211.56 252.89,211.56 252.69,211.76 PU19.13
8816APHASE1: length 11.5
  TOP w0.508: PR100.2 v1(238.04,200.67)
  IN1 w0.508: v1(246.53,200.58) 246.53,202.04 248.03,203.54 248.03,208.01 247.6,208.45 v1(247.6,208.57)
  BOTTOM w0.508: PC314.1 247.53,209.13 247.6,209.06 v1(247.6,208.57)
  vias: v1(233.41,195.18)
8816APHASE2: length 9.7
  IN4 w0.508: v1(252.48,209.14) 253.57,208.05 253.57,204.38 v1(256.72,201.23)
  vias: v1(264.16,200.62)
8816APSI: length 3.1
  BOTTOM w0.203: PR377.2 PR380.2 246.74,212.36 PR382.1 246.84,212.35 247.03,212.16 PU19.4
8816APVCC: length 1.7
  BOTTOM w0.203: 249.57,208.69 249.57,209.15 249.82,209.39 PU19.18
  vias: v1(249.43,208.37)
8816AREFIN: length 6.2
  BOTTOM w0.203: PU19.7 249.42,213.72 248.84,214.3 247.9,214.3 247.72,214.48 247.31,214.48 PC286.1 247.37,214.82 248.29,214.82 PR365.1 249.03,214.99 PR366.2 249.21,215.59 249.41,215.79 PR354.1
8816ARGDN: length 3.2
  BOTTOM w0.102: 252.93,214.31 PR367.2
  BOTTOM w0.14: PU19.10 250.62,213.56 250.76,213.7 251.53,213.7 251.63,213.6 251.83,213.6 PC294.2 251.9,213.68 251.9,213.99 PC289.1 252.93,214.31
8816ASS: length 2
  BOTTOM w0.14: PU19.12 252.48,212.16 PR384.1 252.52,212.92 PC298.1
8816ATON: length 3.9
  BOTTOM w0.203: PR351.1 251.66,215.91 251.4,215.65 PC281.1 251.4,214.75 250.98,214.33 250.42,214.33 250.22,214.13 PU19.9
8816AUGATE1: length 1.6
  BOTTOM w0.203: 247.03,210.77 247.62,211.36 PU19.2
  vias: v1(246.13,210.44)
8816AUGATE1_1: length 12.2
  IN1 w0.508: v1(242.23,206.93) 241.37,206.07 236.46,206.07 236.02,206.52 v1(235.38,206.52)
  BOTTOM w0.508: v1(235.38,206.52) 235.66,206.52 236.37,207.22 PQ44.1 ; PR394.2 242.99,207.35 PQ43.1 242.55,207.26 v1(242.23,206.93)
8816AUGATE2: length 1.4
  BOTTOM w0.203: PU19.14 252.21,211.36 252.56,211.01
  vias: v1(253.11,210.91)
8816AUGATE2_1: length 12.4
  IN1 w0.508: v1(259.48,206.69) 255.56,206.69 254.38,207.86 254.38,208.98 255.17,209.77 v1(255.17,209.89)
  BOTTOM w0.508: PQ41.1 254.46,208.24 254.36,208.34 PR392.2 254.77,209.29 255.17,209.69 v1(255.17,209.89) ; PQ42.1 260.55,207.52 259.71,206.69 v1(259.48,206.69)
8816AVREF: length 2.3
  BOTTOM w0.203: PU19.8 249.82,214.41 PR369.2 249.81,214.54 250.13,214.87 PC282.1
8816AVSNS: length 48.9
  TOP w0.14: PR114.1 234.45,187.13 234.31,186.98 234.04,186.98 233.9,187.11 PR113.2 233.9,188.01 233.66,188.25 v1(233.26,188.25) 233.02,188.25 231.97,189.3 231.97,189.91 231.39,190.48 231.39,191.22 v1(231.29,191.33)
  IN4 w0.086: v1(253.44,213.55) 250.54,210.65 246.87,210.65 245.67,209.46 244.29,209.46 243.11,208.27 241.68,208.27 239.92,206.51 236.27,206.51 235,205.24 235,204.63 233.91,203.53 233.91,199.86 232.68,198.63 232.68,191.83 232.47,191.63 231.86,191.63 231.56,191.33 v1(231.29,191.33)
  BOTTOM w0.14: v1(253.44,213.55) 253.81,213.92 253.81,214.37 PC285.1 253.66,214.45 253.13,213.92 252.53,213.92 252.35,213.73 PC294.1 252.35,213.49 251.99,213.13 251.99,212.86 251.7,212.56 PU19.11
9336ADJ: length 14.4
  TOP w0.203: v1(203.21,99.36) 203.29,99.28 204.09,99.28 204.84,100.03 PR134.2 ; v1(198.2,104.39) 198.5,104.39 199.14,103.75 PR130.1
  IN2 w0.203: v1(198.2,104.39) 198.26,104.33 200.04,104.33 201.8,102.58 201.8,100.78 v1(203.21,99.36)
  BOTTOM w0.203: v1(198.2,104.39) 198.2,103.67 198.73,103.15 PU28.5
9336DRV: length 8.7
  TOP w0.14: v1(200.16,106.64) 200.53,106.27 PD1.1
  TOP w0.508: v1(198.83,104.79) 199.5,104.79 200.36,103.93 200.55,103.93 PQ14.4 200.99,103.57 200.99,104.8 200.53,105.26 PD1.1
  BOTTOM w0.203: PR530.1 199.94,105.08 199.8,105.22 199.11,105.22 198.83,104.94 v1(198.83,104.79)
  BOTTOM w0.508: PU28.6 199.36,104.26 v1(198.83,104.79)
9512_5VCC: length 3.3
  TOP w0.203: 257.66,79.59 PU10.12
  TOP w0.254: PR185.2 255.69,80.28 PC158.1 256.97,80.28 257.66,79.59
9512_ADDR: length 4.1
  TOP w0.14: PR249.1 261.04,72.19 260.71,72.52 260.71,73.46 260.98,73.72 PR232.2 261.17,73.72 261.31,73.86 261.31,74.77 261.19,74.89 PU10.26
9512_CH_OC: length 2
  TOP w0.14: PR176.2 262.51,82.23 261.99,81.71 PU10.3
9512_COMP: length 5.4
  TOP w0.14: PC194.2 265.26,72.63 265.26,73.27 264.81,73.72 PR234.2 264.67,74.29 v1(264.15,74.82) 262.97,74.82 262.79,75 PU10.30
9512_CSNSUM: length 3.1
  TOP w0.14: PU10.21 259.19,75.19 259.05,75.05 258.4,75.05 v1(258.35,74.99) 257.18,73.82 PR228.1
9512_CSP1: length 15.8
  TOP w0.14: v1(258.41,75.75) 258.03,75.75 257.89,75.89 257.89,76.3 257.99,76.39 PU10.20 ; PR244.2 256.26,71.97 256.12,71.83 255.01,71.83 PR243.2 254.61,71.67 v1(254.4,71.45) 254.29,71.35 253.69,71.35 253.2,71.84 253.2,72.77 v1(253.29,72.86) 253.29,73.03 252.96,73.35 PR235.2 252.96,73.62 252.74,73.85 252.2,73.85 251.94,73.59 PC181.1
  IN1 w0.086: v1(253.29,72.86) 253.57,73.15 256.17,73.15 258.41,75.39 v1(258.41,75.75)
9512_CSP2: length 14.2
  TOP w0.14: PC174.1 251.49,74.52 251.63,74.66 252.82,74.66 252.96,74.52 PR227.2 253.08,74.26 v1(253.53,74.26) ; PU10.19 257.8,76.79 257.56,76.55 257.56,75.4 v1(256.92,74.77) 256.92,74.28 256.26,73.62 PR237.2 256.26,73.14 256.09,72.97 254.76,72.97 254.61,73.12 PR236.2
  BOTTOM w0.14: v1(253.53,74.26) 254.14,74.26 254.59,74.72 255.34,74.72 256.17,73.89 256.51,73.89 256.92,74.3 v1(256.92,74.77)
9512_CSP3: length 12.5
  TOP w0.14: PC168.1 251.95,75.17 252.18,74.94 252.73,74.94 252.96,75.17 PR224.2 253.16,75.37 v1(253.51,75.01) ; PR225.2 254.61,74.47 254.92,74.78 256.13,74.78 256.26,74.66 PR226.1 256.46,74.59 256.46,75.01 256.8,75.35 v1(256.8,75.65) 257.28,76.14 257.28,76.67 257.81,77.19 PU10.18
  BOTTOM w0.14: v1(256.8,75.65) 256.29,75.14 255.93,75.14 255.34,75.74 254.85,75.74 254.12,75.01 v1(253.51,75.01)
9512_CSP4: length 10.8
  TOP w0.14: PU10.17 257.74,77.59 v1(256.82,76.67) 256.82,76.36 256.26,75.8 ; PC164.1 251.5,76.36 251.64,76.5 252.79,76.5 252.97,76.33 PR213.2 252.97,76.05 253.11,75.91 253.3,75.91 v1(253.5,76.11)
  BOTTOM w0.14: v1(253.5,76.11) 253.61,75.99 253.81,75.99 254.57,76.75 255.34,76.75 255.61,76.48 255.61,76.06 255.84,75.83 256.31,75.83 256.6,76.12 256.73,76.12 256.82,76.21 v1(256.82,76.67)
9512_CSP5: length 12.3
  TOP w0.14: PR210.2 254.61,76.64 254.78,76.82 256.09,76.82 256.26,76.65 256.26,76.56 ; v1(253.52,76.75) 253.52,76.9 253.23,77.19 PR205.2 252.96,76.92 252.82,76.78 252.09,76.78 251.95,76.92 PC162.1 ; 256.26,76.56 256.37,76.66 256.37,76.89 v1(256.8,77.32) 256.96,77.48 257.17,77.48 257.68,78 PU10.16 ; 256.26,76.56 PR211.1
  BOTTOM w0.14: v1(253.52,76.75) 253.58,76.75 254.59,77.77 255.34,77.77 255.61,77.5 255.61,76.88 255.69,76.8 256.28,76.8 v1(256.8,77.32)
9512_CSP6: length 12
  TOP w0.14: 256.26,77.44 256.26,77.67 256.09,77.83 254.8,77.83 254.61,77.65 PR202.2 ; 256.26,77.44 PR203.1 ; 256.26,77.44 256.8,77.97 v1(256.8,78.05) 257.29,78.05 257.63,78.39 PU10.15 ; v1(253.51,77.63) 253.3,77.63 PR199.2 252.98,78.19 252.82,78.35 251.7,78.35 251.51,78.16 PC161.1
  BOTTOM w0.14: v1(253.51,77.63) 253.82,77.63 254.98,78.79 255.36,78.79 255.89,78.26 255.89,78.08 256.24,77.73 256.47,77.73 v1(256.8,78.05)
9512_CSP7: length 11.6
  TOP w0.14: v1(253.51,78.53) 253.51,78.62 253.09,79.04 PR193.2 252.97,78.81 252.79,78.63 251.66,78.63 251.51,78.79 PC160.1
  TOP w0.178: PR196.2 254.62,78.45 254.97,78.8 255.44,78.8 255.51,78.87 256.08,78.87 256.26,78.69 PR197.1 256.5,78.45 v1(256.75,78.7) 257.28,78.7 257.37,78.79 PU10.14
  BOTTOM w0.178: v1(256.75,78.7) 256.27,78.7 255.75,79.22 255.75,79.49 255.47,79.77 254.75,79.77 v1(253.51,78.53)
9512_CSP8: length 9.8
  TOP w0.14: PR191.2 253.62,79.16 v1(253.5,79.29) 252.96,79.83 PR187.2 252.96,80.01 252.69,80.28 251.63,80.28 251.49,80.14 PC159.1
  TOP w0.178: PR190.1 v1(256.92,79.34) 257.07,79.19 PU10.13
  BOTTOM w0.178: v1(253.5,79.29) 254.33,80.13 255.76,80.13 256.55,79.34 v1(256.92,79.34)
9512_CSPSUM: length 2.6
  TOP w0.14: PU10.22 259.59,75.1 259.25,74.77 258.85,74.77 258.33,74.24 PR229.1
9512_DAC: length 11.7
  TOP w0.14: v1(267.06,76.62) 266.79,76.62 PC163.2 ; v1(262.13,74.26) 261.99,74.4 PU10.28 ; v1(263.54,71.8) 263.54,71.88 PC188.2
  BOTTOM w0.14: v1(263.54,71.8) 262.55,72.79 PR612.2 262.13,73.66 v1(262.13,74.26) 264.49,76.62 v1(267.06,76.62)
9512_EAP: length 2.8
  TOP w0.14: PU10.29 262.39,74.84 262.69,74.54 263.24,74.54 263.91,73.87 PR233.2
9512_EN: length 13.6
  TOP w0.14: PU10.36 264.49,78.39 v1(264.93,78.83) ; PQ20.3 272.46,82.53 272.07,82.14 272.07,81.68 271.89,81.5 271.43,81.5 271.31,81.62 PR177.1 271.12,82.14 270.74,82.14 v1(270.51,81.92) 270.32,81.92 269.98,82.25 269.98,82.8 270.11,82.92 PR168.2
  IN1 w0.086: v1(270.51,81.92) 270.4,81.81 268.64,81.81 268.4,81.57 267.52,80.68 266.78,80.68 v1(264.93,78.83)
9512_EN_1: length 10.1
  TOP w0.14: PR167.1 280.93,83.83 280.47,84.29 279.67,84.29 279.53,84.43 PD2.2 279.43,85.01 PR145.2 278.42,85.97 v1(277.7,85.26) PC155.1 277.36,83.79 277.22,83.93 276.49,83.93 276.25,83.69 275.66,83.69 275.4,83.43 PQ19.2
9512_EN_S: length 81.7
  TOP w0.14: v1(272.93,85.81) 272.93,84.6 271.75,83.42 271.75,81.96 PR177.2
  BOTTOM w0.14: PR578.1 287.76,86.99 286.79,86.01 283.7,86.01 283.52,86.2 278.01,86.2 ; PR582.2 219.62,86.86 220.01,86.47 226.06,86.47 226.63,85.9 228.58,85.9 228.81,86.13 228.81,86.56 PR587.2 229.37,86.61 229.37,85.56 229.62,85.31 231.14,85.31 231.52,85.69 233.43,85.69 233.6,85.86 238.43,85.86 238.89,86.32 238.89,86.35 ; 238.89,86.35 245.45,86.35 246.07,85.73 248.21,85.73 248.67,86.2 248.67,86.34 ; 238.89,86.35 PR592.2 ; 258.45,86.32 258.45,86.2 258.09,85.83 249.17,85.83 248.67,86.34 ; 258.45,86.32 PR602.2 ; 258.45,86.32 258.91,85.86 263.83,85.86 264,85.7 267.82,85.7 268.11,85.98 268.11,86.74 PR607.2 268.69,86.4 270.28,86.4 270.87,85.81 v1(272.93,85.81) 273.38,85.36 277.17,85.36 278.01,86.2 ; 248.67,86.34 PR597.2 ; 278.01,86.2 PR575.1
9512_FB: length 7.6
  TOP w0.14: PR240.2 PR248.1 PR247.2 266.28,72.2 265.96,72.51 265.8,72.51 265.64,72.67 PR241.2 265.64,73.31 265.13,73.82 265.13,75.94 v1(264.8,76.27) 264.68,76.39 PU10.31
9512_FBRTN: length 23.2
  TOP w0.14: v1(267.97,77.99) 268.37,77.99 268.51,77.85 PR201.2 PR207.1 ; PC154.2 PR164.2 266.15,83.14 267.41,81.88 PC157.2 267.75,81.88 267.9,82.03 v1(267.9,82.51) ; v1(266.35,73.5) 265.98,73.5 265.59,73.89 PC179.1 265.59,74.28 265.49,74.38 265.49,74.89 265.68,75.09 PC169.2 265.68,75.32 PC163.1 265.17,76.79 PU10.32
  BOTTOM w0.14: v1(267.9,82.51) 268.2,82.21 268.2,80.41 268.41,80.2 268.41,78.68 267.97,78.25 v1(267.97,77.99) 268.9,77.07 268.9,74.45 267.94,73.5 v1(266.35,73.5)
9512_IMON: length 4.1
  TOP w0.14: PU10.25 260.79,74.12 260.39,73.72 PR231.1 259.97,73.72 259.83,73.58 259.83,72.3 PC193.1
9512_LPC: length 4.6
  TOP w0.14: PU10.24 260.39,75.07 259.5,74.17 259.33,74.17 259.14,73.98 PR230.2 259.28,73.72 259.55,73.45 259.55,72.61 259.13,72.2 PR246.1
9512_PGOOD: length 4.3
  TOP w0.14: PR184.1 266.99,80.59 266.65,80.25 265.6,80.25 265.46,80.1 PR188.1 265.46,79.75 265.32,79.61 264.66,79.61 264.24,79.19 PU10.38
9512_PSI: length 3.7
  TOP w0.14: PU10.37 264.23,78.79 264.73,79.29 266.09,79.29 266.3,79.08 PR192.1
9512_PWM1: length 6.1
  TOP w0.14: PR180.2 PR181.1 254.79,81.37 254.94,81.22 255.43,81.22 255.65,81.45 v1(256.54,81.45) 257.32,81.45 257.46,81.3 257.84,81.3 258.1,81.05 258.1,80.59 257.85,80.34 257.85,80.14 257.99,80 PU10.11
9512_PWM1_S: length 39.5
  TOP w0.14: v1(253.92,82.21) 254.1,82.02 255.13,82.02 255.24,81.91 PR181.2
  IN2 w0.14: v1(220.85,88.05) 226.57,88.05 227.08,88.56 228.3,88.56 229.77,87.08 233.81,87.08 234.37,86.53 235.87,86.53 236.43,87.08 238.51,87.08 238.97,86.62 250.68,86.62 252.45,84.86 252.45,83.68 v1(253.92,82.21)
  BOTTOM w0.14: PU31.34 v1(220.85,88.05)
9512_PWM2: length 6.6
  TOP w0.14: PR155.2 PR169.1 254.74,82.99 254.91,82.82 254.91,82.65 255.63,81.93 257.27,81.93 257.61,81.58 257.98,81.58 258.22,81.34 259.05,81.34 259.19,81.2 PU10.10
9512_PWM2_S: length 28
  TOP w0.14: v1(253.84,83.69) 253.84,82.96 254.25,82.54 PR169.2
  IN2 w0.14: v1(230.63,88.05) 231.35,87.33 233.91,87.33 234.47,86.77 235.77,86.77 236.33,87.33 238.61,87.33 239.07,86.86 250.78,86.86 252.69,84.96 252.69,84.47 253.47,83.69 v1(253.84,83.69)
  BOTTOM w0.14: PU32.34 v1(230.63,88.05)
9512_PWM3: length 6
  TOP w0.14: PR156.2 PR170.1 255.96,82.99 256.19,82.76 256.19,82.59 256.58,82.21 257.38,82.21 257.71,81.88 258.44,81.88 258.7,81.62 259.34,81.62 259.59,81.37 PU10.9
9512_PWM3_S: length 18.7
  TOP w0.14: v1(255.02,83.33) 255.22,83.12 255.22,82.72 255.4,82.54 PR170.2
  IN2 w0.14: v1(255.02,83.33) 255.02,83.75 251.66,87.1 241.35,87.1 v1(240.41,88.05)
  BOTTOM w0.14: PU33.34 v1(240.41,88.05)
9512_PWM4: length 5.1
  TOP w0.14: PR157.2 PR171.1 257.18,82.99 257.32,82.85 257.32,82.69 257.78,82.23 258.54,82.23 258.86,81.9 259.45,81.9 259.99,81.37 PU10.8
9512_PWM4_S: length 10.8
  TOP w0.14: PR171.2 256.62,82.54 256.49,82.67 256.49,83.2 v1(256.29,83.4)
  IN2 w0.14: v1(256.29,83.4) 256.29,84.71 253.63,87.36 250.87,87.36 v1(250.19,88.05)
  BOTTOM w0.14: PU34.34 v1(250.19,88.05)
9512_PWM5: length 4.4
  TOP w0.14: PR158.2 PR172.1 258.33,82.99 258.47,82.85 258.47,82.7 258.98,82.18 259.71,82.18 260.39,81.5 PU10.7
9512_PWM5_S: length 7.6
  TOP w0.14: PR172.2 257.83,82.54 257.6,82.77 257.6,83.31 v1(257.56,83.35)
  IN2 w0.14: v1(259.97,88.05) 259.97,87.34 257.56,84.93 v1(257.56,83.35)
  BOTTOM w0.14: PU35.34 v1(259.97,88.05)
9512_PWM6: length 3.7
  TOP w0.14: PR159.2 PR173.1 259.47,82.99 259.61,82.85 259.61,82.68 260.79,81.5 PU10.6
9512_PWM6_S: length 15.8
  TOP w0.14: v1(258.7,83.33) 258.81,83.22 258.81,82.71 258.98,82.54 PR173.2
  IN2 w0.14: v1(269.75,88.05) 269.13,87.43 261.24,87.43 258.7,84.89 v1(258.7,83.33)
  BOTTOM w0.14: PU36.34 v1(269.75,88.05)
9512_PWM7: length 3.4
  TOP w0.14: PR160.2 PR174.1 260.61,82.99 260.75,82.85 260.75,82.57 261.19,82.13 PU10.5
9512_PWM7_S: length 24.7
  TOP w0.14: PR174.2 260.1,82.54 259.95,82.69 259.95,83.22 v1(259.85,83.33)
  IN2 w0.14: v1(279.66,88.23) 278.83,87.4 269.44,87.4 269.23,87.19 262.24,87.19 259.85,84.79 v1(259.85,83.33)
  BOTTOM w0.14: PU29.34 279.78,88.48 279.66,88.35 v1(279.66,88.23)
9512_PWM8: length 3.4
  TOP w0.14: PR161.2 PR175.1 261.93,82.99 262.02,82.89 262.02,82.35 261.59,81.92 PU10.4
9512_PWM8_S: length 33
  TOP w0.14: v1(260.99,83.27) 261.12,83.15 261.12,82.79 261.37,82.54 PR175.2
  IN1 w0.086: v1(260.99,83.27) 260.99,83.28 263.37,83.28 263.66,82.99 275.9,82.99 275.98,82.92 281.64,82.92 283.78,85.06 284.87,85.06 v1(284.99,85.18)
  BOTTOM w0.14: v1(284.99,85.18) 285.54,85.73 287.03,85.73 287.92,86.63 288.19,86.63 288.45,86.88 288.45,87.43 289.69,88.67 PU30.34
9512_REFADJ: length 2.9
  TOP w0.14: PR178.2 265.12,81.65 264.74,81.28 v1(264.74,80.65) 264.09,80 PU10.40
9512_REFIN: length 8.9
  TOP w0.14: PR166.2 268.47,83.14 267.69,83.92 PR165.2 267.21,84.31 267.07,84.45 264.81,84.45 264.67,84.31 PC154.1 264.66,83.92 264.21,83.47 264.21,82.75 v1(263.57,82.11) 262.79,81.33 262.79,81.33 PU10.1
9512_REFOUT: length 3.9
  TOP w0.14: PU10.23 259.99,75.06 259.39,74.46 259.11,74.46 258.74,74.09 258.74,73.13 258.52,72.91 258.19,72.58 PR242.1
9512_SCL: length 2.2
  TOP w0.14: PR195.2 265.45,78.7 264.75,78 PU10.35
9512_SDA: length 2.1
  TOP w0.14: PU10.34 265.32,77.59 265.46,77.73 PR200.2
9512_TSENSE: length 1.9
  TOP w0.14: PU10.33 265.45,77.19 PR206.2
9512_VID: length 2.4
  TOP w0.14: PR183.1 265.46,80.64 264.83,80.01 264.57,80.01 264.16,79.59 PU10.39
9512_VINMON: length 3.5
  TOP w0.14: PR239.1 PR238.1 261.87,73.38 261.59,73.66 PU10.27
9512_VREF: length 4.2
  TOP w0.14: PC153.1 262.65,84.13 262.93,83.86 262.93,83.6 263.39,83.14 PR163.2 263.4,82.64 262.39,81.63 PU10.2
9619_BST1: length 2.1
  BOTTOM w0.254: PR583.1 220.63,87.08 221.37,87.83 221.37,88.26 221.3,88.33 PU31.33
9619_BST2: length 3.2
  BOTTOM w0.14: v1(230.29,85.98) PR588.1
  BOTTOM w0.254: PR588.1 230.4,87.08 231.15,87.83 231.15,88.26 231.08,88.33 PU32.33
9619_BST3: length 2.1
  BOTTOM w0.254: PU33.33 240.86,88.33 240.93,88.26 240.93,87.83 240.18,87.08 PR593.1
9619_BST4: length 2.1
  BOTTOM w0.254: PU34.33 250.64,88.33 250.71,88.26 250.71,87.83 249.96,87.08 PR598.1
9619_BST5: length 2.1
  BOTTOM w0.254: PU35.33 260.42,88.33 260.49,88.26 260.49,87.83 259.74,87.08 PR603.1
9619_BST6: length 2.1
  BOTTOM w0.254: PR608.1 269.52,87.08 270.27,87.83 270.27,88.26 270.2,88.33 PU36.33
9619_BST7: length 1.9
  BOTTOM w0.254: PU29.33 280.23,88 PR569.1
9619_BST8: length 2.4
  BOTTOM w0.254: PR567.1 290.54,87.38 v1(290.14,87.78) PU30.33
9619_PHASE1: length 4.3
  BOTTOM w0.14: v1(224.67,87.08) PC476.2
  BOTTOM w0.254: PU31.32 221.75,88.4 221.77,88.39 221.77,87.95 221.96,87.76 223.43,87.76 223.79,87.41 PC476.2
9619_PHASE2: length 4.4
  BOTTOM w0.14: v1(234.57,87.08) PC477.2
  BOTTOM w0.254: PC477.2 233.56,87.41 233.35,87.62 232.55,87.62 232.41,87.76 231.74,87.76 231.55,87.95 231.55,88.39 231.53,88.4 PU32.32
9619_PHASE3: length 4.2
  BOTTOM w0.14: v1(244.22,87.08) PC478.2
  BOTTOM w0.254: PU33.32 241.31,88.4 241.32,88.39 241.32,87.95 241.52,87.76 242.87,87.76 243.34,87.29 PC478.2
9619_PHASE4: length 4.3
  BOTTOM w0.14: v1(254,87.08) PC479.2
  BOTTOM w0.254: PU34.32 251.09,88.4 251.1,88.39 251.1,87.95 251.3,87.76 252.78,87.76 253.12,87.41 PC479.2
9619_PHASE5: length 4.2
  BOTTOM w0.14: v1(263.78,87.08) PC480.2
  BOTTOM w0.254: PU35.32 260.87,88.4 260.88,88.39 260.88,87.95 261.08,87.76 262.47,87.76 262.9,87.32 PC480.2
9619_PHASE6: length 4.3
  BOTTOM w0.14: v1(273.69,87.08) PC481.2
  BOTTOM w0.254: PU36.32 270.65,88.4 270.66,88.39 270.66,87.95 270.86,87.76 272.2,87.76 272.68,87.28 PC481.2
9619_PHASE7: length 4.1
  BOTTOM w0.14: v1(283.85,87.34) PC475.2
  BOTTOM w0.254: PC475.2 282.84,87.45 282.19,88.1 281.23,88.1 281.21,88.12 280.68,88.65 PU29.32
9619_PHASE8: length 4.2
  BOTTOM w0.254: PU30.32 290.59,88.64 291.11,88.11 293.32,88.11 293.58,87.86 PC474.2
9619_SW1: length 3
  BOTTOM w0.254: PR543.2 223.59,95.75 221.89,97.46
9619_SW2: length 3
  BOTTOM w0.254: PR544.2 233.21,95.83 231.58,97.46
9619_SW3: length 2.6
  BOTTOM w0.254: 241.83,97.46 243.54,95.75 PR545.2
9619_SW4: length 2.7
  BOTTOM w0.254: PR546.2 253.12,95.7 251.36,97.46
9619_SW5: length 2.9
  BOTTOM w0.254: PR547.2 262.66,95.68 260.88,97.46
9619_SW6: length 1.9
  BOTTOM w0.254: PR548.2 272.09,95.7 271.25,96.54
9619_SW7: length 1.5
  BOTTOM w0.254: PR541.2 281.31,95.94
9619_SW8:
  vias: v1(292.87,97.37)
9619_VOS1: length 25.1
  IN1 w0.178: v1(219.73,105.17) 214.45,105.17 212.98,103.7 212.98,99.96 217.49,95.45 v1(217.49,89.38)
  BOTTOM w0.14: v1(217.49,89.38) PU31.1
  BOTTOM w0.203: PR527.1 v1(219.73,105.17)
9619_VOS2: length 21.7
  IN1 w0.178: v1(229.33,105.4) 227.25,105.4 224.69,102.83 224.69,98.01 227.27,95.42 v1(227.27,89.38)
  BOTTOM w0.14: v1(227.27,89.38) PU32.1
  BOTTOM w0.178: PR521.1 v1(229.33,105.4)
9619_VOS3: length 20.2
  IN1 w0.178: v1(237.05,89.38) 237.05,95.91 236.1,96.86 236.1,104.66 236.84,105.4 v1(238.97,105.4)
  BOTTOM w0.14: v1(237.05,89.38) PU33.1
  BOTTOM w0.178: v1(238.97,105.4) PR522.1
9619_VOS4: length 20
  IN1 w0.178: v1(248.54,105.4) 246.54,105.4 245.88,104.74 245.88,94.89 246.83,93.94 v1(246.83,89.38)
  BOTTOM w0.14: v1(246.83,89.38) PU34.1
  BOTTOM w0.178: v1(248.54,105.4) PR523.1
9619_VOS5: length 21.5
  TOP w0.14: v1(256.74,88.88) v1(256.74,89.55)
  IN1 w0.178: v1(257.97,105.4) 256.83,105.4 255.59,104.17 255.59,97.05 256.66,95.99 256.66,92.18 257.36,91.48 257.36,89.54 256.74,88.93 v1(256.74,88.88)
  BOTTOM w0.14: PU35.1 257.32,89.04 257.14,88.86 256.76,88.86 v1(256.74,88.88)
  BOTTOM w0.178: PR524.1 v1(257.97,105.4)
9619_VOS6: length 19
  IN1 w0.178: v1(267.76,105.4) 266.69,105.4 266,104.71 266,93.94 266.46,93.49 266.46,89.51 v1(266.37,89.42)
  BOTTOM w0.178: PU36.1 266.41,89.38 v1(266.37,89.42) ; PR525.1 267.9,105.4 v1(267.76,105.4)
9619_VOS7: length 18.8
  IN1 w0.178: v1(276.96,105.53) 276.46,105.53 275.53,104.6 275.53,95.9 276.58,94.84 276.58,89.8 v1(276.42,89.64)
  BOTTOM w0.178: v1(276.96,105.53) 277.22,105.53 PR519.1 ; v1(276.42,89.64) PU29.1
9619_VOS8: length 18.9
  IN1 w0.178: v1(286.33,89.64) 286.33,92.45 286.16,92.62 286.16,95.95 285.05,97.05 285.05,104.88 285.71,105.53 v1(286.65,105.53)
  BOTTOM w0.178: v1(286.33,89.64) PU30.1 ; v1(286.65,105.53) PR520.1
24780_ACDET: length 5.1
  TOP w0.14: PU18.6 37.56,45.46 36.96,46.06 PC238.1 35.54,46.06 PR315.2 35.08,46.06 35.07,46.06 PR316.2 34.17,46.06 v1(33.66,46.57)
24780_ACDRV: length 279.4
  TOP w0.14: v2(38.4,46.5) 38.4,46.12 38.36,46.07 PU18.4 ; v1(181.57,187.33) 181.1,187.33 180.37,186.6 180.37,181.43 179.14,180.2 178,180.2 177.13,179.34 177.13,176.37 v1(177.18,176.32)
  IN1 w0.086: v1(80.94,89.39) 80.94,89.97 80.49,90.43 80.49,92.42 86.28,98.21 90.59,98.21 93.67,101.28 100.19,101.28 107.62,108.71 107.62,111.37 109.53,113.28 109.53,126.21 113.89,130.57 113.89,134.05 113.14,134.8 113.14,137.62 117.02,141.5 117.02,144.33 117.94,145.24 117.94,153.77 113.44,158.27 113.44,163.95 114.9,165.42 115.45,165.42 v1(115.6,165.27)
  IN4 w0.086: v1(177.18,176.32) 177.06,176.19 176.26,176.19 176.13,176.32 175.36,176.32 175.06,176.01 174.7,176.01 174.27,175.57 172.83,175.57 170.6,173.34 153.97,173.34 153.3,172.67 119.89,172.67 117.13,169.91 117.13,166.56 115.84,165.27 v1(115.6,165.27)
  BOTTOM w0.14: v1(80.94,89.39) 81.2,89.39 82.53,88.07 82.53,50.54 80.94,48.95 65.66,48.95 63.91,50.7 62.07,50.7 61.27,51.5 61.27,52.4 58.89,54.78 58.37,54.78 58.04,55.11 48.21,55.11 45.64,52.54 43.56,52.54 42.06,51.05 40.43,51.05 38,48.62 38,46.9 v2(38.4,46.5) ; v1(181.57,187.33) 182.01,187.77 PR485.2
24780_ACN: length 276.9
  TOP w0.14: PU18.1 39.56,45.13 40.27,45.85 PC239.2 v1(40.27,46.73) 40.61,47.07 PC236.1
  IN1 w0.086: v1(115.51,163.5) 115.2,163.82 114.58,163.82 114.07,163.31 114.07,158.54 118.58,154.03 118.58,144.98 117.66,144.06 117.66,141.24 114.06,137.64 114.06,134.78 114.53,134.32 114.53,130.31 110.16,125.95 110.16,113.02 108.25,111.11 108.25,108.35 100.28,100.37 94.08,100.37 90.64,96.94 86.32,96.94 81.15,91.77 81.15,91.04 81.34,90.86 81.46,90.86 v1(81.8,91.2)
  IN4 w0.086: v1(115.51,163.5) 115.82,163.82 116.17,163.82 117.76,165.41 117.76,169.65 120.15,172.04 153.56,172.04 154.23,172.71 170.86,172.71 173.09,174.94 174.53,174.94 174.96,175.38 175.52,175.38 175.55,175.34 175.86,175.34 175.95,175.25 v1(175.95,175.05)
  BOTTOM w0.14: v1(81.8,91.2) 82.09,90.91 82.67,90.91 83.59,89.98 83.59,50.1 81.38,47.88 65.05,47.88 63.31,49.63 61.64,49.63 60.21,51.05 60.21,51.96 58.45,53.71 57.93,53.71 57.6,54.05 48.65,54.05 46.08,51.48 44,51.48 42.49,49.97 42.49,48.22 41.22,46.96 40.49,46.96 v1(40.27,46.73) ; PR501.2 180.41,181.46 180.41,176.02 180.14,175.75 180.14,174.41 179.74,174.01 176.83,174.01 176.42,174.42 176.42,175.12 176.28,175.26 176.09,175.26 175.95,175.12 v1(175.95,175.05)
24780_ACP: length 276.5
  TOP w0.14: v1(40.25,47.45) 40.01,47.21 39.63,47.21 PC235.2 39.5,46.53 39.49,46.52 PC239.1 39.49,45.63 39.16,45.3 PU18.2
  IN1 w0.086: v1(115.51,164.29) 115.2,163.98 114.51,163.98 113.91,163.38 113.91,158.47 118.41,153.96 118.41,145.05 117.49,144.13 117.49,141.3 113.9,137.71 113.9,134.71 114.36,134.25 114.36,130.38 110,126.02 110,113.09 108.09,111.18 108.09,108.42 100.21,100.54 94.01,100.54 90.57,97.11 86.26,97.11 80.99,91.84 80.99,90.97 81.27,90.69 81.46,90.69 v1(81.8,90.35)
  IN4 w0.086: v1(115.51,164.29) 115.82,163.98 116.1,163.98 117.6,165.48 117.6,169.71 120.09,172.2 153.49,172.2 154.16,172.87 170.79,172.87 173.02,175.1 174.46,175.1 174.9,175.54 175.59,175.54 175.62,175.51 175.85,175.51 175.95,175.61 v1(175.95,175.84)
  BOTTOM w0.14: v1(175.95,175.84) 175.95,175.73 176.15,175.53 176.39,175.53 176.69,175.23 176.69,174.53 176.94,174.28 179.63,174.28 179.87,174.52 179.87,175.86 180.14,176.13 180.14,181.57 180.15,181.58 PR500.2 ; v1(40.25,47.45) 40.27,47.45 40.49,47.22 41.11,47.22 42.22,48.33 42.22,50.08 43.89,51.74 45.97,51.74 48.54,54.31 57.71,54.31 58.04,53.98 58.56,53.98 60.47,52.07 60.47,51.16 61.75,49.89 63.42,49.89 65.16,48.15 81.27,48.15 83.33,50.21 83.33,89.87 82.56,90.64 82.09,90.64 v1(81.8,90.35)
24780_BATDRV: length 34.9
  TOP w0.14: v1(58.61,47.31) 59.02,46.9 PR314.2 ; PU18.18 38.36,40 v1(38.4,39.96)
  IN3 w0.089: v1(58.61,47.31) 58.32,47.03 58.06,47.03 57.86,46.83 57.86,39.82 56.41,38.37 48.97,38.37 48.45,37.85 48.45,36.56 47.67,35.78 40.22,35.78 39.01,36.99 39.01,38.93 38.4,39.54 v1(38.4,39.96)
24780_BATSRC: length 35.4
  TOP w0.14: PU18.17 37.96,40.31 37.75,40.1 v1(37.75,39.93) ; PR320.2 58.61,46.37 v1(58.61,46.58)
  IN3 w0.089: v1(37.75,39.93) 38.82,38.85 38.82,36.91 40.14,35.59 47.75,35.59 48.64,36.48 48.64,37.77 49.05,38.18 56.49,38.18 58.05,39.74 58.05,46.75 58.14,46.84 58.35,46.84 v1(58.61,46.58)
24780_BM#: length 1.2
  TOP w0.14: PR341.2 37.13,39.92 37.56,40.35 PU18.16
24780_BST: length 3.3
  TOP w0.178: PR327.1 42.39,43.62 42.2,43.43 42.2,42.98 41.88,42.66 41.29,42.66 41.18,42.76 PU18.25
24780_CMPIN: length 4.3
  TOP w0.14: PU18.13 35.94,41.96 35.21,41.23 35.21,40.88 34.9,40.56 PR337.1 ; PR343.1 PR344.2
  TOP w0.152: PR344.2 34.9,39.87 PR337.1
24780_CMPOUT: length 12.6
  TOP w0.14: PR335.2 27.99,41.23 27.75,41.47 v1(27.44,41.47) ; PR342.2 35.53,39.68 35.39,39.82 v1(35.39,40.27) 35.6,40.48 35.6,41.19 35.97,41.56 PU18.14
  BOTTOM w0.14: v1(27.44,41.47) 27.99,40.91 32.57,40.91 33.45,40.02 35.14,40.02 v1(35.39,40.27)
24780_CMSRC: length 285.5
  TOP w0.14: v2(38.88,46.15) 38.76,46.02 PU18.3 ; v1(176.65,176.68) 176.85,176.89 176.85,179.45 177.88,180.48 179.02,180.48 180.09,181.55 180.09,186.72 181.35,187.98 v1(181.49,187.98)
  IN1 w0.086: v1(80.43,89.86) 80.3,89.99 80.3,92.49 86.2,98.39 90.51,98.39 93.59,101.47 100.12,101.47 107.43,108.79 107.43,111.45 109.34,113.36 109.34,126.29 112.92,129.87 112.92,137.66 116.84,141.58 116.84,144.4 117.75,145.32 117.75,153.69 113.25,158.2 113.25,164.24 114.93,165.92 v1(115.56,165.92)
  IN4 w0.086: v1(115.56,165.92) 116.22,165.92 116.94,166.64 116.94,169.99 119.81,172.86 153.22,172.86 153.89,173.53 170.52,173.53 172.75,175.76 174.19,175.76 174.62,176.2 174.93,176.2 175.3,176.57 176.54,176.57 v1(176.65,176.68)
  BOTTOM w0.14: v1(80.43,89.86) 81.13,89.86 82.81,88.18 82.81,50.43 81.05,48.67 65.54,48.67 63.79,50.42 61.95,50.42 61,51.38 61,52.28 58.78,54.5 58.26,54.5 57.92,54.84 48.32,54.84 45.75,52.27 43.67,52.27 42.18,50.77 40.55,50.77 38.28,48.51 38.28,47.24 38.88,46.64 v2(38.88,46.15) ; PR470.2 182.12,194 181.95,193.82 181.95,191.46 181.85,191.36 181.85,188.34 v1(181.49,187.98)
24780_DH: length 9.1
  TOP w0.14: v3(47.37,42.25) v1(46.87,42.76)
  TOP w0.178: v3(41.66,43.19) 41.63,43.16 PU18.26
  IN1 w0.635: v3(41.66,43.19) 46.43,43.19 v3(47.37,42.25)
  BOTTOM w0.635: v3(47.37,42.25) 47.21,42.42 PQ69.4
24780_DL: length 5.1
  IN1 w0.635: v3(41.21,41.79) v3(44.48,41.79)
  BOTTOM w0.14: v1(43.36,41.79) v3(44.48,41.79)
  BOTTOM w0.381: PQ71.4 44.41,41.73 v3(44.48,41.79)
24780_ILIM: length 4.8
  TOP w0.14: PC263.2 41.08,40.29 v1(41.08,40.89) 41.06,40.87 40.29,40.87 40.02,40.6 40.02,40.41 39.89,40.28 39.7,40.28 39.56,40.42 PU18.21
  BOTTOM w0.14: PR656.1 41.37,39.8 PR655.1 41.08,40.09 v1(41.08,40.89)
24780_LX: length 13.8
  TOP w0.152: v3(41.57,43.96) 41.16,43.56 PU18.27
  TOP w0.254: v3(41.57,43.96) 41.89,44.29 43.55,44.29 43.77,44.06 43.77,41.99 43.24,41.45 PC259.1
  IN1 w0.635: v3(48.47,43.9) 48.41,43.96 v3(41.57,43.96)
  vias: v1(47.09,40.02)
24780_SRN: length 37.3
  TOP w0.102: PC267.2 38.85,39.19 38.85,38.76 PC272.2 38.87,38.53 38.87,38.12 38.43,37.68 37.63,37.68 37.51,37.8 37.51,38.05 v1(37.75,38.28)
  TOP w0.14: PU18.19 38.76,40.29 38.83,40.22 38.83,39.53 PC267.2
  IN1 w0.086: v1(56.91,51.8) 56.59,51.48 56.59,51.25 56.41,51.07 52.06,51.07 51.7,50.71 48.77,50.71 47.58,49.52 44.57,49.52 43.13,48.08 43.13,47.03 40.63,44.53 37.43,44.53 36.43,43.52 36.43,41.62 36.02,41.21 36.02,39.82 36.78,39.06 37.28,39.06 37.46,38.87 37.46,38.68 37.47,38.56 v1(37.75,38.28)
  BOTTOM w0.14: v1(56.91,51.8) 56.89,51.78 56.89,50.99 PR623.1
24780_SRP: length 38.1
  TOP w0.102: v1(37.02,38.28) 37.31,37.99 37.31,37.71 37.55,37.47 38.51,37.47 39.07,38.03 39.07,38.53 39.19,38.65 PC272.1 39.05,38.8 39.05,39.2 39.21,39.35 PC266.2
  TOP w0.14: PU18.20 39.16,40.27 39.07,40.18 39.07,39.51 PC266.2
  IN1 w0.086: v1(56.18,51.77) 56.42,51.53 56.42,51.32 56.34,51.23 51.99,51.23 51.63,50.87 48.7,50.87 47.51,49.68 44.5,49.68 42.97,48.15 42.97,47.1 40.56,44.69 37.36,44.69 36.26,43.59 36.26,41.69 35.86,41.28 35.86,39.75 36.71,38.89 37.21,38.89 37.3,38.8 37.3,38.68 37.3,38.56 v1(37.02,38.28)
  BOTTOM w0.14: v1(56.18,51.77) 56.62,51.34 56.62,51.04 PR622.1
51225_CS1: length 3.1
  TOP w0.203: PU15.1 154.6,60.45 154.82,60.67 155.88,60.67 v1(156.01,60.8) PR277.1
51225_CS2: length 3
  TOP w0.203: PR278.1 150.79,61.8 151.67,60.92 v1(151.9,60.92) 152.4,60.92 153,60.33 PU15.5
51225_DH1: length 9.8
  TOP w0.14: v3(163.79,54.2) v1(163.79,53.43)
  IN1 w0.762: v3(163.79,54.2) 160.91,54.2 157.97,57.14 v3(155.96,57.14)
51225_DH2: length 10.4
  TOP w0.14: v3(148.72,48.73) v1(148.72,49.49)
  IN2 w0.762: v3(151.64,57.11) 148.72,54.19 v3(148.72,48.73)
51225_DL1: length 5.7
  TOP w0.14: v3(159.14,54.27) v1(159.14,55.08)
  IN1 w0.762: v3(159.14,54.27) 157.41,56 155.78,56 v3(155.21,56.57)
51225_DL2: length 10.7
  TOP w0.14: v3(154.35,48.48) 154.35,48.4 v1(153.67,47.71)
  IN1 w0.762: v3(154.35,48.48) 153.81,49.02 153.81,55.2 v3(152.4,56.6)
  BOTTOM w0.14: v3(152.4,56.6) v1(153.17,56.6)
51225_EN1: length 2
  TOP w0.203: PU15.20 155.59,59.44 156.7,60.54 PR294.2
51225_FB1: length 4.8
  TOP w0.203: PR281.1 156.92,61.42 v1(156.61,61.1) ; v1(155.48,61.16) 155.48,61.41 155.14,61.74 PR283.2 154.66,61.51 154.66,61.05 154.2,60.59 PU15.2
  BOTTOM w0.203: v1(155.48,61.16) 156.54,61.16 v1(156.61,61.1)
51225_FB2: length 3.2
  TOP w0.203: PU15.4 153.4,60.57 153.2,60.78 153.11,60.78 152.91,60.98 152.91,61.43 153.04,61.56 PR280.2 PR279.1
51225_SW1: length 16.9
  TOP w0.508: PR308.1 160.29,50.2 v1(160.29,48.43) 160.29,47.72 v3(160.84,47.18)
  IN2 w0.762: v3(156.23,58.88) 160.84,54.27 v3(160.84,47.18)
51225_SW2: length 15.5
  TOP w0.508: v3(152.4,47.21) 152.4,48.1 153.18,48.87 v1(153.18,49.11) PR307.1
  IN1 w0.762: v3(152.4,47.21) 152.4,52.7 150.45,54.66 150.45,57.7 v3(151.02,58.28)
51225_VBST1: length 2.9
  TOP w0.178: PU15.17 156.06,58.24
  TOP w0.254: 156.06,58.24 156.17,58.13 v1(156.47,58.13) 156.47,57.83 157.27,57.02 PR295.2
51225_VBST2: length 3
  TOP w0.203: PU15.9 151.8,58.24
  TOP w0.254: 151.8,58.24 v1(150.9,57.34) 150.46,56.89 PR296.1
51225_VIN: length 3.8
  TOP w0.178: PR300.1 151.61,55.21 151.64,55.18 PC219.1 152.37,55.35 v1(153.04,56.02) 153.4,56.39 PU15.12
81305_ALERT#: length 1.6
  BOTTOM w0.14: PU20.35 119.95,213.45 PR372.2
81305_COMP: length 4.8
  BOTTOM w0.178: PU20.6 123.44,210.33 124.14,209.62 PC313.2 124.93,209.13 125.85,209.13 PC311.2
81305_CSCOMP: length 41.7
  IN4 w0.086: v1(111.12,191.95) 110.86,191.69 110.61,191.69 110.3,192 110.3,195.15 111.1,195.94 111.1,198.03 114.44,201.37 127.6,201.37 129.61,203.39 129.61,207.73 128.81,208.54 v1(128.81,208.63)
  BOTTOM w0.14: PU20.8 123,209.53 124.13,208.4 PR395.1 124.65,208.4 124.89,208.63 PC316.1 PC317.1 126.64,209.13 127.34,209.13 127.83,208.64 PR398.2 128.8,208.64 v1(128.81,208.63) ; PR481.1 111.01,191.84 v1(111.12,191.95)
81305_CSP1: length 8.1
  BOTTOM w0.14: v1(113.19,203.51) PR6041.2 114.13,203.51 114.91,204.29 PR414.2 115.39,204.58 115.39,205.13 115.29,205.23 PC329.2 115.94,206.18 115.94,206.53 117.35,207.95 117.35,208.59 117.49,208.73
  BOTTOM w0.152: 117.49,208.73 PU20.21
81305_CSP2: length 8.9
  BOTTOM w0.14: PC328.2 116.61,205.37 116.61,203.82 116.3,203.51 PR6040.2 115.53,202.98 115.53,202.7 115.47,202.64 PR415.2 v1(114.32,202.26)
  BOTTOM w0.152: PU20.19 118.75,207.84 117.74,206.83 117.37,206.83 117.12,206.58 117.12,206.23 PC328.2
81305_CSP3: length 8.6
  BOTTOM w0.14: v1(117.35,200.88) 117.45,200.98 PR416.2 117.69,202.05 117.69,202.9 117.32,203.27 PR6039.2 117.79,203.98 117.79,204.62 117.71,204.7 117.71,205.13 117.65,205.19 PC326.2
  BOTTOM w0.152: PU20.17 119.55,207.76 118.26,206.47 118.26,206.16 PC326.2
81305_CSP4: length 9.6
  BOTTOM w0.14: v1(118.62,200.11) 118.42,200.32 PR417.2 118.98,201.51 118.98,203.08 PR6038.2 119.1,204.07 119.1,204.75 118.81,205.04 PC327.2
  BOTTOM w0.152: PU20.15 120.34,207.43 119.57,206.66 119.57,206.31 PC327.2
81305_CSP5: length 9.7
  BOTTOM w0.14: v1(120.02,200.11) 119.48,200.65 PR418.2 119.75,200.95 120.12,201.32 120.12,202.83 119.66,203.29 PR6037.2
  BOTTOM w0.152: PU20.13 121.15,207.37 120.65,206.88 120.65,206.17 PC325.2 120.04,205.22 120.27,204.99 120.27,204.19 PR6037.2
81305_CSP6: length 8.5
  BOTTOM w0.14: PR419.2 v1(122.65,201.68)
  BOTTOM w0.178: PR419.2 121.5,201.91 121.25,202.16 121.25,202.92 121.05,203.12 PR6036.2 121.62,204.08 121.62,205.18 121.24,205.56 PC323.2 121.25,205.57 121.73,206.05 121.73,207.07 121.95,207.28 PU20.11
81305_CSREF: length 10.7
  BOTTOM w0.152: PC324.2 122.73,206.07 122.73,206.71 122.96,206.95 122.96,207.45 122.73,207.69 122.73,208.13 122.96,208.37 122.96,208.58 122.81,208.73 PU20.10
  BOTTOM w0.178: PR425.2 PR424.2 PR423.2 PR422.2 123.24,204.31 PR421.2 PR420.2 122.26,205.17 122.22,205.22 PC324.2
81305_CSSUM: length 14
  BOTTOM w0.152: PR403.2 123.2,206.35
  BOTTOM w0.178: PC316.2 PC317.2 PR397.1 127.1,207.5 127.47,207.13 128.06,207.13 128.77,206.42 128.77,206.35 ; PU20.9 122.89,209.13 123.98,208.04 123.98,207.35 123.2,206.58 123.2,206.35 PR404.2 PR405.2 PR406.2 PR407.2 128.77,206.35 ; 128.77,206.35 PR408.2
81305_DIFFOUT: length 3.2
  BOTTOM w0.178: PU20.4 123.41,211.13 123.93,211.65 PC301.1 PR391.2
81305_EN: length 10.3
  TOP w0.14: PU3.4 125.85,213.39 125.89,213.42 PR29.2 125.89,214.29 v1(125.5,214.68) 123.72,214.68 123.44,214.95 123.44,215.34 123.19,215.6 122.64,215.6 122.25,215.2 v2(122.25,215.09)
  BOTTOM w0.14: PU20.39 121.55,213.48 121.75,213.68 122.02,213.68 122.38,214.04 PC290.2 122.08,214.16 121.92,214.32 121.92,214.76 v2(122.25,215.09) PR362.2
81305_FB: length 8.2
  BOTTOM w0.14: PR387.1 v1(128.27,211.8)
  BOTTOM w0.178: PR387.1 127.27,211.56 PR390.2 126.05,210.78 125.85,210.99 125.4,210.99 125.22,210.81 PR391.1 PC313.1 124.72,210.12 124.13,210.12 123.53,210.73 PU20.5
81305_ILIM: length 2.3
  BOTTOM w0.178: PU20.7 123.12,209.93 124.2,208.85 PR395.2
81305_IOUT: length 6
  BOTTOM w0.178: PR378.1 126.33,213.31 126.49,213.14 PR381.1 125.86,212.16 124.53,212.16 124.24,212.45 PC299.2 124.15,212.69 123.31,211.85 123.19,211.85 122.87,211.53 PU20.3
81305_PSYS: length 4.7
  BOTTOM w0.14: PU20.40 121.95,213.15 122.19,213.4 122.34,213.4 PC291.2 123.3,214.16 123.5,214.36 123.5,214.88 123.45,214.94 123.45,214.94 123.44,214.95 123.44,215.33 123.45,215.34 PR353.1 123.12,215.73 122.94,215.54 PR363.2
81305_ROSC: length 2.1
  BOTTOM w0.14: PR375.1 118.08,213.87 118.52,213.87 119.15,213.24 PU20.33
81305_SCLK: length 1.5
  BOTTOM w0.14: PU20.36 120.34,213.78 PR370.2
81305_SDIO: length 1.8
  BOTTOM w0.14: PR371.2 118.61,214.18 119.55,213.24 PU20.34
81305_TSENSE: length 3.6
  BOTTOM w0.178: PU20.23 117.3,209.53 v1(116.49,208.72) 116.16,208.39 PR396.2 PC320.2
81305_VCC: length 5.7
  BOTTOM w0.14: v1(114.33,215.25) PR355.1 116.07,215.25 PC284.1 116.93,214.27 117.62,213.59 118.37,213.59 118.75,213.21 PU20.32
81305_VR_RDY: length 1.5
  BOTTOM w0.14: PR374.2 121.15,213.82 PU20.38
81305_VRHOT: length 1.4
  BOTTOM w0.14: PR373.2 120.87,213.97 120.87,213.61 120.74,213.49 PU20.37
81305_VRMP: length 4.2
  BOTTOM w0.178: PU20.31 118.34,213.11 118.17,213.29 117.5,213.29 116.86,213.92 116.67,213.92 116.63,213.95 PR376.2
  BOTTOM w0.203: PC297.2 PR376.2
81305_VSN: length 9.5
  BOTTOM w0.152: PC295.2 124.92,213.11 125.62,213.11 125.86,213.36 125.86,213.79 126.15,214.08 127.8,214.08 128.12,214.4 128.12,215.2 v1(127.92,215.4) 127.71,215.61 PR364.1
  BOTTOM w0.178: PC295.2 123.84,212.96 123.84,212.83 123.25,212.23 123.12,212.23 122.82,211.93 PU20.2
81305_VSP: length 9.1
  TOP w0.14: PR19.2 126.23,215.14 125.99,215.14 125.85,215.28 125.85,215.55 125.71,215.69 125.43,215.69 125.29,215.55 125.29,215.28 125.15,215.14 124.73,215.14 124.51,215.35 124.05,215.35 123.91,215.22 v1(123.91,215.14)
  BOTTOM w0.14: 124.48,215.56 PC280.1 124.32,215.55 v1(123.91,215.14)
  BOTTOM w0.178: PR356.2 124.48,215.56 ; PU20.1 122.76,212.33 123.93,213.5 123.93,214.07 PC287.1 v1(123.91,215.14)
+BAT_RTC: length 26.6
  BOTTOM w0.305: R1160.1 v1(230.38,46.06) 228.43,46.06 227.82,45.45 226.72,45.45 226.37,45.1 226.37,44.51 226.18,44.32 226,44.32 225.28,43.6 224.72,43.6 224.4,43.92 CN16.1 222.26,45.44 221.76,44.93 215.76,44.93 212.98,47.71 211.2,47.71 211.06,47.58 Q116.1
+CORE_PLLVDD: length 23.4
  TOP w0.203: CG354.2 243.82,132.59 v2(243.8,132.57) ; CG344.1 237.35,134.02 237.24,134.12 236.96,134.12 v2(236.81,133.97) ; CG355.2 246.12,132.81 246.34,132.59 v2(246.6,132.59) ; CG339.1 239.37,133.73 v2(239.62,133.97)
  TOP w1.016: 266.6,135.9 266.6,135.72 v1(265.58,134.69) 264.69,133.81 261.87,133.81 261.86,133.8 261.84,133.79 261.2,133.14 259,133.14 258.7,133.44 258.7,136.28 257.05,137.94 254.84,137.94
  BOTTOM w0.25: UG6.BG22 242.05,133.62 v2(242.39,133.96) ; v2(246.6,132.59) 246.26,132.92 UG6.BH16
  BOTTOM w0.254: UG6.BH22 242.4,133.27 v2(242.4,133.28) ; UG6.BG25 239.95,133.64 v2(239.62,133.97) 239.95,134.3 UG6.BF25 ; v2(251.41,134.74) 251.41,134.58 UG6.BF9 v2(250.79,134.68) ; UG6.BH19 244.11,132.92 243.8,132.6 v2(243.8,132.57)
+FBA_PLL_AVDD: length 14.3
  TOP w0.203: CG245.1 226.02,143.17 v2(225.77,142.92) ; CG123.1 226.67,156.23 226.33,155.89 226.21,155.89 v2(225.86,155.54) 225.86,155.27 225.62,155.03 CG152.1 ; v2(249.4,149.38) 249.48,149.3 CG197.1 249.48,148.94 CG198.1 ; CG184.1 225.78,150.58 v2(225.78,150.58) ; v2(245.95,158.42) 246.11,158.26 CG98.1 ; v2(232.76,158.37) 232.76,158.28 232.47,158 CG106.1
  IN1 w0.508: 226.34,142.43 226.34,140.56 225.71,139.94 225.71,139.21 226.27,138.65 226.27,138.27
  BOTTOM w0.102: v2(225.78,150.58) 225.62,150.42 UG6.AC46 ; UG6.T46 225.39,155.32 225.66,155.59 225.81,155.59 v2(225.86,155.54) ; UG6.AE11 249.75,149.03 v2(249.4,149.38)
  BOTTOM w0.25: v2(225.77,142.92) 225.57,142.72 UG6.AP46
  BOTTOM w0.254: UG6.L35 232.76,158.63 v2(232.76,158.37) ; v2(245.95,158.42) UG6.L17
  vias: v2(225.76,137.63) v2(226.32,137.47)
+FBVDDQ_MEM: length 245.8
  TOP w0.203: v2(204.33,145.7) 204.45,145.81 RG37.1 ; RG22.1 266.75,158.64 ; v2(210.25,144.85) 210.01,145.08 RG39.1 ; v2(251.27,174.23) 251.4,174.37 RG18.1 ; v2(267.74,156.81) 268.31,157.38 RG23.1 ; CG276.2 226.13,140.39 v2(225.69,140.83) ; v2(225.71,142.25) 225.89,142.08 CG251.2 ; 264.53,145.42 RG38.1
  TOP w0.254: RG21.1 206.27,160.98
  TOP w0.508: v2(201.16,145.69) 201.41,145.94 CG214.1 ; v1(199.04,148.48) 198.84,148.48 CG206.1 ; v1(255.11,214.71) 255.32,214.71 255.55,214.93 PR11.1 ; CG291.1 202.75,138.4 v2(202.75,137.92) ; CG303.1 199.97,137.92 v2(200.39,137.92) ; CG162.1 200.42,152.3 v2(200.39,152.27) ; v1(198.99,147.11) 198.31,146.42 CG215.1 ; CG290.1 204.1,138.51 v2(204.1,137.99) ; CG189.1 198.94,149.85 v1(199.14,149.65) ; CG129.1 200,156.54 v2(200.38,156.91) ; CG279.1 274.9,140.59 v2(274.62,140.88)
  IN1 w0.102: v2(212.5,127.23) 212.86,126.86 213.62,126.86 v2(214,127.25)
  IN2 w0.508: v1(255.11,214.71) 255.28,214.71 255.79,214.2 255.79,213.29 253.84,211.34 253.84,203.78 255.5,202.12 255.5,197.63
  BOTTOM w0.102: VRAM5.N4 270.38,163.16 ; UG6.AH11 249.57,146.92 v2(249.32,146.67) ; v2(267.75,165.1) 267.38,164.73 VRAM5.J2 ; VRAM6.L14 208.32,142.25 208.32,142.89 VRAM6.L13 ; v2(211.76,150.07) 212.13,149.7 VRAM6.T4 ; VRAM4.J2 207.63,157.41
  BOTTOM w0.203: v2(205.67,127.22) 205.67,127.17 205.48,126.98 CG513.1 ; VRAM7.E10 270.94,147.76 v2(270.94,147.45) ; VRAM7.L14 266.68,150.89 266.68,150.25 VRAM7.L13 ; VRAM5.L14 268.77,155.8 268.77,156.34 VRAM5.L13 ; VRAM3.H14 247.69,177.88 248.31,177.88 VRAM3.H13 ; v2(204.25,127.24) 204.21,127.2 CG512.1 ; VRAM6.H13 206.13,142.78 206.19,142.72 206.19,142.36 206.13,142.31 VRAM6.H14 ; VRAM3.P10 250.8,173.63 250.8,173.77 v2(251.27,174.23) ; VRAM7.H14 268.82,150.89 268.82,150.25 VRAM7.H13 ; VRAM3.L14 247.69,175.76 248.31,175.76 VRAM3.L13 ; v2(202.75,127.25) 202.81,127.18 CG511.1
  BOTTOM w0.245: v2(208.77,141.73) 208.69,141.73 208.38,142.05 VRAM6.L14 ; VRAM5.C14 262.65,155.47 v2(262.65,155.12) ; VRAM1.L14 218.4,175.47 v2(218.09,175.47) ; VRAM8.E14 210.63,137.55 v2(211.05,137.97) ; VRAM2.C1 233.03,171.95 v2(232.66,171.57) ; VRAM5.L14 268.88,155.16 v2(268.79,155.08) ; v2(201.39,148.42) 201.39,148.71 VRAM6.B5 ; VRAM3.A1 257.38,183.37 v2(257.68,183.67) ; v2(212.72,156.18) 212.21,156.7 VRAM4.C1 ; VRAM5.C11 262.88,157.97 v2(262.5,158.35) ; v2(212.54,137.96) 212.13,137.54 VRAM8.C14 ; VRAM6.T14 212.13,142.1 v2(212.52,141.7) ; VRAM2.A1 233.05,170.45 v2(232.68,170.07) ; VRAM3.P5 253.77,174.05 v2(253.77,174.28) ; v2(212.36,152.49) 212.13,152.26 VRAM6.T1 ; VRAM3.H14 247.32,178.25 v2(247.1,178.25) ; 262.56,165.97 v2(262.5,165.92) 262.88,165.54 VRAM5.C1 ; VRAM8.A14 214,137.82 v2(214,138) ; VRAM4.U5 201.67,159.7 202.02,159.34 v2(202.02,159.31) 202.38,158.96 VRAM4.T4 ; CG514.1 209.09,126.31 208.7,126.71 v2(208.7,127.23) 208.7,127.34 208.38,127.66 ; v2(243.41,171.59) 243.23,171.59 VRAM2.C14 ; 208,128.07 VRAM8.H1 208.38,127.66 ; 208,128.07 VRAM8.J2 ; 208,128.07 VRAM8.H2 ; 208.38,127.66 v2(207.94,127.22) ; VRAM2.B10 239.67,171.2 v2(239.39,170.92) ; v2(218.13,171.55) 218.53,171.95 VRAM1.T14 ; v2(208.51,152.52) 208.38,152.38 VRAM6.L1 ; v2(262.48,151.44) 262.88,151.04 VRAM7.T14 ; v2(225.72,174.57) 225.75,174.57 VRAM1.N4 VRAM1.P5 ; v2(247,175.66) 247.04,175.7 VRAM3.L14 ; v2(247.13,171.55) 247.53,171.95 VRAM3.T14 ; v2(211.09,141.68) 211.06,141.68 210.63,142.12 VRAM6.P14 ; v2(222.27,170.78) 221.86,171.2 VRAM1.U10 ; v2(218.13,173.03) 218.55,173.45 VRAM1.P14 ; VRAM2.E1 233.07,173.39 232.87,173.39 v2(232.64,173.16) ; v2(202.75,141.75) 202.38,142.12 VRAM6.C14 ; VRAM6.C1 202.38,152.02 202.38,152.43 v2(202.38,152.5) ; VRAM5.V14 274.14,155.7 v2(274.61,155.23) ; v2(211.01,152.46) 211.01,152.33 VRAM6.P1 ; v2(204.1,137.99) 204.18,138.07 204.18,139.29 ; v2(204.26,141.72) 204.08,141.54 204.08,140.35 ; v2(205.67,127.22) 205.75,127.3 205.75,127.32 205.95,127.52 VRAM8.L1 206.13,127.6 v2(206.5,127.23) ; VRAM4.H1 208.7,156.37 v2(208.7,156.23) ; VRAM6.H14 205.67,141.74 ; v2(236.6,170.7) 236.13,171.17 VRAM2.B5 ; v2(274.6,165.02) 274.17,165.45 VRAM5.V1 ; VRAM5.F11 265.13,157.97 v2(264.75,158.34) 264.4,158.7 VRAM5.E10 ; VRAM2.A14 243.02,170.3 243.43,170.3 v2(243.44,170.31) ; VRAM6.V14 213.63,142 213.69,141.93 213.69,141.91 v2(213.92,141.69) ; VRAM7.F4 VRAM7.E5 271.03,144.2 270.41,144.81 v2(270.37,144.81) ; v2(243.41,173.07) 243.03,173.45 VRAM2.E14 ; VRAM8.E1 210.63,127.62 v2(211.03,127.22) 210.87,127.06 CG515.1 ; VRAM4.E1 210.63,156.62 211.04,156.2 v2(211.14,156.2) ; v2(247.13,173.03) 247.55,173.45 VRAM3.P14 ; VRAM7.A1 274.3,141.2 v2(274.62,140.88) ; CG517.1 214.37,126.77 214,127.15 v2(214,127.25) 213.63,127.62 VRAM8.A1
  BOTTOM w0.25: v2(214.02,156.2) 213.63,156.59 VRAM4.A1 ; VRAM1.L13 219.29,175.78 218.71,175.78 VRAM1.L14 ; VRAM1.H13 219.29,177.86 218.71,177.86 VRAM1.H14 ; v2(205.68,166.94) 206.13,166.5 VRAM4.L14
  BOTTOM w0.254: VRAM4.E10 210.27,163.8 v2(210.25,163.8) 210.23,163.82 210.21,163.82 209.88,164.15 VRAM4.F11 ; VRAM5.B10 262.15,158.7 v2(262.5,158.35) ; VRAM4.P14 203.88,166.48 204.08,166.69 v2(204.08,167.15) 204.08,167.52 204.35,167.78 ; VRAM6.N11 v2(209.51,144.08) ; v2(263.96,151.44) 264.38,151.03 VRAM7.P14 ; VRAM8.N4 204.63,129.95 v2(205,130.31) ; v2(212.5,130.35) 212.13,129.97 VRAM8.C4 212.14,129.95 v2(212.49,129.59) ; VRAM6.L2 208.38,151.23 v2(208,151.6) 207.63,151.22 VRAM6.K2 ; VRAM4.T1 202.38,156.62 v2(202.75,156.25) ; v2(218.12,170.15) 218.33,170.15 VRAM1.V14 ; CG516.1 212.52,127.2 v2(212.5,127.23) 212.13,127.6 VRAM8.C1 ; UG6.AJ11 249.55,146.02 v2(249.55,145.66) ; VRAM1.J13 219.35,177.2 v2(218.98,176.82) 219.36,176.45 VRAM1.K13 ; VRAM8.C11 212.13,135.17 v2(212.5,134.8) 212.85,134.45 VRAM8.B10 ; VRAM5.A14 261.38,155.36 v2(261.21,155.19) ; VRAM2.C11 240.63,171.95 240.98,172.31 v2(240.98,172.33) ; VRAM6.V1 213.63,152.02 213.89,152.29 v2(213.89,152.46) ; v2(200.39,152.27) 200.56,152.27 VRAM6.A1 ; VRAM7.H14 268.88,151 v2(269.25,151.37) ; v2(228.86,170.02) 228.44,170.45 VRAM1.V1 ; UG6.AU11 249.75,140.62 v2(249.38,140.99) ; VRAM5.J13 267.38,156.41 v2(267.75,156.04) ; VRAM7.U5 262.15,144.2 v2(262.5,143.85) 262.5,143.82 VRAM7.T4 ; VRAM1.F4 226.13,179.45 v2(225.76,179.82) 225.38,180.2 VRAM1.E5 ; VRAM6.N4 209.87,149.7 209.49,149.31 v2(209.49,149.3) ; VRAM2.H14 242.87,175.7 242.51,175.33 v2(242.51,175.32) 242.5,175.32 242.13,175.69 VRAM2.H13 ; VRAM6.E1 203.65,152.18 v2(203.65,152.51) ; VRAM7.B10 273.38,147.87 v2(273.78,147.47) ; VRAM6.H1 205.96,152.11 v2(205.96,152.54) ; VRAM7.J2 VRAM7.K2 ; VRAM4.L2 206.13,157.42 v2(205.75,157.04) ; v2(202.75,137.92) 202.75,137.82 VRAM8.T14 ; v2(213.27,148.3) 213.27,148.55 VRAM6.U5 ; VRAM8.K13 206.88,136.72 v2(207.25,137.1) 207.63,136.72 VRAM8.J13 ; UG6.K10 250.45,159.52 v2(250.8,159.17) ; VRAM5.P14 271.13,155.57 v2(270.84,155.28) ; VRAM8.P10 203.91,134.45 v2(204.25,134.79) 204.63,135.16 VRAM8.N11 ; VRAM8.P5 203.88,130.68 v2(204.26,130.3) ; VRAM8.U10 v2(202,134.82) VRAM8.T11 ; v2(212.5,144.85) 212.13,144.47 VRAM6.T11 ; v2(202.76,144.8) 202.73,144.8 VRAM6.C11 ; VRAM8.E10 210.6,134.45 v2(210.25,134.79) 209.88,135.17 VRAM8.F11 ; v2(273.76,150.58) 274.12,150.95 VRAM7.A14 ; VRAM4.P5 203.89,159.7 v2(204.25,159.34) ; v2(261.87,161.98) 261.87,162.19 VRAM5.B5 262.17,162.45 262.5,162.77 v2(262.5,162.79) 262.88,163.17 VRAM5.C4 ; 202.95,168.95 202.95,167.27 v2(202.67,166.99) 202.67,166.74 VRAM4.T14 ; VRAM3.U5 254.72,171.54 v2(254.72,171.57) 254.75,171.57 VRAM3.T4 ; VRAM4.K13 206.88,165.72 v2(207.25,166.1) 207.63,165.73 VRAM4.J13 ; VRAM5.P10 271.09,158.7 v2(270.74,158.35) 270.74,158.31 VRAM5.N11 ; v2(204.25,127.24) 203.88,127.61 VRAM8.P1 ; v2(208.75,166.1) 208.4,166.45 VRAM4.H14 ; VRAM4.N4 205,159.33 v2(205,159.34) ; VRAM4.V1 200.59,156.7 v2(200.38,156.91) ; VRAM6.P10 210.59,145.2 v2(210.25,144.85) ; VRAM3.N11 249.9,174.2 v2(250.27,173.83) 250.27,173.78 250.6,173.45 VRAM3.P10 ; v2(212.2,166.98) 212.2,166.95 212.13,166.88 VRAM4.C14 ; v2(249.33,144.54) 249.61,144.82 UG6.AL11 ; v2(201.19,160.2) 201.63,159.77 VRAM4.U5 ; VRAM6.F4 204.63,149.67 v2(204.28,149.32) 203.9,148.95 VRAM6.E5 ; VRAM7.B5 273.01,143.83 v2(272.98,143.83) 272.98,143.8 VRAM7.C4 ; UG6.AR11 249.63,142.02 v2(249.31,142.35) ; VRAM2.C4 235.38,171.93 235.74,171.57 v2(235.78,171.57) 235.78,171.53 236.11,171.2 VRAM2.B5 ; v2(260.97,150.6) 261.31,150.95 VRAM7.V14 ; v2(270,148.3) 270.38,148.67 VRAM7.F11 ; VRAM7.E1 271.11,141.2 v2(270.69,140.78) 270.91,140.55 CG501.1 ; VRAM4.K2 206.88,157.42 v2(207.23,157.07) ; v2(267.74,150.59) 267.74,150.58 ; 267.74,150.58 267.38,150.22 VRAM7.K13 ; 267.74,150.58 268.13,150.2 VRAM7.J13 ; VRAM2.F4 235.4,174.2 235.77,173.83 v2(235.78,173.83) 235.78,173.82 236.13,173.47 VRAM2.E5 ; VRAM7.N11 265.13,148.67 v2(264.75,148.29) 264.4,147.95 VRAM7.P10 ; v2(213.23,145.88) 213.23,145.55 VRAM6.U10 ; v2(202.02,130.31) 202.02,130.29 202.36,129.95 VRAM8.T4 ; VRAM7.C14 272.63,151.06 v2(272.29,151.4) ; VRAM5.P1 271.12,165.45 v2(270.66,165.91) 270.66,166.73 ; v2(247.12,170.15) 247.23,170.15 247.52,170.45 VRAM3.V14 ; VRAM6.B5 202,149.32 v2(202,149.33) 202.01,149.33 VRAM6.C4 ; v2(264.05,155.24) 264.38,155.57 VRAM5.E14 ; VRAM6.F11 204.63,144.48 v2(205,144.85) ; v2(202.75,141.75) 202.75,140.47 202.74,140.47 ; VRAM8.E5 210.6,130.7 v2(210.25,130.34) ; v2(263.25,157.56) 262.88,157.93 VRAM5.C11 ; v2(204.26,141.72) 203.88,142.11 VRAM6.E14 ; VRAM5.F4 265.13,163.2 265.48,163.56 265.49,163.56 v2(265.5,163.57) ; VRAM5.U10 273.38,158.68 v2(273,158.31) 272.64,157.95 VRAM5.T11 ; UG6.AF11 249.67,148.32 v2(249.36,148.01) ; VRAM8.H14 208.4,137.45 v2(208.75,137.1) 208.38,136.72 VRAM8.H13 ; VRAM8.L2 206.13,128.42 v2(206.5,128.05) 206.88,128.42 VRAM8.K2 ; VRAM7.E14 271.13,151.03 v2(270.74,151.42) ; v1(271.82,167.55) 271.82,166.33 v2(272.25,165.9) 272.63,165.52 VRAM5.T1 ; VRAM1.T1 228.55,171.95 v2(228.87,171.62) ; VRAM4.H13 208.38,165.7 v2(208.75,165.33) ; VRAM2.E10 239.88,173.47 v2(240.22,173.82) 240.6,174.2 VRAM2.F11 ; VRAM5.L1 268.88,165.94 v2(268.84,165.98) ; v2(204.25,156.24) 204.25,156.32 VRAM4.P1 ; v2(207.26,143.31) 207.26,143.31 VRAM6.K13 ; v2(205.68,166.94) 204.92,167.7 CG447.2 ; VRAM7.C1 272.63,141.15 v2(272.27,140.79) 272.38,140.67 CG502.1 ; VRAM8.B5 213.37,131.19 v2(213.37,131.21) ; VRAM5.E5 264.35,162.45 v2(264,162.79) ; VRAM1.N11 220.91,174.2 v2(221.28,173.82) 221.63,173.48 VRAM1.P10 ; UG6.AP11 v2(249.34,143.13) ; UG6.AV11 249.7,139.92 249.45,139.67 v2(249.45,139.54) ; VRAM5.V1 273.27,166.3 v1(273.27,167.55) ; VRAM4.H2 208.38,157.42 v2(208,157.04) 207.63,157.41 ; VRAM1.T4 226.11,171.95 v2(225.73,171.57) 225.38,171.22 VRAM1.U5 ; VRAM4.B10 212.84,163.45 v2(212.5,163.79) 212.13,164.16 VRAM4.C11 ; CG500.1 269.05,141.02 VRAM7.H1 268.85,141.2 v2(268.49,141.55) 268.88,141.93 VRAM7.H2 ; 201.16,146.57 v2(201.16,145.69) 201.63,145.22 VRAM6.B10 ; VRAM6.J2 206.88,151.23 v2(206.5,151.6) 206.5,151.57 VRAM6.H2 ; VRAM7.C11 272.63,148.68 v2(272.99,148.32) ; VRAM3.J13 248.38,177.18 v2(248.74,176.82) 248.74,176.81 VRAM3.K13 248.36,176.45 247.98,176.82 v2(247.97,176.82) ; v2(205.97,156.17) 205.97,156.54 VRAM4.L1 ; VRAM4.E14 210.63,166.64 v2(210.94,166.96) ; VRAM4.A14 213.61,166.46 213.61,166.85 v2(213.46,167) ; VRAM4.P10 203.89,163.45 v2(204.24,163.8) ; VRAM2.L13 242.14,177.95 242.5,178.3 v2(242.51,178.3) 242.51,178.29 242.86,177.95 VRAM2.L14 ; v2(242.52,176.82) 242.14,176.45 VRAM2.J13 ; v2(201.15,131.17) 201.62,130.7 VRAM8.U5 ; VRAM4.T11 202.38,164.18 v2(202.01,163.81) 201.64,163.45 VRAM4.U10 ; VRAM1.P1 228.62,173.45 v2(228.89,173.18) ; 204.33,146.4 v2(204.33,145.7) 204.33,145.65 VRAM6.E10 ; v2(254.72,173.82) 254.75,173.82 VRAM3.N4 ; VRAM8.F4 209.87,129.95 v2(209.5,129.58) ; v2(204.1,137.99) 204.1,137.66 VRAM8.P14 ; v2(249.38,143.76) 249.74,144.12 UG6.AM11 ; v2(264.97,144.8) 264.97,144.66 264.5,144.2 VRAM7.P5 VRAM7.N4 265.5,143.82 v2(265.5,143.85) ; VRAM4.L14 206.22,166.35 206.22,165.79 VRAM4.L13 ; VRAM2.K13 242.13,177.18 241.77,176.82 v2(241.75,176.82) ; VRAM1.T11 VRAM1.U10 ; VRAM3.T11 249.88,171.93 250.24,171.57 v2(250.27,171.57) 250.27,171.55 VRAM3.U10 250.93,170.89 v2(251.27,170.89) ; v2(272.37,155.21) 272.37,155.44 VRAM5.T14 ; 199.67,166.92 v2(200.39,166.92) 200.86,166.45 VRAM4.V14 ; VRAM5.U5 273.38,162.45 v2(273,162.83) 272.63,163.2 VRAM5.T4 ; VRAM5.H13 266.63,156.41 v2(266.26,156.04) 266.61,155.7 VRAM5.H14 ; v2(205.01,163.8) 205.01,163.84 204.65,164.2 VRAM4.N11 ; v2(267.74,156.81) 268.1,156.45 VRAM5.K13 ; v2(210.26,149.3) 210.27,149.3 VRAM6.P5 ; v2(207.25,142.54) 206.88,142.92 VRAM6.J13 ; VRAM4.B5 212.53,159.35 v2(212.49,159.35) 212.13,158.98 VRAM4.C4 ; VRAM7.T11 262.88,148.67 262.5,148.3 v2(262.5,148.29) 262.5,148.29 262.15,147.95 VRAM7.U10 262.13,147.92 261.51,147.31 v2(260.69,147.31) ; v2(270,162.79) 270.38,163.16 v2(270.75,162.79) 270.78,162.79 VRAM5.P5 ; VRAM3.C1 257.6,181.7 v2(257.85,181.44) ; v2(202.75,127.25) 202.38,127.62 VRAM8.T1 ; 201.39,147.54 v2(201.39,148.42) ; v2(266.4,151.48) 266.63,151.26 VRAM7.L14 ; VRAM4.F4 210.25,159.32 v2(210.25,159.34) 210.6,159.7 VRAM4.E5
  BOTTOM w0.35: v2(260.69,147.31) 260.22,147.78 260.22,149.86 v2(260.97,150.6)
  vias: v1(197.96,138.22) v1(198.29,155.31) v1(198.29,154.42) v1(198.24,141.33) v1(198.23,140.6) v1(198.32,169.5) v1(198.35,168.83) v1(198.35,156.35) v1(198.35,153.55) v1(198.61,129.4) v1(198.71,166.63) v1(198.67,131.04) v1(198.76,165.37) v1(198.8,135.82) v1(198.73,132.64) v1(198.82,134.24) v1(198.94,152.39) v1(198.93,145.76) v1(198.98,144.12) v1(198.96,142.49) v1(199.02,169.44) v1(199.11,167.5) v1(199.06,163.85) v1(199.06,162.06) v1(199.08,160.5) v1(199.07,158.86) v1(199.04,157.2) v1(215.18,177.93) v1(215.14,177.03) v1(215.64,183.89) v1(215.64,182.4) v1(215.64,179.32) v1(215.75,180.86) v1(217.25,185.04) v1(221.8,184.97) v1(226.91,184.9) v1(259.58,183.66) v1(261.09,185.82) v1(261.08,185.13) v1(261.09,184.4) v1(261.08,183.71) v1(261.07,182.98) v1(261.06,182.28) v1(261.07,181.51) v1(261.06,180.81) v1(261.07,180.01) v1(261.06,179.31) v1(261.09,177.05) v1(261.09,175.78) v1(261.1,175.06) v1(261.11,174.41) v1(261.11,172.99) v1(261.12,173.68) v1(261.55,178.46) v1(261.54,177.76) v1(268.74,167.62) v1(269.45,167.58) v1(270.26,167.6) v1(271,167.55) v1(272.52,167.5) v1(273.97,167.55) v1(274.7,166.92) v1(274.72,167.6) v1(275.55,168.83) v1(275.66,168.18) v1(275.65,167.53) v1(275.69,161.93) v1(275.68,161.28) v1(275.7,159.66) v1(275.7,151.33) v1(275.76,166.76) v1(275.75,166.11) v1(275.76,165.21) v1(275.75,164.56) v1(275.74,163.66) v1(275.73,163.01) v1(275.71,160.31) v1(275.76,158.35) v1(275.75,157.7) v1(275.75,155.72) v1(275.74,153.65) v1(275.73,153) v1(275.71,151.97) v1(275.74,150.5) v1(275.73,149.85) v1(275.75,149.19) v1(275.75,148.5) v1(275.74,147.2) v1(275.73,146.55) v1(275.74,145.5) v1(275.73,144.85) v1(275.74,143.85) v1(275.73,143.2) v1(275.74,142.09) v1(275.73,141.45) v1(275.74,140.29) v1(275.73,139.64) v1(275.9,154.32) v1(275.92,154.97) v2(200.28,128.08) v2(200.41,142.62) v2(200.44,126.74) v2(205.67,141.69) v2(205.75,137.92) v2(211.39,173.13) v2(213.12,173.15) v2(214.12,166.99) v2(214.56,172.08) v2(218.16,181.37) v2(218.15,179.81) v2(218.14,178.28) v2(218.97,183.59) v2(221.26,182.06) v2(221.28,179.82) v2(222.1,182.85) v2(224.81,182.66) v2(224.9,157.07) v2(224.9,154.96) v2(224.89,138.17) v2(224.91,148.67) v2(225.22,153.79) v2(225.29,143.35) v2(225.6,147.3) v2(225.58,136.8) v2(225.65,148.73) v2(225.65,146.53) v2(225.66,138.22) v2(225.76,182.08) v2(225.73,151.14) v2(225.9,157.04) v2(225.93,157.79) v2(226.86,158.16) v2(227,159.16) v2(228.02,177.57) v2(228.03,176.07) v2(228.57,158.31) v2(228.7,183.69) v2(228.81,179.92) v2(228.84,181.31) v2(228.89,178.16) v2(228.96,175.23) v2(229.38,158.32) v2(231.12,158.37) v2(231.96,158.43) v2(232.61,176.16) v2(232.62,181.45) v2(232.65,177.56) v2(232.65,175.37) v2(232.73,179.79) v2(233.28,183.77) v2(233.38,158.37) v2(233.49,177.56) v2(233.51,176.8) v2(234.02,158.2) v2(234.24,176.07) v2(235.4,158.44) v2(235.77,182.06) v2(235.75,179.8) v2(236.65,182.83) v2(236.71,179.55) v2(236.66,158.93) v2(238.47,158.59) v2(239.01,158.39) v2(239.28,179.42) v2(239.59,159.17) v2(240.26,182.08) v2(240.24,179.82) v2(241.71,158.47) v2(243.01,159.03) v2(243.35,183.68) v2(243.35,181.43) v2(243.34,179.84) v2(243.42,173.73) v2(244.58,158.48) v2(247.09,180.53) v2(247.19,182.06) v2(247.85,183.68) v2(247.98,158.46) v2(248.89,158.25) v2(249.27,155.21) v2(249.31,149.94) v2(249.46,158.4) v2(249.44,157.79) v2(249.48,152.01) v2(249.53,156.05) v2(249.9,151.6) v2(250.09,152.87) v2(250.24,182.06) v2(250.28,179.82) v2(251.1,182.85) v2(253.71,179.64) v2(253.85,182.89) v2(254.77,182.06) v2(254.74,180.58) v2(254.72,179.82) v2(257.02,177.58) v2(257.88,178.22) v2(257.87,173.04) v2(257.89,171.78) v2(257.89,170.09) v2(257.91,179.89) v2(257.96,175.18) v2(261,165.93) v2(260.99,140.58) v2(262.55,140.64) v2(263.98,165.93) v2(264.12,140.68) v2(266.16,140.61) v2(266.3,165.92) v2(267,141.54) v2(267.09,165.92) v3(240.32,196.04) v3(240.32,195.26) v3(240.32,194.47) v3(240.67,193.76) v3(240.8,192.94) v3(241.1,196.04) v3(241.1,195.26) v3(241.1,194.47) v3(241.53,193.17) v3(241.53,192.38) v3(241.74,193.93) v3(242.07,194.67) v3(242.31,193.17) v3(242.31,192.38) v3(242.83,194.91) v3(242.83,194.02) v3(243.1,193.17) v3(243.1,192.38) v3(243.89,193.17) v3(243.89,192.38) v3(244.68,193.17) v3(244.68,192.38) v3(245.46,193.17) v3(245.46,192.38) v3(246.28,193.14) v3(246.25,192.35) v3(248.07,196.08) v3(248.07,195.3) v3(248.07,194.51) v3(248.11,193.71) v3(248.86,196.08) v3(248.86,195.3) v3(248.86,194.51) v3(249,193.71) v3(249.65,196.08) v3(249.65,195.3) v3(249.65,194.51) v3(249.81,193.7) v3(250.24,192.75) v3(250.29,191.97) v3(251.08,193.13) v3(251.08,192.37) v3(251.08,191.61) v3(254.99,193.16) v3(254.99,192.39) v3(255.31,196.15) v3(255.31,195.36) v3(255.31,194.57) v3(255.95,193.2) v3(256.1,196.15) v3(256.1,195.36) v3(256.1,194.57) v3(256.02,192.37) v3(256.03,191.49) v3(256.88,196.15) v3(256.88,195.36) v3(256.88,194.57) v3(256.89,193.21) v3(256.95,192.36) v3(257.04,191.52) v3(257.94,193.38) v3(257.94,192.49) v3(257.94,191.61)
