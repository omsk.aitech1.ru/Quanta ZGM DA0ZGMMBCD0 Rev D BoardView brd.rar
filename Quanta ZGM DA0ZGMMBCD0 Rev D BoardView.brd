# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GPU_EDP_TXN1_R: length 2.2
  BOTTOM w0.14: C574.2 270.8,215.19 270.8,214.92 270.94,214.78 271.63,214.78 271.78,214.63 272,214.42 U36.2
GPU_EDP_TXN2: length 159.3
  IN4 w0.086: v1(275.52,216.75) 275.4,216.87 275.18,216.87 275.07,216.76 275.07,216.61 275.29,216.39 275.29,215.53 275.51,215.31 275.51,214.88 275.98,214.4 275.98,213.88 276.16,213.7 276.4,213.7 276.68,213.42 276.68,211.95 276.37,211.63 276.22,211.63 276.13,211.55 276.13,210.97 276.24,210.87 276.68,210.87 277.65,209.91 278.41,209.91 278.75,209.56 278.75,208.82 279.06,208.51 279.06,207.03 278.84,206.81 278.84,205.24 278.93,205.16 279.88,205.16 280.52,204.52 280.52,202.85 280.34,202.67 279.98,202.67 279.9,202.58 279.9,202.16 279.98,202.07 280.32,202.07 280.52,201.87 280.52,201.33 280.34,201.15 279.68,201.15 279.59,201.06 279.59,200.66 279.71,200.55 280.66,200.55 280.85,200.37 280.85,199.69 280.66,199.51 279.92,199.51 279.83,199.42 279.83,199.23 280.09,198.97 280.09,198.64 279.83,198.38 279.83,198.15 279.92,198.07 280.51,198.07 280.69,197.89 280.69,197.35 280.48,197.14 279.92,197.14 279.83,197.06 279.83,196.16 279.92,196.08 280.37,196.08 280.56,195.89 280.56,154.02 279.36,152.82 279.36,139.5 279.76,139.09 279.76,118.5 274.98,113.72 261.95,113.72 261.6,113.37 254.29,113.37 252.62,115.04 252.62,116.77 249.85,119.54 249.22,119.54 246.81,121.95 246.81,122.98 247.27,123.44 247.27,123.6 247.11,123.76 v1(246.94,123.76)
  BOTTOM w0.102: UG6.BR17 245.46,128.02 245.36,127.92 245.36,127.7 245.21,127.55 245.21,126.8 244.83,126.42 244.83,125.68 246.39,124.12 246.39,123.65 246.76,123.28 247.05,123.28 247.25,123.48 247.25,123.64 247.13,123.76 v1(246.94,123.76)
  BOTTOM w0.14: v1(275.52,216.75) 275.43,216.75 275.29,216.61 275.29,216.41 275.46,216.24 C568.1
GPU_EDP_TXN2_R: length 1.9
  BOTTOM w0.14: U36.11 275.6,214.45 275.55,214.49 275.55,215.13 275.34,215.34 275.34,215.57 C568.2
GPU_EDP_TXN3: length 157.4
  IN4 w0.086: v1(278.79,216.95) 278.5,216.95 278.41,216.86 278.41,216.59 278.13,216.3 278.13,215.07 277.76,214.7 277.33,214.7 277.11,214.47 277.11,213.87 277.3,213.67 277.53,213.67 277.72,213.49 277.72,211.63 280.02,209.33 280.02,205.8 281.08,204.75 281.08,201.14 281.4,200.81 281.4,196.93 281.11,196.64 281.11,153.69 279.94,152.52 279.94,139.91 280.32,139.53 280.32,118.27 275.21,113.17 262.18,113.17 261.83,112.82 253.75,112.82 252.06,114.5 252.06,116.54 249.62,118.97 248.14,118.97 246.65,120.46 246.65,121.32 246.25,121.72 246.25,123.87 246.71,124.33 247.65,124.33 247.99,124.66 248.67,124.66 248.87,124.86 248.87,125.02 248.74,125.15 v1(248.6,125.15)
  BOTTOM w0.102: v1(248.6,125.15) 248.76,125.15 248.86,125.05 248.86,124.85 248.74,124.73 248.45,124.73 247.97,125.21 247.11,125.21 246.81,124.91 246.39,124.91 245.49,125.8 245.49,126.35 245.96,126.82 245.96,127.22 246.06,127.32 UG6.BT16
  BOTTOM w0.14: v1(278.79,216.95) 278.59,216.95 278.39,216.74 278.39,216.28 C566.1
GPU_EDP_TXN3_R: length 4
  BOTTOM w0.14: C566.2 278.3,215.67 278.3,213.21 278,212.91 277.46,212.91 277.43,212.89 U36.17
GPU_EDP_TXP0: length 159.9
  IN4 w0.086: v1(249.01,124.05) 248.84,124.05 248.7,123.9 248.7,123.58 249.11,123.18 249.92,123.18 251.63,121.47 251.63,119.56 252.29,118.9 252.8,118.9 253.11,118.58 253.11,118.08 253.9,117.3 253.9,116.21 254.94,115.16 261.06,115.16 261.22,115 274.45,115 278.48,119.03 278.48,138.01 276.98,139.51 276.98,144.85 277.16,145.03 277.27,145.03 277.38,145.14 277.38,145.44 277.3,145.53 277.16,145.53 276.98,145.71 276.98,147.83 277.16,148.01 277.7,148.01 277.79,148.1 277.79,148.52 277.7,148.61 277.16,148.61 276.98,148.79 276.98,152.62 279.26,154.89 279.26,185.8 279.17,185.89 278.6,185.89 278.39,186.1 278.39,186.63 278.57,186.81 279.17,186.81 279.26,186.9 279.26,187.32 279.17,187.41 276.68,187.41 276.49,187.59 276.49,188.15 276.68,188.33 279.17,188.33 279.26,188.42 279.26,188.99 279.17,189.08 277.49,189.08 277.31,189.26 277.31,193.85 276.81,194.35 276.81,200.36 276.59,200.58 276.59,206.04 275.17,207.46 274.77,207.46 273.65,208.58 273.14,208.58 272.96,208.77 272.96,209.43 272.69,209.69 271.97,209.69 270.44,211.22 270.44,211.39 270.19,211.65 269.27,211.65 269.02,211.4 v1(269.02,211.29)
  BOTTOM w0.102: v1(249.01,124.05) 248.93,124.05 248.77,123.88 248.77,123.49 248.92,123.34 248.92,122.51 248.77,122.36 248.77,122.1 248.35,121.68 246.36,121.68 244.89,123.15 244.89,123.73 243.66,124.96 243.66,127.11 UG6.BT20
  BOTTOM w0.14: v1(269.02,211.29) 269.29,211.56 269.49,211.56 269.63,211.42 C581.1
GPU_EDP_TXP0_R: length 1.4
  BOTTOM w0.14: C581.2 270.33,211.59 270.59,211.59 270.76,211.75 270.89,211.75 270.96,211.69 U36.35
GPU_EDP_TXP1: length 159.2
  IN4 w0.086: v1(248.03,122.77) 247.89,122.77 247.76,122.64 247.76,122.29 249.33,120.71 249.96,120.71 250.57,120.11 250.57,119.84 253.34,117.07 253.34,115.97 255.21,114.09 261,114.09 261.35,114.44 274.68,114.44 279.04,118.8 279.04,138.28 278.48,138.84 278.48,153.15 279.81,154.48 279.81,190.53 279.73,190.61 278.99,190.61 278.81,190.79 278.81,191.35 278.99,191.54 279.73,191.54 279.81,191.62 279.81,192.19 278.78,193.22 278.78,193.55 279.15,193.92 279.15,194.29 279.02,194.41 278.9,194.41 278.68,194.63 278.68,195.12 278.9,195.34 279.02,195.34 279.11,195.42 279.11,196.36 279.02,196.45 278.72,196.45 278.54,196.63 278.54,197.19 278.72,197.38 279.02,197.38 279.11,197.46 279.11,198.48 279.02,198.57 278.52,198.57 278.34,198.75 278.34,199.28 278.52,199.46 278.75,199.46 278.83,199.55 278.83,199.97 278.75,200.05 278.13,200.05 277.95,200.24 277.95,207.08 278.2,207.34 278.2,208.24 277.89,208.55 275.81,208.55 275.62,208.73 275.62,210.05 274.98,210.7 274.45,210.7 274.27,210.88 273.5,210.88 273.35,210.73 272.64,210.73 272.29,211.08 272.29,211.47 272.12,211.64 272,211.64 271.68,211.95 271.68,213.39 272.05,213.75 272.11,213.75 272.2,213.84 272.2,214.37 272.11,214.46 271.72,214.46 271.25,214.94 271.25,215.9 271.16,215.99 270.97,215.99 270.73,216.22 270.73,216.57 270.62,216.68 270.37,216.68 v1(270.28,216.59)
  BOTTOM w0.102: UG6.BR19 244.27,127.9 244.27,127.71 244.51,127.47 244.51,127.08 244.12,126.69 244.12,125.31 245.49,123.95 245.49,123.41 246.77,122.14 247.54,122.14 247.76,122.36 247.76,122.63 247.9,122.77 v1(248.03,122.77)
  BOTTOM w0.14: v1(270.28,216.59) 270.49,216.38 270.49,216.05 C573.1
GPU_EDP_TXP1_R: length 2.2
  BOTTOM w0.14: U36.1 271.6,214.44 271.52,214.52 270.82,214.52 270.53,214.81 270.53,215.05 C573.2
GPU_EDP_TXP2: length 159.4
  IN4 w0.086: v1(274.67,216.75) 274.7,216.75 275.13,216.32 275.13,215.46 275.34,215.24 275.34,214.81 275.82,214.33 275.82,213.81 276.09,213.53 276.33,213.53 276.51,213.35 276.51,212.02 276.3,211.8 276.15,211.8 275.97,211.62 275.97,210.9 276.17,210.71 276.62,210.71 277.58,209.74 278.34,209.74 278.59,209.49 278.59,208.75 278.9,208.44 278.9,207.1 278.68,206.88 278.68,205.17 278.86,204.99 279.82,204.99 280.36,204.45 280.36,202.92 280.27,202.83 279.92,202.83 279.73,202.65 279.73,202.09 279.92,201.91 280.26,201.91 280.36,201.8 280.36,201.4 280.27,201.31 279.61,201.31 279.43,201.13 279.43,200.59 279.64,200.39 280.59,200.39 280.68,200.3 280.68,199.76 280.59,199.67 279.85,199.67 279.67,199.49 279.67,199.16 279.92,198.9 279.92,198.71 279.67,198.45 279.67,198.09 279.85,197.9 280.44,197.9 280.53,197.82 280.53,197.42 280.42,197.31 279.85,197.31 279.67,197.13 279.67,196.09 279.85,195.91 280.3,195.91 280.39,195.82 280.39,154.09 279.19,152.89 279.19,139.43 279.6,139.02 279.6,118.57 274.92,113.89 261.88,113.89 261.53,113.54 254.36,113.54 252.78,115.11 252.78,116.84 249.92,119.7 249.29,119.7 246.97,122.02 246.97,122.91 247.43,123.37 247.43,123.49 v1(247.65,123.71)
  BOTTOM w0.102: v1(247.65,123.71) 247.46,123.51 247.46,123.4 247.14,123.08 246.68,123.08 246.19,123.57 246.19,124.04 244.63,125.6 244.63,126.51 245.01,126.88 245.01,127.63 245.15,127.78 245.15,128 245.15,128 245.15,128.06 245.55,128.45 UG6.BP17
  BOTTOM w0.14: C567.1 275.03,216.42 275.03,216.59 274.86,216.75 v1(274.67,216.75)
GPU_EDP_TXP2_R: length 1.9
  BOTTOM w0.14: U36.10 275.2,214.44 275.29,214.53 275.29,215.02 275.07,215.23 275.07,215.57 C567.2
GPU_EDP_TXP3: length 157.4
  IN4 w0.086: v1(277.94,216.95) 278.09,216.95 278.25,216.79 278.25,216.65 277.97,216.37 277.97,215.14 277.69,214.86 277.26,214.86 276.94,214.54 276.94,213.8 277.23,213.51 277.46,213.51 277.55,213.42 277.55,211.57 279.86,209.26 279.86,205.74 280.91,204.68 280.91,201.07 281.24,200.75 281.24,197 280.95,196.71 280.95,153.76 279.78,152.59 279.78,139.84 280.15,139.46 280.15,118.34 275.15,113.33 262.11,113.33 261.76,112.98 253.82,112.98 252.23,114.57 252.23,116.6 249.69,119.14 248.21,119.14 246.82,120.53 246.82,121.39 246.42,121.79 246.42,123.8 246.78,124.16 247.72,124.16 248.06,124.5 248.74,124.5 249.04,124.79 249.04,125.07 249.12,125.15 v1(249.33,125.15)
  BOTTOM w0.102: UG6.BT17 245.7,127.32 245.76,127.26 245.76,126.9 245.29,126.44 245.29,125.72 246.3,124.71 246.9,124.71 247.2,125.01 247.88,125.01 248.36,124.52 248.82,124.52 249.07,124.77 249.07,125 249.22,125.15 v1(249.33,125.15)
  BOTTOM w0.14: v1(277.94,216.95) 278.12,216.76 278.12,216.54 277.83,216.25 C565.1
GPU_EDP_TXP3_R: length 4
  BOTTOM w0.14: U36.16 277.4,213.29 277.51,213.18 277.89,213.18 278.03,213.32 278.03,215.86 277.98,215.92 277.78,215.92 277.71,215.85 C565.2
GPU_EVENT#: length 13.5
  BOTTOM w0.102: 198.31,54.29 198.31,54.8 199,55.49 200.96,55.49 201.57,54.88 203,54.88 203.53,55.41 204.68,55.41 204.83,55.56 204.83,57.33 205.22,57.72 205.85,57.72 206.16,57.4 U49.L45
  BOTTOM w0.14: 198.31,54.29 198.31,53.4 TP162.1
GPU_THERMDA: length 139.2
  TOP w0.14: v1(175.14,200.93) 175.5,201.3 175.5,201.83 175.76,202.08 175.76,203.81 176.82,204.87 177.15,204.87 177.29,205.01 Q11.2 178.24,204.74 Q11.3
  IN1 w0.086: v1(210.65,190.91) 210.35,190.61 210.35,190.36 210.17,190.17 209.63,190.17 208.65,191.15 208.65,191.7 208.4,191.95 198.8,191.95 197.89,191.05 192.81,191.05 187.81,196.05 182.45,196.05 182.07,196.43 179.98,196.43 177.36,199.05 176.48,199.05 175.28,200.26 175.28,200.61 175.34,200.67 175.34,200.72 v1(175.14,200.93)
  IN2 w0.089: v1(259.62,211.57) 259.87,211.31 259.87,210.63 260.46,210.05 261.09,210.05 263.61,207.53 263.83,207.53 265.88,205.48 265.88,203.24 265.37,202.73 265.37,201.28 265.92,200.73 265.92,190.56 265,189.64 230.6,189.64 229.96,189.01 222.9,189.01 222.42,188.52 221.43,188.52 220.39,189.56 210.68,189.56 210.35,189.89 210.35,190.61 v1(210.65,190.91)
  BOTTOM w0.14: v1(259.62,211.57) 259.84,211.78 259.84,211.94 259.69,212.09 259.69,213.05 C578.1 259.68,213.23 259.68,214.02 259.34,214.36 259.34,215.83 259.63,216.12 259.94,216.12 260.13,216.32 U35.2
GPU_THERMDC: length 136
  TOP w0.14: Q11.1 177.29,204.46 177.15,204.6 176.93,204.6 176.03,203.7 176.03,201.97 175.77,201.72 175.77,200.65 v1(175.8,200.62)
  IN1 w0.086: v1(209.86,190.91) 210.19,190.58 210.19,190.43 210.1,190.34 209.69,190.34 208.81,191.22 208.81,191.77 208.47,192.12 198.73,192.12 197.83,191.21 192.88,191.21 187.88,196.22 182.52,196.22 182.14,196.6 180.04,196.6 177.43,199.22 176.55,199.22 175.44,200.32 175.44,200.54 175.53,200.62 v1(175.8,200.62)
  IN2 w0.089: v1(209.86,190.91) 210.16,190.61 210.16,189.81 210.6,189.37 220.31,189.37 221.35,188.33 222.5,188.33 222.98,188.82 230.04,188.82 230.67,189.45 265.08,189.45 266.11,190.48 266.11,200.81 265.56,201.36 265.56,202.65 266.07,203.16 266.07,205.56 263.91,207.72 263.69,207.72 261.17,210.24 260.54,210.24 260.07,210.71 260.07,211.32 260.28,211.54 v1(260.28,211.54)
  BOTTOM w0.14: U35.3 260.15,215.66 259.96,215.86 259.74,215.86 259.6,215.72 259.6,214.47 259.95,214.13 259.95,213.24 C578.2 259.95,213.05 259.95,212.2 260.1,212.05 260.1,211.72 v1(260.28,211.54)
GPU_THROTTING#: length 307.5
  IN2 w0.089: v1(198.22,68.87) 197.89,68.87 197.56,69.2 194.16,69.2 v1(192.08,71.28)
  IN3 w0.089: v1(192.08,71.28) 192.18,71.18 192.19,71.18 192.47,70.89 192.47,64.41 193.32,63.56 193.32,62.83 192.63,62.14 188.7,62.14 188.17,62.67 188.17,63.49 185.6,66.05 185.03,66.05 183.9,67.18 179.51,67.18 177.44,69.25 165.46,69.25 165.12,69.59 159.64,69.59 158.58,68.54 155.1,68.54 154.08,69.57 140.94,69.57 139.92,68.55 134.32,68.55 133.08,67.31 131.51,67.31 130.15,65.95 124.75,65.95 123.37,64.57 110.8,64.57 109.5,63.27 94.51,63.27 94.14,63.64 67.53,63.64 63.99,60.11 63.2,60.11 62.61,59.52 61.65,59.52 58.83,56.7 v1(58.83,55.89) ; v1(263.79,118.83) 263.32,118.83 260.8,116.32 260.8,115.29 260.56,115.05 256.34,115.05 255.77,114.48 248.14,114.48 247.72,114.05 246.82,114.05 246.28,114.59 246.28,115.06 245.93,115.41 244.68,115.41 243.82,114.55 240.6,114.55 240.31,114.26 212.41,114.26 208.52,110.37 208.52,105.77 207.53,104.78 207.53,101.26 202.96,96.69 202.44,96.69 199.23,93.48 199.23,87.44 198.31,86.51 198.31,80.69 198.2,80.58 198.2,76.83 198,76.62 198,69.1 v1(198.22,68.87)
  BOTTOM w0.14: v1(58.83,55.89) 58.57,56.16 48.69,56.16 45.47,52.94 43.39,52.94 41.9,51.44 39.76,51.44 36.3,47.98 36.3,47.61 33.47,44.78 30.33,44.78 30.08,44.54 PR648.1 ; DG2.1 262.89,115.85 263.74,116.7 263.74,118.23 263.79,118.27 v1(263.79,118.83) 263.7,118.83 263.6,118.73 RG168.1
GPU_TSENSE: length 88.4
  TOP w0.14: PR206.1 v1(266.45,77.18) ; v1(228.35,86.36) 228.8,86.81 237.64,86.81 v1(238.13,86.32) 238.71,86.91 247.2,86.91 v1(247.91,86.2) 250.17,86.2 250.93,86.96 257.03,86.96 v1(257.69,86.3) 258.24,86.86 266.78,86.86 v1(267.47,86.17) 267.64,86.35 274.6,86.35 275.01,85.94 276.69,85.94 v1(277.24,86.49) 278.35,87.59 285.47,87.59 v1(286.59,86.47)
  IN2 w0.089: v1(228.35,86.36) 227.77,85.79 226.06,85.79 225.48,86.37 v1(218.86,86.37) ; v1(266.45,77.18) 265.92,77.18 264.52,78.57 264.52,80.89 267.47,83.83 v1(267.47,86.17)
  BOTTOM w0.14: v1(286.59,86.47) 286.59,86.57 287.01,86.99 PR577.1 ; v1(228.35,86.36) PR586.2 ; PR596.2 v1(247.91,86.2) ; v1(238.13,86.32) PR591.2 ; PR574.1 v1(277.24,86.49) ; PR606.2 v1(267.47,86.17) ; PR601.2 v1(257.69,86.3) ; PR581.2 218.57,86.67 v1(218.86,86.37)
GPUT_CLK: length 118.2
  TOP w0.14: QG11.3 261.8,115.73 v1(262,115.92) ; v1(177.42,78.45) 177.42,77.68 177.06,77.32 177.06,76.61 176.79,76.34 R357.2
  IN2 w0.089: v1(177.42,78.45) 177.47,78.4 183.25,78.4 184.2,77.46 195.95,77.46 198.31,79.82 v1(199.33,79.82)
  IN3 w0.089: v1(262,115.92) 262,115.4 262.09,115.3 262.09,114.12 261.26,113.28 248.64,113.28 248.21,112.86 240.93,112.86 240.73,113.07 213.08,113.07 210.72,110.7 210.72,110.24 210.49,110.01 210.49,108.72 210.77,108.44 210.77,107.37 210.17,106.77 210.17,104.97 209.62,104.42 209.62,102.53 208.72,101.63 208.72,100.76 203.45,95.5 202.94,95.5 200.43,92.99 200.43,86.94 199.5,86.02 199.5,80 v1(199.33,79.82)
GPUT_DATA: length 124.6
  TOP w0.14: v1(263.81,115.97) 263.81,114.96 v1(263.62,114.77) 262.81,113.95 QG11.6 ; v1(176.66,78.45) 176.66,76.88 176.3,76.52 176.3,75.77 R356.2
  IN2 w0.089: v1(176.66,78.45) 177.17,77.93 183.06,77.93 184,76.99 199.41,76.99 v1(199.54,76.85)
  IN3 w0.089: v1(263.81,115.97) 263.81,115.17 261.45,112.81 248.83,112.81 248.38,112.36 240.76,112.36 240.53,112.6 213.28,112.6 211.19,110.51 211.19,110.04 210.96,109.81 210.96,108.92 211.24,108.64 211.24,107.17 210.64,106.57 210.64,104.77 210.09,104.23 210.09,102.34 209.19,101.43 209.19,100.57 203.65,95.03 203.13,95.03 200.9,92.8 200.9,86.75 199.97,85.82 199.97,81.18 200.86,80.3 200.86,78.94 199.54,77.62 v1(199.54,76.85)
H_CPU_SVIDALRT#: length 11.5
  IN1 w0.086: v1(179.56,155.16) 178.57,154.16 178.57,152.23 176.4,150.06 175.49,150.06 174.43,148.99 v2(174.43,148.94)
  BOTTOM w0.102: v2(174.43,148.94) 174.41,148.94 174.03,148.57 174.03,148.31 173.84,148.12 173.39,148.12 U42.F32
  BOTTOM w0.14: R790.1 179.59,155.19 v1(179.56,155.16)
H_CPU_SVIDDAT: length 10.4
  IN1 w0.086: v2(174.99,148.95) 175.07,148.95 175.71,149.59 176.6,149.59 181.13,154.12 v1(181.13,154.3)
  BOTTOM w0.102: U42.D32 174.49,148.45 v2(174.99,148.95)
  BOTTOM w0.14: R793.2 v1(181.13,154.3) R792.1
H_PM_DOWN: length 162.2
  IN2 w0.089: v1(121.07,143.19) 120.66,142.79 120.66,140.56 114.47,134.37 113.2,134.37 112.77,133.94 112.77,126.87 111.74,125.83 111.74,124.18 112.53,123.39 123.37,123.39 125.58,121.17 179.31,121.17 194.08,106.4 196.63,106.4 197.55,105.48 197.55,104.2 198.24,103.5 198.64,103.5 199.75,102.39 200.77,102.39 201.32,101.84 201.32,99.91 201.65,99.58 201.65,95.26 203.61,93.3 203.61,89.72 203.67,89.65 203.67,88.5 206.33,85.85 206.99,85.85 207.32,85.52 211.49,85.52 212.61,86.64 212.99,86.64 v1(213.06,86.7)
  BOTTOM w0.102: 214.74,82.45 214.74,81.85 214.9,81.69 214.9,79.07 214.77,78.95 U49.AH2
  BOTTOM w0.14: TP132.1 214.17,87.6 214.17,87.11 213.98,86.92 R869.2 ; v1(213.06,86.7) 213.24,86.7 213.44,86.5 R869.2 ; R869.2 213.98,86.02 213.95,86 213.95,85.48 214.23,85.21 214.44,85.21 214.58,85.07 214.58,83.84 214.77,83.65 214.77,83.07 214.74,83.04 214.74,82.45 ; R805.1 123.24,141.37 121.41,143.19 121.07,143.19 v1(121.07,143.19)
H_PM_DOWN_R: length 6.4
  BOTTOM w0.102: 126.5,142.69 127.71,142.69 127.91,142.89 128.27,142.89 128.45,143.07 128.45,143.5 U42.CR24
  BOTTOM w0.14: R805.2 124.02,141.35 125.39,142.72 125.95,142.72 125.98,142.69 126.5,142.69
H_PROCHOT#: length 637
  TOP w0.14: Q48.1 232.17,65.23 232.31,65.09 232.31,61.1 230.95,59.73 230.95,56.9 231.29,56.55 234.19,56.55 234.41,56.33 234.41,52.45 235.15,51.71 235.15,49.59 233.38,47.82 219.87,47.82 218.86,46.8 216.28,46.8 210.94,41.47 210.19,41.47 209.86,41.8 209.86,41.87 v1(209.83,41.9) ; v1(113.67,126.86) 112.86,126.86 109.36,123.36 109.36,117.17 110.66,115.88 110.66,113.54 111.17,113.02 111.17,104.53 110.25,103.61 110.25,97.72 108.74,96.2 108.74,84.21 107.81,83.29 107.81,76.5 107.34,76.02 107.34,73.37 106.86,72.9 106.86,70.99 107.34,70.52 107.34,68.88 109.1,67.12 109.1,65.12 108.83,64.86 108.83,62.68 v1(108.37,62.21) ; C40.1 R89.1 R90.1 184.61,162.04 185.4,162.04 185.73,161.71 v1(185.73,160.74) ; Q46.3 154.63,67.54 v1(154.21,67.96) ; PR331.1 30.48,41.93 31.03,41.37 v1(32.62,41.37)
  IN1 w0.086: v1(209.83,41.9) 209.02,41.09 200.81,41.09 200.19,41.71 196.32,41.71 195.86,42.18 194.43,42.18 v1(193.67,41.42)
  IN2 w0.089: v1(193.67,41.42) 191.38,41.42 187.22,45.58 184.49,45.58 181.27,48.79 181.27,50.46 177.32,54.41 174.2,54.41 173.21,55.4 171.58,55.4 169.87,57.12 166.38,57.12 165.31,58.19 164.82,58.19 163.09,59.93 161.19,59.93 158.14,62.97 158.14,63.13 157.82,63.46 150.68,63.46 149.29,62.07 v1(148.17,62.07) 145.11,62.07 144.84,61.79 133.1,61.79 132.44,61.13 123.64,61.13 122.35,59.84 119.56,59.84 118.42,58.7 113.39,58.7 110.96,56.28 109.2,56.28 108.98,56.5 104.58,56.5 100.68,52.6 93.65,52.6 89.21,48.16 62.25,48.16 59.1,51.31 48.04,51.31 47.44,50.71 43.08,50.71 42.49,50.12 42.49,49.58 41.55,48.63 41.55,48.35 41.18,47.98 40.22,47.98 39.11,46.88 38.25,46.88 37.42,46.05 35.29,46.05 33.6,44.36 33.6,42.5 32.62,41.52 v1(32.62,41.37)
  IN3 w0.089: v1(108.37,62.21) 110.05,62.21 110.32,62.47 111.04,62.47 111.54,62.97 118.77,62.97 119.39,63.59 123.77,63.59 124.89,64.7 130.28,64.7 131.91,66.33 133.49,66.33 134.04,66.89 140.9,66.89 141.6,66.18 146.09,66.18 148.49,68.59 153.59,68.59 v1(154.21,67.96) ; v1(113.67,126.86) 114.08,126.86 115.6,128.39 115.6,136.33 115.09,136.84 115.09,137.25 117.9,140.06 117.9,143.94 119.27,145.32 119.27,172.46 115.94,175.79 111.58,175.79 110.3,177.07 110.3,195.02 112.98,197.7 112.98,209.37 113.12,209.51 113.57,209.51 113.95,209.13 114.54,209.13 115.66,210.25 115.66,212.76 116.96,214.06 120.84,214.06 121.44,214.66 121.44,215.25 121.18,215.51 120.75,215.51 120.31,215.08 v2(120.29,215.08) ; v1(156.68,75.8) 156.68,75.83 157.04,76.2 159.76,76.2 161.24,74.72 164.55,74.72 167.6,77.77 172.73,77.77 172.85,77.89 172.85,78.47 173.6,79.22 178.16,79.22 178.56,78.81 183.55,78.81 184.62,77.74 186.01,77.74 186.39,77.36 188.24,77.36 189.34,78.46 189.34,79.81 189.39,79.86 189.39,79.86 190.78,81.25 190.78,96.41 191.79,97.43 191.79,102.68 190.08,104.39 188.16,104.39 186.26,106.28 186.26,154.79 185.97,155.09 185.73,155.33 v1(185.73,160.74)
  BOTTOM w0.14: PR360.1 120.27,215.07 120.29,215.05 ; v1(156.68,75.8) 155.4,75.8 154.81,75.21 154.81,70.43 156.91,68.33 156.91,67.62 156.53,67.24 154.93,67.24 v1(154.21,67.96) 151.82,67.96 150.98,67.12 150.98,63.03 149.79,61.84 148.4,61.84 v1(148.17,62.07) ; 120.29,215.05 v2(120.29,215.08) ; 120.29,215.05 120.66,214.68 PR373.1
H_PROCHOT#_R: length 23.2
  TOP w0.102: 171.38,152.69 171.07,152.39 171.07,151.6 170.79,151.32 170.79,150.78 v2(171.18,150.39)
  TOP w0.14: 171.38,152.69 171.38,158.49 174.43,161.55 183.21,161.55 R90.2
  BOTTOM w0.102: U42.H35 171.57,150.06 171.24,150.39 v2(171.18,150.39)
H_PWRGD: length 178.6
  IN1 w0.086: v1(113.76,121.96) 116.44,124.64 116.44,136 122.59,142.15 122.59,144.32 123.18,144.92 v1(123.18,145.33)
  IN2 w0.089: v1(113.76,121.96) 113.71,121.91 113.71,121.16 112.95,120.4 112.95,113.91 115.54,111.32 115.54,102.87 116.43,101.98 116.43,97.24 118.84,94.84 118.84,84.21 121.13,81.92 127.43,81.92 129.35,80 129.35,78.98 129.85,78.48 130.55,78.48 131.24,79.17 136.68,79.17 139.14,76.71 142.95,76.71 143.1,76.87 144.89,76.87 145.05,76.71 148.56,76.71 149.86,78.01 150.66,78.01 151.93,79.28 169.26,79.28 169.9,78.63 170.43,78.63 171.45,79.65 187.98,79.65 188.39,79.25 195.42,79.25 198.05,81.88 199.73,81.88 200.21,81.4 201,81.4 201.49,81.89 202.58,81.89 204.2,83.51 v1(204.2,83.84)
  BOTTOM w0.102: U42.CT25 127.81,144.16 126.83,144.16 126.72,144.26 ; U49.AC3 211.35,79.62 211.05,79.62 210.67,80 210.67,80.3 208.74,82.23 208.74,82.51 208.41,82.84
  BOTTOM w0.14: 126.72,144.26 126.13,144.85 123.66,144.85 v1(123.18,145.33) ; v1(204.2,83.84) 204.3,83.94 TP141.1 205.37,84.29 206.96,84.29 208.41,82.84
H_VCCST_PWRGD: length 8.8
  TOP w0.14: v1(124.92,143.76) 125.57,144.41 v1(129.54,144.41) v2(130.44,144.41)
  BOTTOM w0.125: v2(130.44,144.41) 130.01,144.41 U42.CP24
  BOTTOM w0.14: R803.1 123.69,142.9 123.83,143.04 124.49,143.04 124.92,143.48 v1(124.92,143.76)
H_VCCST_PWRGD_R: length 2.4
  BOTTOM w0.14: R803.2 R802.1 122.75,143.64 v1(122.5,143.89) Q96.6
HDMI_HPD: length 33.8
  TOP w0.14: CN23.19 13.38,39.54 13.38,41.26 C546.1 14.21,41.62 14.38,41.46 14.84,41.46 RV1.1 14.99,41.36 18.72,41.36 19.2,41.84 20.26,41.84 21.6,43.17 21.61,43.17 22.01,43.57 22.01,44.21 23.37,45.58 23.37,46.21 v1(28.73,51.57) 29.25,52.08 30.36,52.08 30.62,52.35 30.98,52.35 31.46,52.82 31.46,53.93 31.23,54.16 31.23,54.64 31.38,54.8 R608.1 32.13,54.8 R590.2 32.42,55.38 Q52.3
HDMI_HPD_GPU: length 309.6
  TOP w0.14: RG55.2 CG360.1 277.48,131.07 v1(277.8,131.07) ; v1(34.43,58.28) 34.16,58.28 R563.1
  IN1 w0.086: v1(34.43,58.28) 34.59,58.44 34.84,58.44 35.21,58.07 46.12,58.07 50.03,61.98 60.98,61.98 61.99,62.99 64.53,62.99 65.13,63.59 84.33,63.59 85.06,64.31 109.62,64.31 110.46,65.15 123.24,65.15 123.4,64.99 141.74,64.99 142.32,65.57 146.21,65.57 147.38,66.74 150.01,66.74 151.28,68.01 153.61,68.01 154.3,67.31 159.72,67.31 160.07,67.65 161.25,67.65 161.44,67.85 163.34,67.85 163.87,67.31 164.84,67.31 165.95,68.42 171.42,68.42 171.87,67.97 174.2,67.97 174.95,68.72 178.26,68.72 179.05,69.51 v1(179.08,69.51)
  IN2 w0.089: v1(179.08,69.51) 179.31,69.28 181.53,69.28 181.97,68.84 184.66,68.84 184.94,68.56 186,68.56 187.63,66.93 188.37,66.93 189.08,66.22 190.51,66.22 190.78,65.95 192.33,65.95 193.38,64.9 196.2,64.9 v1(196.24,64.86)
  IN3 w0.089: v1(196.24,64.86) 196.2,64.9 196.2,66.19 195.81,66.59 195.81,77.53 195.96,77.68 195.96,87.4 196.98,88.41 196.98,98.3 197.55,98.87 199.47,98.87 199.72,98.62 200.31,98.62 201.09,99.4 201.09,101.83 203.65,104.38 203.84,104.38 206.33,106.87 206.33,111.28 211.6,116.55 216.14,116.55 217.25,117.67 225.21,117.67 226.14,118.59 232.78,118.59 233.55,117.83 240.01,117.83 240.29,118.1 241.42,118.1 242.19,117.33 244.52,117.33 244.76,117.57 246.84,117.57 247.24,117.97 249.76,117.97 250.73,117.01 253.91,117.01 254.74,117.84 256.76,117.84 256.9,117.97 258.77,117.97 260.16,119.37 260.16,121.87 260.95,122.66 260.95,123.35 262.05,124.44 264.12,124.44 265.1,123.47 267.71,123.47 275.31,131.07 v1(277.8,131.07)
HDMI_HPD_PCH: length 216.6
  TOP w0.14: v1(34.42,58.97) 34.09,58.97 R556.1 ; 214.68,84.9 214.42,85.17 v1(214.42,85.69) ; 214.68,84.9 215.36,84.9 Q30.3 ; 214.68,84.9 214.38,84.6 214.38,83.22 213.9,82.75 213.9,82.03 214.13,81.8 215.21,81.8 215.3,81.7 R1191.1
  IN1 w0.086: v1(179.05,70.16) 179.05,70.08 178.08,69.11 174.79,69.11 174.04,68.37 172.03,68.37 171.58,68.81 165.78,68.81 164.67,67.7 164.04,67.7 163.5,68.24 161.28,68.24 161.08,68.05 159.9,68.05 159.56,67.7 155.35,67.7 154.62,68.43 151.15,68.43 149.85,67.13 147.22,67.13 146.05,65.96 142.16,65.96 141.58,65.38 123.56,65.38 123.4,65.54 110.3,65.54 109.46,64.7 84.9,64.7 84.17,63.98 64.96,63.98 64.37,63.39 61.83,63.39 60.81,62.37 49.87,62.37 45.96,58.46 35.38,58.46 35.01,58.83 34.56,58.83 v1(34.42,58.97)
  IN2 w0.089: v1(179.05,70.16) 179.07,70.14 179.79,70.14 180.25,69.68 181.69,69.68 182.14,69.23 184.82,69.23 185.11,68.95 186.17,68.95 187.8,67.32 188.81,67.32 188.99,67.13 191.71,67.13 192.89,65.95 195.83,65.95 197.59,64.19 199.74,64.19 v1(199.98,63.94)
  IN3 w0.089: v1(199.98,63.94) 200.69,64.65 200.74,64.65 202.44,66.35 202.44,69.43 204.54,71.53 204.54,72.25 205.23,72.94 205.23,74.87 205.23,74.87 205.23,76.17 204.83,76.57 204.83,77.15 206.76,79.09 206.76,81.49 205.88,82.37 205.88,85.24 206.51,85.87 207.26,85.87 207.42,85.71 211.64,85.71 212.17,85.18 213.91,85.18 v1(214.42,85.69)
HDMI_HPD_Q: length 10.4
  TOP w0.14: R1191.2 215.75,81.8 215.96,82.01 215.96,82.36 216.2,82.6 Q30.1 217.09,82.12 217.83,82.12 R264.2 217.74,81.83 217.51,81.83 217.15,81.47 v1(217.15,81.05) 217.15,80.68 217.39,80.44 217.39,79.3 218.16,78.53 218.42,78.53 219.03,77.92 219.03,77.58 v1(219.52,77.09)
  BOTTOM w0.102: v1(219.52,77.09) 219.52,77.1 219.54,77.12 219.54,77.57 U49.AU5
HDMI_SCLK: length 17.2
  IN4 w0.086: v1(17.21,29.9) 16.65,29.9 16.46,30.09 16.46,30.4 18.41,32.36 18.41,33.14 17.84,33.71 v1(17.25,33.71)
  BOTTOM w0.14: v1(17.25,33.71) 16.98,33.98 R1175.2 15.33,33.98 14.73,34.58 14.73,36.07 13.16,37.64 12.57,37.64 12.14,37.22 12.14,36.3 CN23.15 ; R1177.2 17.53,29.9 v1(17.21,29.9) 17.16,29.94 RV3.1
HDMI_SDATA: length 17.8
  IN4 w0.086: v1(17.2,29.24) 17.2,29.42 17.12,29.51 16.48,29.51 16.06,29.93 16.06,30.57 18.02,32.52 18.02,32.98 17.68,33.32 17.34,33.32 17.26,33.23 v1(17.26,33.04)
  BOTTOM w0.14: CN23.16 12.89,36.15 13.31,36.56 13.61,36.56 14.28,35.89 14.28,35.61 14.09,35.42 13.65,35.42 13.49,35.26 13.49,35.01 13.64,34.86 14.11,34.86 14.28,34.69 14.28,34.35 14.14,34.21 13.76,34.21 13.6,34.06 13.6,33.75 13.82,33.53 15.85,33.53 16.03,33.36 R1176.2 16.34,33.36 16.54,33.56 16.74,33.56 v1(17.26,33.04) ; R1178.2 17.33,29.36 v1(17.2,29.24) 16.86,29.24 RV4.1
HP-L2: length 3.1
  TOP w0.203: U20.27 316.21,65.03
  TOP w0.381: 316.21,65.03 316.47,65.03 317.1,64.4 v1(317.25,64.4)
  BOTTOM w0.305: v1(317.25,64.4) 317.25,64.5 316.84,64.91 CN10.44
HP-R2: length 5.4
  TOP w0.203: U20.26 316.07,64.63 316.27,64.43
  TOP w0.381: v1(318.19,64.2) 317.85,63.86 316.85,63.86 316.27,64.43
  BOTTOM w0.305: CN10.43 316.98,65.41 v1(318.19,64.2)
HP_JD#: length 35.9
  TOP w0.14: R407.1 307.96,72.83 307.5,73.29 307.5,77.31 308.99,78.81 308.99,79.69 309.54,80.24 v1(310.13,80.24)
  IN4 w0.086: v1(310.13,80.24) 310.32,80.05 313.85,80.05 316.52,77.38 316.52,71.1 317.3,70.32 318.07,70.32 318.4,69.99 318.4,69.43 318.66,69.18 319.21,69.18 319.46,68.93 319.46,65.06 v1(318.85,64.45)
  BOTTOM w0.305: CN10.42 316.82,65.91 316.91,65.82 317.29,65.82 318.65,64.45 v1(318.85,64.45)
HP_JD_C#: length 3.3
  TOP w0.14: U20.48 310.15,69.8 310.01,69.94 309.32,69.94 v1(309.25,70.02) 309.25,70.14 308.76,70.63 R419.1 308.58,70.86 308.18,71.27 R407.2
HWPG: length 169.1
  TOP w0.14: v1(113.34,111.72) 112.76,111.14 112.76,103.84 111.84,102.91 111.84,92.38 112.47,91.75 112.47,90.12 111.34,88.99 111.34,82.96 110.42,82.04 110.42,76.32 110.11,76 110.11,75.06 109.39,74.35 109.39,69.55 111.03,67.92 111.03,65.42 111.34,65.1 111.34,60.17 v1(111.49,60.02) ; v1(151.7,66.93) 151.7,67.46 152.44,68.2 Q45.3 153.9,68.72 155.68,68.72 155.96,69 157.93,69 158.07,69.14 158.07,69.32 158.46,69.71 D36.2 D39.2 D40.2 159.36,66.87 159.64,67.15 R459.1 R472.2 ; D42.2 D41.2 159.95,65.12 159.19,65.87 153.93,65.87 v1(153.33,66.47) ; D42.2 161.02,63.71 161.9,62.83 165.13,62.83 165.35,62.6 R502.2 166.12,62.6 166.82,63.3 U23.21 ; D42.2 D43.2 D44.2
  IN2 w0.089: v1(111.49,60.02) 111.49,60.5 113.2,62.21 122.33,62.21 124.93,64.81 129.82,64.81 130.65,65.63 147.84,65.63 148.09,65.88 150.65,65.88 v1(151.7,66.93)
  BOTTOM w0.14: v1(153.33,66.47) 153.33,66.82 153.08,67.07 151.84,67.07 v1(151.7,66.93) ; v1(113.34,111.72) 115.44,113.82 115.44,136.36 114.7,137.11 U41.1 114.7,141.41 113.88,142.23 113.88,144.81 113.74,144.95 R799.1
HWPG_1.8V: length 5
  TOP w0.14: D36.1 157.27,70.25 156.77,70.75 R414.2 156.77,71.18 156.85,71.26 157.04,71.26 157.55,71.76 v1(157.55,72.23) 157.55,73.47 157.41,73.61 Q39.6
HWPG_1.8VS5: length 352.1
  TOP w0.14: PR56.1 167.36,209.57 v1(167.36,209.57) ; v1(260.3,37.38) 260.3,39.08 262.05,40.83 262.05,45.48 262.51,45.94 265.64,45.94 270.36,50.66 270.36,52.11 269.57,52.9 268.48,52.9 267.52,53.86 267.52,56.55 264.75,59.32 262.37,59.32 261.9,59.79 261.9,60.75 260.95,61.7 PR285.2 PR284.2 ; D41.1 158.67,64.58 158.92,64.32 159.06,64.32 159.3,64.08 v1(159.3,62.92)
  IN1 w0.086: v1(166.04,174.12) 166.04,173.71 169.11,170.64 182.56,170.64 184.64,168.57 v1(185.14,168.57)
  IN2 w0.089: v1(182.85,50.03) 182.56,50.31 182.56,51.44 181.82,52.19 180.03,52.19 177.46,54.75 174.34,54.75 173.33,55.77 171.7,55.77 170.01,57.47 166.53,57.47 165.46,58.54 164.96,58.54 163.23,60.27 161.33,60.27 159.3,62.3 v1(159.3,62.92)
  IN3 w0.089: v1(185.14,168.57) 185.54,168.17 185.54,163.68 187.24,161.98 187.24,152.45 188.12,151.58 188.12,110.12 189.61,108.62 189.61,105.75 192.43,102.94 192.43,96.99 191.97,96.53 191.97,89.84 191.41,89.28 191.41,79.56 187.55,75.7 185.76,75.7 184.64,76.82 183.51,76.82 v1(183.15,77.18) ; v1(166.04,174.12) 166.18,173.98 166.61,173.98 167.85,175.21 167.85,182.44 167.47,182.82 167.47,187.66 167.83,188.01 167.83,192.34 168.65,193.17 168.65,193.7 167.48,194.88 167.48,199.42 165.86,201.04 165.86,203.42 166.75,204.31 166.75,205.05 167.72,206.02 167.72,208.37 167.36,208.73 v1(167.36,209.57)
  IN4 w0.086: v1(260.3,37.38) 259,36.08 245.67,36.08 245.01,36.74 244.33,36.74 244.05,37.02 241.35,37.02 240.97,36.64 240.32,36.64 v1(240.21,36.75) 239.94,37.02 239.37,37.02 239.25,36.9 227.99,36.9 224.65,40.23 221.12,40.23 219.75,38.86 209.73,38.86 208.82,39.77 198.91,39.77 197.87,40.81 194.82,40.81 194.41,41.21 194.41,42.05 192.88,43.59 192.32,43.59 187.35,48.56 185.55,48.56 184.08,50.03 v1(182.85,50.03)
  BOTTOM w0.14: v1(183.15,77.18) 183.15,75.45 180.44,72.74 180.44,68.98 179.6,68.15 179.6,67.35 179.92,67.04 179.92,63.4 181.42,61.91 181.42,58.43 182.37,57.48 182.37,54.61 183.5,53.47 183.5,52.17 182.74,51.4 182.74,50.14 182.85,50.04 v1(182.85,50.03) ; v1(240.21,36.75) 240.21,37.28 240.64,37.71 PR661.1
HWPG_2.5V: length 129.8
  TOP w0.14: D42.1 158.22,63.27 158.22,62.83 157.88,62.49 157.88,61.88 158.28,61.48 158.85,61.48 159.36,60.97 159.36,59.46 v1(159.37,59.45)
  IN2 w0.089: v1(110.73,46.98) 110.73,47.98 113.67,50.92 114.7,50.92 120.86,57.08 122.81,57.08 124.87,59.14 132.18,59.14 132.64,58.68 137.24,58.68 138.37,59.8 143.49,59.8 144.11,59.18 149.29,59.18 150.09,59.98 150.09,60.14 151.07,61.12 152.5,61.12 153.11,60.51 158.43,60.51 159.37,59.57 v1(159.37,59.45) ; v1(166.3,80.06) 166.75,80.51 188.66,80.51 189.9,81.75 191.77,81.75 192.58,80.94 195.76,80.94 200.3,85.47 v1(200.61,85.47)
  IN3 w0.089: v1(166.3,80.06) 166.3,79.45 164.2,77.35 164.2,75.97 163.3,75.07 161.9,75.07 v1(161.61,75.35)
  BOTTOM w0.14: v1(159.37,59.45) 159.37,59.63 160.16,60.42 160.16,63.39 159.19,64.36 159.19,71.8 159.55,72.16 160.98,72.16 161.8,72.98 161.8,75.16 v1(161.61,75.35) ; PR639.1 v1(110.73,46.98) ; PR571.1 199.68,87.21 PR609.2 200.31,85.71 200.55,85.47 v1(200.61,85.47)
HWPG_VDDR: length 57.5
  TOP w0.14: D44.1 158.67,60.02 158.74,59.95 v1(158.74,59.64)
  IN2 w0.089: v1(112.12,48.21) 112.12,48.95 113.79,50.62 114.94,50.62 121.02,56.71 123.78,56.71 125.92,58.85 132.06,58.85 132.52,58.38 137.36,58.38 138.49,59.51 141.29,59.51 142.59,58.21 148.91,58.21 150.38,59.69 150.38,60.02 151.19,60.83 152.38,60.83 152.99,60.22 158.15,60.22 v1(158.74,59.64)
  BOTTOM w0.14: v1(112.12,48.21) 112.3,48.21 112.69,47.82 PR630.2 112.83,48.05 113.28,48.5 PR628.2
I2C_EN_DP: length 3.1
  TOP w0.14: R660.2 22.51,26.1 v1(22.66,26.25) 22.28,26.63 R657.2
  BOTTOM w0.14: v1(22.66,26.25) 22.42,26.01 U56.17
I2C_TP_SCL_C: length 7
  TOP w0.14: R639.2 201.58,43.47 200.91,44.15 200.91,44.35 v1(200.76,44.49) 200.63,44.36 R638.1 200.63,42.52 200.93,42.23 200.93,42.03 200.79,41.89 Q62.4
  BOTTOM w0.14: CN17.6 200.25,45 v1(200.76,44.49)
I2C_TP_SDA_C: length 10.7
  TOP w0.14: R647.2 200.76,39.21 200.9,39.07 201.19,39.07 201.33,39.21 R648.1 201.33,40.18 201.73,40.59 Q62.1 203.27,40.59 203.75,41.06 203.75,42.4 202.72,43.42 202.41,43.42 201.45,44.38 201.45,44.48 v1(201.43,44.5)
  BOTTOM w0.14: CN17.5 201.25,44.68 v1(201.43,44.5)
I2CB_SCL_G: length 25.9
  TOP w0.14: v1(257.93,117.08) 257.93,116.3 258.38,115.85 258.38,115.44 257.79,114.84 257.79,113.97 v1(256.44,112.63) 255.88,112.63 255.48,112.23 RG105.2 255.2,112.35 255.2,112.76 255.66,113.23 QG10.4
  IN4 w0.086: v1(257.93,117.08) 257.93,117.12 257.22,117.83 255.35,117.83 254.71,118.47 254.71,119.64 255.16,120.09 255.16,121.5 254.33,122.32 253.41,122.32 253,122.74 253,123.52 251.72,124.8 251.72,126.58 252.24,127.11 252.24,129.03 v2(252.21,129.07)
  BOTTOM w0.102: v2(252.21,129.07) 252.21,129.07 251.86,129.42 UG6.BN8
I2CB_SDA_G: length 22.6
  TOP w0.14: RG79.2 259.01,117.71 258.87,117.85 257.83,117.85 257.29,117.31 v1(257.29,117.1) 256.66,116.48 QG10.1
  IN4 w0.086: v2(252.2,129.76) 251.77,129.33 251.77,127.53 251.21,126.96 251.21,124.65 252.53,123.33 252.53,122.54 253.22,121.85 254.14,121.85 254.69,121.3 254.69,120.28 254.24,119.84 254.24,118.28 255.15,117.36 256.29,117.36 256.55,117.1 v1(257.29,117.1)
  BOTTOM w0.102: v2(252.2,129.76) 252.2,129.77 UG6.BM8
I2CC_SCL_GFX: length 209.4
  TOP w0.102: RG1.2 226.83,215.03 226.93,215.13 227.27,215.13 v1(227.39,215.25)
  TOP w0.14: QG12.4 259.79,115.49 v1(259.2,116.08) 259.46,116.34 259.67,116.34 259.79,116.46 RG84.1
  IN2 w0.089: v2(253.03,129.87) 253.03,130.46 253.3,130.73 253.87,130.73 254.86,131.72 255.22,131.72 255.46,131.47 256.87,131.47 257.04,131.64 260.3,131.64 260.71,131.22 261.99,131.22 262.48,131.71 266.14,131.71 266.8,131.05 272.69,131.05 277.37,135.73 277.37,135.98 277.75,136.36 278,136.36 280.31,138.67 280.31,152.19 281.91,153.78 281.91,165.31 284.66,168.06 284.66,170.63 284.03,171.27 283.53,171.27 277.73,177.07 276.67,178.13 276.67,180.45 277.91,181.69 279.34,181.69 279.76,182.11 279.76,188.22 280.56,189.01 280.56,196.1 280.89,196.42 280.89,197.79 281.49,198.39 281.49,199.38 281.06,199.81 278.18,199.81 277.22,200.76 277.13,200.76 276.22,201.67 275.31,201.67 274.17,202.81 274.17,204.95 273.26,205.87 270.24,205.87 268.94,207.17 268.94,207.37 267.86,208.44 267.86,212.8 265.61,215.06 263.01,215.06 262.44,215.63 261.15,215.63 258.95,217.82 253.07,217.82 252.43,217.18 251.37,217.18 251.14,217.42 247.45,217.42 246.44,216.4 245.36,216.4 244.96,216 244.96,213.58 244.7,213.32 244.7,211.68 245.37,211.02 245.37,210.53 243.87,209.04 237.78,209.04 234.84,211.98 234.84,214.11 233.51,215.44 233.51,216.26 232.46,217.31 229.44,217.31 227.39,215.26 v1(227.39,215.25)
  IN4 w0.086: v2(253.03,129.87) 253.03,129.6 253.9,128.72 253.9,127.64 253.6,127.33 253.6,126.07 255.8,123.87 258.94,123.87 259.65,123.15 259.65,122.49 260.36,121.79 260.36,120.86 261.53,119.68 261.53,119.06 262.6,117.99 262.73,117.99 263.67,117.05 263.67,116.59 263.3,116.22 262.33,116.22 262.12,116.43 259.99,116.43 259.64,116.08 v1(259.2,116.08)
  BOTTOM w0.102: UG6.BM7 252.59,130.12 252.84,129.87 v2(253.03,129.87)
I2CC_SDA_GFX: length 199.6
  TOP w0.102: v1(227.41,214.12) 227.37,214.15 RG2.2
  TOP w0.14: v1(258.26,114.56) 258.79,114.03 QG12.1 258.79,113.59 v1(258.32,113.12) RG102.1
  IN1 w0.086: v1(265.31,211.89) 265.31,212.21 263.3,214.22 262.83,214.22 262.09,213.47 257.35,213.47 257.04,213.17 257.04,212.05 256.62,211.62 255.81,211.62 255.3,211.11 250.93,211.11 250.32,210.5 247.15,210.5 244,207.35 243.61,207.35 241.65,205.39 235.85,205.39 234.77,206.47 234.77,207.97 234.6,208.14 234.6,208.8 234.8,209 234.8,210.05 234.42,210.43 233.4,210.43 232.87,210.96 232.18,210.96 231.18,211.97 231.18,213.39 230.36,214.21 227.5,214.21 v1(227.41,214.12)
  IN2 w0.089: v1(258.26,114.56) 258.26,114.78 258.78,115.3 258.78,116.62 259.02,116.86 259.02,118.39 259.82,119.19 259.82,121.7 259.56,121.95 259.56,123.35 257.63,125.28 257.63,129.11 257.27,129.46 256.78,129.46 256.69,129.37 256.1,129.37 255.27,130.2 254.88,130.2 254.54,129.86 254.54,129.35 254.05,128.87 253.12,128.87 v2(252.99,129)
  IN3 w0.089: v2(252.99,129) 253.11,128.88 253.88,128.88 254.78,127.98 256.98,127.98 259.08,130.08 263,130.08 263.58,130.66 266.58,130.66 268.25,132.34 269.15,132.34 270.7,133.89 270.7,135.46 271.64,136.4 273.58,136.4 274.32,137.14 274.94,137.14 277.14,139.35 277.14,152.3 279.67,154.83 279.67,184 278.08,185.59 277.16,185.59 276.63,186.12 274.6,186.12 273.3,187.42 270.14,187.42 269.37,186.65 268.42,186.65 267.7,185.94 266.97,185.94 266.22,186.68 266.22,189.32 264.82,190.72 264.82,191.17 265.09,191.44 266.03,191.44 267.01,192.42 267.01,199.91 267.34,200.24 267.85,200.24 269.12,201.51 269.12,202.02 268.48,202.65 268.48,206.85 267.63,207.7 267.63,210.46 267.05,211.04 265.69,211.04 265.31,211.41 v1(265.31,211.89)
  BOTTOM w0.102: UG6.BN7 252.57,129.42 v2(252.99,129)
I2S2_RXD: length 11.1
  IN3 w0.089: v1(230.04,61.99) 229.33,62.7 229.33,64.16 228.83,64.66 228.02,64.66 227.36,64 225.41,64 225,63.6 v1(225,62.74)
  BOTTOM w0.102: 230.64,62.26 230.36,61.99 v1(230.04,61.99) ; v1(225,62.74) 224.61,62.74 223.79,61.91 U49.BE36
  BOTTOM w0.14: R998.2 230.64,62.26
I2S2_SCLK: length 11.1
  IN3 w0.089: v1(230.05,61.19) 229.14,62.1 229.14,63.13 228.73,63.54 228.1,63.54 227.84,63.79 226,63.79 225.64,63.43 v1(225.64,62.91)
  BOTTOM w0.102: R1001.2 230.85,61.65 230.39,61.19 v1(230.05,61.19) ; U49.BD36 223.12,61.91 223.35,62.14 223.73,62.14 224.32,62.73 224.32,62.78 224.7,63.16 225.39,63.16 v1(225.64,62.91)
ICMNT: length 178.3
  TOP w0.14: U23.67 185.07,59.7 185.16,59.6 186.34,59.6 186.89,59.05 C504.1 186.89,58.63 187.03,58.49 187.32,58.49 188.22,59.39 v1(188.22,59.58) ; PC242.2 PR319.2 34.7,45.41 34.87,45.57 36.01,45.57 v1(36.06,45.52)
  IN3 w0.089: v1(36.06,45.52) 36.56,45.52 38.27,47.24 38.27,48.17 39.49,49.38 41.79,49.38 43.34,50.93 57.99,50.93 60.65,48.28 72.05,48.28 73.52,49.75 73.52,50.99 77.24,54.71 94.76,54.71 98.08,58.03 100.84,58.03 102.89,60.08 110.98,60.08 111.49,60.59 111.79,60.59 111.99,60.78 122.07,60.78 123.06,61.77 124.53,61.77 125.64,62.89 140.71,62.89 143.18,65.36 146.43,65.36 148.84,67.76 153.17,67.76 154.26,66.67 160.18,66.67 160.36,66.85 161.37,66.85 161.52,66.7 163.3,66.7 163.54,66.94 165.3,66.94 165.59,67.23 170.34,67.23 170.76,66.81 177.58,66.81 178.83,65.56 182.8,65.56 183.74,64.62 183.74,62.4 184.84,61.3 186,61.3 187.48,59.82 187.97,59.82 v1(188.22,59.58)
IDCHG_R: length 185
  TOP w0.14: PC244.2 34.01,43.83 34.15,43.69 34.42,43.69 34.58,43.84 PR322.2 34.58,44.46 v1(34.42,44.61) ; PR343.2 33.65,38.48 v1(33.94,38.18) ; R540.2 188.16,60.39 188.71,59.83 v1(188.81,59.83)
  IN3 w0.089: v1(34.42,44.61) 34.75,44.95 36.25,44.95 38.75,47.44 38.95,47.44 40.71,49.19 41.87,49.19 43.42,50.74 57.91,50.74 60.57,48.09 72.12,48.09 73.71,49.68 73.71,50.91 77.32,54.52 94.84,54.52 97.42,57.1 100.42,57.1 102.6,59.28 111.39,59.28 112.7,60.59 122.15,60.59 123.07,61.51 124.62,61.51 125.8,62.69 140.79,62.69 143.26,65.17 146.51,65.17 148.92,67.57 153.09,67.57 154.18,66.48 160.47,66.48 160.64,66.66 161.29,66.66 161.56,66.39 162.08,66.39 162.61,65.86 163.15,65.86 164.04,66.75 165.38,66.75 165.67,67.04 170.26,67.04 170.68,66.62 177.5,66.62 178.75,65.37 182.72,65.37 183.55,64.54 183.55,62.32 184.77,61.11 185.92,61.11 187.85,59.18 188.39,59.18 188.81,59.6 v1(188.81,59.83)
  BOTTOM w0.14: v1(33.94,38.18) 33.96,38.18 35.89,40.11 35.89,43.14 v1(34.42,44.61)
IFPAB_RSET: length 4.6
  TOP w0.102: v2(241.01,129.76) 241.45,130.2 RG58.2
  BOTTOM w0.102: v2(241.01,129.76) 241.51,129.76 241.71,129.96 241.71,132.56 UG6.BH23
IFPC_RSET: length 1.4
  TOP w0.203: RG56.2 243.72,132 243.17,132.55 v2(243.1,132.55)
  BOTTOM w0.102: v2(243.1,132.55) 243.1,132.57 UG6.BH20
IFPEF_RSET: length 2.3
  TOP w0.203: v2(245.9,131.87) 245.67,131.64 RG57.2
  BOTTOM w0.102: v2(245.9,131.87) 245.9,132.57 UG6.BH17
IGPU_BL_EN: length 34.2
  TOP w0.102: v1(257.49,131.1) 257.53,131.06 258.56,131.06 258.8,131.31 258.97,131.31
  TOP w0.14: 258.97,131.31 260.38,131.31 260.58,131.5 261.3,131.5 261.49,131.31 262.08,131.31 262.59,131.81 263.23,131.81 263.53,132.11 265.64,132.11 266.73,131.03 267.47,131.03 268.4,131.97 TP16.1
  IN4 w0.086: v1(257.49,131.1) 258.1,130.49 258.1,129.24 259.82,127.52 259.82,126.79 260.47,126.14 260.47,125.8 261.65,124.62 262.38,124.62 264.12,122.88 265.06,122.88 265.97,121.97 265.97,120.82 265.28,120.14 265.28,119.12 v1(265.96,118.45)
  BOTTOM w0.102: v1(257.49,131.1) 257.07,131.52 UG6.BK1
  BOTTOM w0.14: v1(265.96,118.45) 265.76,118.45 265.6,118.29 265.6,118.09 265.74,117.95 RG175.1 266.04,117.95 266.27,117.72 266.27,117.36 265.57,116.66 QG25.1
ILIM_HI1: length 1.5
  TOP w0.14: R124.1 317.51,98.91 U7.16
ILIM_HI2: length 1.6
  TOP w0.14: R126.1 311.66,98.74 311.16,98.25 U6.16
ILIM_HI3: length 1.8
  BOTTOM w0.14: U52.16 23.2,55.5 23.42,55.72 R1057.1
ILIM_LO1: length 1.5
  TOP w0.14: R125.1 318.02,98.93 U7.15
ILIM_LO2: length 1.8
  TOP w0.14: U6.15 311.67,98.13 311.96,98.42 312.33,98.42 R127.1
ILIM_LO3: length 1.3
  BOTTOM w0.14: U52.15 22.7,56.18 R1054.2
IMVP_PWRGD: length 310
  TOP w0.14: v1(211.18,43.3) 212.19,44.31 212.19,45.45 211.97,45.68 U30.2 210.57,45.68 210.29,45.4 R627.2 ; v1(106.09,55.49) 106.79,56.19 107,56.19 109.23,58.41 109.23,64.7 109.49,64.96 109.49,67.28 107.73,69.04 107.73,70.68 107.26,71.16 107.26,72.74 107.73,73.21 107.73,74.86 108.57,75.7 108.57,76.81 108.88,77.13 108.88,83.81 109.13,84.05 109.13,96.04 110.64,97.56 110.64,103.41 111.57,104.33 111.57,113.19 111.07,113.68 111.07,116.02 109.75,117.34 109.75,123.2 111.84,125.29 v1(112.59,125.29)
  IN3 w0.089: v1(106.09,55.49) 107.4,54.18 113.67,54.18 113.91,54.42 118.2,54.42 120.19,56.41 123.9,56.41 126.03,58.54 137.01,58.54 138.44,57.11 148.88,57.11 151.42,54.57 155.95,54.57 157.18,55.8 163.56,55.8 163.88,56.11 169.5,56.11 170.48,55.13 170.48,53.71 170.85,53.34 171.34,53.34 172.19,52.49 173.33,52.49 173.69,52.85 176.74,52.85 182.19,47.4 186.5,47.4 190.63,43.27 197.05,43.27 198.77,41.55 205.41,41.55 206.25,42.39 210.27,42.39 v1(211.18,43.3) ; v1(112.59,125.29) 112.59,126.19 113.27,126.87 113.27,127.48 115.26,129.47 115.26,136.19 114.74,136.7 114.74,137.39 117.55,140.2 117.55,144.08 118.93,145.46 118.93,172.32 115.8,175.45 111.44,175.45 109.95,176.93 109.95,195.16 112.18,197.39 112.18,209.06 115.32,212.2 115.32,212.91 116.81,214.4 120.7,214.4 120.98,214.68 v2(120.98,215.07)
  BOTTOM w0.14: v1(112.59,125.29) 112.59,125.29 112.59,128.05 112.8,128.25 Q98.2 ; PR374.1 121.43,214.63 v2(120.98,215.07) 120.95,215.1 120.95,215.47 PR361.2
IN1_EQ0: length 5.8
  TOP w0.14: v1(278.13,215.48) 277.88,215.48 277.71,215.31 v1(277.42,215.31) 277.35,215.38 R18.1
  IN1 w0.086: v1(277.42,215.31) 277.18,215.55 274.65,215.55 v1(274.4,215.3)
  BOTTOM w0.14: v1(274.4,215.3) 274.4,215.29 274.36,215.24 274.36,214.52 274.4,214.48 U36.8
IN1_EQ1: length 2.1
  TOP w0.14: v1(270.39,213.45) 270.39,213.7 270.88,214.19 R25.1
  BOTTOM w0.14: U36.7 274,214.64 v1(273.78,214.86)
IN1_EQ2: length 0.7
  BOTTOM w0.14: v1(274.86,214.81) 274.8,214.75 U36.9
INA199_IN+: length 19.3
  TOP w0.14: PU6.4 226.18,188.06 225.98,188.25 225.79,188.25 225.65,188.11 225.65,186.77 226.02,186.4 227.64,186.4 227.88,186.17 230.84,186.17 231.41,186.74 231.41,187.17 231.99,187.75 231.99,188.09 231.83,188.25 231.63,188.25 231.46,188.08 PU5.4 230.41,188.08 230.17,188.33 230.01,188.33 229.71,188.62 229.71,190.75 229.56,190.9 229.1,190.9 PC48.1 228.91,190.9 228.4,190.9 228.25,191.04 227.82,191.04 PC49.2 227.64,191.01 226.83,191.01 226.53,191.3 226.53,191.5 PR101.1
INA199_IN-: length 20.6
  TOP w0.14: PR102.1 226.8,191.61 226.8,191.41 226.94,191.27 227.5,191.27 PC47.1 227.9,191.31 228.36,191.31 228.51,191.17 228.92,191.17 PC48.2 229.1,191.16 229.67,191.16 229.98,190.86 229.98,188.73 230.12,188.59 230.25,188.59 230.38,188.73 PU5.5 231.42,188.73 231.63,188.52 231.94,188.52 232.26,188.2 232.26,187.64 231.68,187.06 231.68,186.63 230.95,185.9 227.77,185.9 227.53,186.14 225.9,186.14 225.38,186.66 225.38,188.23 225.68,188.52 226.01,188.52 226.2,188.71 PU6.5
INT_DP0_AUXN: length 159.8
  TOP w0.14: v1(152.19,160.47) 152.37,160.28 152.62,160.28 153.98,158.92 153.98,157.88 C50.2
  IN1 w0.086: v1(152.19,160.47) 152.43,160.22 152.73,160.22 153,160.07 154.28,158.43 154.38,158.33 158.33,158.33 158.66,158.66 161.28,160.06 163.67,160.06 168.22,159.25 172.39,157.52 173.47,157.32 177.71,157.32 181.25,155.85 181.63,155.48 182.17,154.18 182.17,149.96 187.27,144.85 188.13,140.41 188.13,129.27 194.98,122.42 194.98,118.1 198.46,114.63 202.5,114.63 205.43,117.56 205.43,120.98 205.88,121.44 207.8,121.44 208.72,120.52 224.33,120.52 224.53,120.72 233.2,120.72 233.28,120.64 233.76,120.64 v1(233.96,120.84)
  BOTTOM w0.102: 251.88,120.49 251.84,120.53 251.84,121.02 251.57,121.68 251.54,121.76 251.15,122.33 250.6,123.68 250.6,126.31 250.34,126.57 250.34,127.21 UG6.BT10
  BOTTOM w0.14: 251.88,120.49 RG164.1 251.88,119.24 251.49,118.85 250.23,118.32 247.64,118.32 243.71,114.39 234.72,114.39 234.04,115.08 234.04,116.01 232.18,117.86 232.18,119.59 233.32,120.72 233.85,120.72 v1(233.96,120.84)
INT_DP0_AUXN_C: length 6.9
  TOP w0.14: v2(154.3,152.31) 154.21,152.23 154.02,152.23 153.71,152.53 153.71,153.66 153.95,153.89 153.95,156.77 153.64,157.07 153.64,157.29 153.78,157.43 153.98,157.43 C50.1
  BOTTOM w0.14: v2(154.3,152.31) 154.27,152.35 154.03,152.35 153.87,152.19 153.87,152.03 U42.AT38
INT_DP0_AUXP: length 159.8
  TOP w0.14: v1(152.19,159.67) 152.19,159.82 152.33,159.96 152.49,159.96 153.67,158.79 153.67,157.95 153.53,157.81 153.3,157.81 C49.2
  IN1 w0.086: v1(234.01,120.19) 234.01,120.32 233.89,120.45 233.2,120.45 233.12,120.53 224.61,120.53 224.41,120.33 208.64,120.33 207.72,121.25 205.96,121.25 205.61,120.9 205.61,117.48 202.58,114.44 198.38,114.44 194.8,118.03 194.8,122.34 187.95,129.19 187.95,140.39 187.1,144.76 181.98,149.88 181.98,154.15 181.47,155.37 181.15,155.69 177.68,157.13 173.45,157.13 172.34,157.34 168.16,159.07 163.66,159.87 161.33,159.87 158.77,158.51 158.41,158.14 154.3,158.14 154.14,158.31 152.88,159.93 152.68,160.03 152.26,160.03 152.13,159.91 152.13,159.74 v1(152.19,159.67)
  BOTTOM w0.102: UG6.BT11 249.75,127.54 249.85,127.64 250.02,127.64 250.14,127.52 250.14,126.48 250.39,126.23 250.39,123.64 250.97,122.24 251.35,121.68 251.36,121.66 251.63,121.01 251.63,120.53 251.62,120.51
  BOTTOM w0.14: 251.62,120.51 251.62,120.3 251.32,120.01 RG163.1 251.32,119.72 251.56,119.48 251.56,119.37 251.31,119.12 250.17,118.64 247.51,118.64 243.58,114.71 234.86,114.71 234.36,115.21 234.36,116.14 232.5,117.99 232.5,119.46 233.45,120.41 233.8,120.41 v1(234.01,120.19)
INT_DP0_AUXP_C: length 7
  TOP w0.14: v2(154.31,151.65) 154.05,151.91 153.89,151.91 153.4,152.4 153.4,153.79 153.63,154.02 153.63,156.64 153.33,156.94 153.33,157.33 C49.1
  BOTTOM w0.14: U42.AT37 153.94,151.34 154.23,151.64 154.3,151.64 v2(154.31,151.65)
INT_DP0_D0: length 154.1
  IN1 w0.086: v1(153.6,162.86) 153.38,163.07 153.38,163.99 153.58,164.18 155.23,164.18 155.68,163.73 160.31,163.73 160.51,163.93 160.51,164.36 160.59,164.44 160.89,164.44 160.97,164.36 160.97,163.93 161.17,163.73 161.62,163.73 161.82,163.93 161.82,164.36 161.9,164.44 162.2,164.44 162.28,164.36 162.28,163.93 162.48,163.73 164.62,163.73 165.73,162.63 169.55,162.63 170.64,161.54 171.15,161.54 171.55,161.15 181.83,161.15 186.71,156.26 186.71,154.82 187.07,154.46 188.6,154.46 188.91,154.16 188.91,153.6 188.82,153.52 186.99,153.52 186.77,153.3 186.77,152.74 186.96,152.55 188.82,152.55 188.91,152.46 188.91,152.04 188.82,151.95 186.96,151.95 186.76,151.76 186.76,151.18 186.96,150.98 188.82,150.98 188.91,150.9 188.91,150.47 188.82,150.39 187.02,150.39 186.82,150.19 186.82,149.61 187.02,149.42 188.82,149.42 188.91,149.33 188.91,148.91 188.82,148.82 187.36,148.82 187.15,148.61 187.15,148.05 187.41,147.78 188.37,147.78 188.66,147.49 188.66,146.61 189.91,145.36 189.91,131.28 197.82,123.38 208.43,123.38 209.51,122.3 222.85,122.3 223.29,122.74 227.26,122.74 227.46,122.94 227.46,124.79 227.55,124.88 227.97,124.88 228.05,124.79 228.05,124.09 228.29,123.86 228.83,123.86 229.02,124.06 229.02,124.79 229.11,124.88 229.53,124.88 229.62,124.79 229.62,124.26 229.82,124.06 230.39,124.06 230.59,124.25 230.59,124.79 230.67,124.88 231.1,124.88 231.18,124.79 231.18,124.29 231.4,124.08 231.96,124.08 232.15,124.27 232.15,124.79 232.24,124.88 232.66,124.88 232.75,124.79 232.75,124.37 232.95,124.16 233.52,124.16 233.72,124.36 233.72,124.79 233.8,124.88 234.23,124.88 234.31,124.79 234.31,124.42 234.53,124.2 235.09,124.2 235.28,124.4 235.28,124.79 235.37,124.88 235.79,124.88 235.88,124.79 235.88,124.4 236.07,124.21 236.64,124.21 236.85,124.42 236.85,124.79 236.93,124.88 237.35,124.88 237.44,124.79 237.44,124.41 237.65,124.21 238.21,124.21 238.41,124.4 238.41,124.79 238.5,124.88 238.92,124.88 239.01,124.79 239.01,124.45 239.23,124.23 239.78,124.23 239.98,124.42 239.98,124.79 240.06,124.88 240.73,124.88 v2(240.93,124.68)
  BOTTOM w0.102: v2(240.93,124.68) 240.93,124.8 240.85,124.87 240.46,124.87 240.21,125.12 240.21,126.43 240.76,126.98 240.76,127.55 241.02,127.81 241.02,128.16 241.17,128.32 241.17,128.54 UG6.BP23
  BOTTOM w0.14: C637.2 153.39,162.65 v1(153.6,162.86)
INT_DP0_D0#: length 154
  IN1 w0.086: v1(152.82,162.86) 152.9,162.78 153.11,162.78 153.2,162.86 153.2,164.06 153.5,164.37 155.31,164.37 155.76,163.92 160.23,163.92 160.32,164.01 160.32,164.43 160.51,164.63 160.96,164.63 161.16,164.43 161.16,164.01 161.25,163.92 161.54,163.92 161.63,164.01 161.63,164.43 161.82,164.63 162.28,164.63 162.47,164.43 162.47,164.01 162.56,163.92 164.7,163.92 165.81,162.81 169.63,162.81 170.72,161.73 171.23,161.73 171.63,161.33 181.91,161.33 186.9,156.34 186.9,154.9 187.14,154.65 188.68,154.65 189.09,154.23 189.09,153.53 188.9,153.33 187.06,153.33 186.95,153.22 186.95,152.82 187.04,152.73 188.9,152.73 189.09,152.54 189.09,151.96 188.9,151.76 187.03,151.76 186.95,151.68 186.95,151.26 187.03,151.17 188.9,151.17 189.09,150.97 189.09,150.4 188.9,150.2 187.09,150.2 187.01,150.11 187.01,149.69 187.09,149.61 188.9,149.61 189.09,149.41 189.09,148.83 188.9,148.63 187.44,148.63 187.33,148.53 187.33,148.13 187.49,147.97 188.45,147.97 188.84,147.57 188.84,146.69 190.1,145.44 190.1,131.36 197.89,123.56 208.51,123.56 209.58,122.49 222.77,122.49 223.21,122.93 227.18,122.93 227.27,123.02 227.27,124.87 227.47,125.06 228.04,125.06 228.24,124.87 228.24,124.17 228.36,124.05 228.75,124.05 228.84,124.14 228.84,124.87 229.03,125.06 229.61,125.06 229.81,124.87 229.81,124.33 229.89,124.25 230.31,124.25 230.4,124.33 230.4,124.87 230.6,125.06 231.17,125.06 231.37,124.87 231.37,124.37 231.48,124.26 231.88,124.26 231.96,124.35 231.96,124.87 232.16,125.06 232.74,125.06 232.94,124.87 232.94,124.44 233.03,124.35 233.44,124.35 233.53,124.43 233.53,124.87 233.73,125.06 234.3,125.06 234.5,124.87 234.5,124.5 234.6,124.39 235.01,124.39 235.09,124.48 235.09,124.87 235.29,125.06 235.87,125.06 236.06,124.87 236.06,124.48 236.15,124.4 236.56,124.4 236.66,124.5 236.66,124.87 236.85,125.06 237.43,125.06 237.63,124.87 237.63,124.49 237.72,124.39 238.14,124.39 238.22,124.48 238.22,124.87 238.42,125.06 239,125.06 239.19,124.87 239.19,124.53 239.31,124.41 239.7,124.41 239.79,124.5 239.79,124.87 239.98,125.06 240.73,125.06 240.93,125.25 v2(240.93,125.33)
  BOTTOM w0.102: v2(240.93,125.33) 240.93,125.23 240.77,125.07 240.55,125.07 240.42,125.2 240.42,126.35 240.98,126.91 240.98,127.44 241.26,127.73 241.26,127.93 UG6.BR23
  BOTTOM w0.14: v1(152.82,162.86) 153.07,162.61 153.07,162.26 152.85,162.04 C636.2
