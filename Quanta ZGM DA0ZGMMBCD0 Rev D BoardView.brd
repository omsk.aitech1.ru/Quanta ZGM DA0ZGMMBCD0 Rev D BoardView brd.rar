# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_TXP_LAN: length 160
  IN1 w0.086: v1(317.62,86.11) 317.31,85.8 317.06,85.8 316.77,85.51 316.77,84.67 317.01,84.42 317.01,81.09 314.97,79.05 311.65,79.05 310.73,78.14 310.73,76.57 309.02,74.86 309.02,73.96 308.45,73.39 308.45,71.36 306.93,69.84 294.8,69.84 293.93,68.97 288.18,68.97 285.17,65.96 285.17,65.29 282.04,62.17 282.04,59.62 276.29,53.87 271.87,53.87 270.34,52.34 265.66,52.34 264.66,51.34 255.19,51.34 253.66,49.82 250.2,49.82 248.66,48.27 242.01,48.27 241.72,47.98 240.55,47.98 240.02,47.45 237.18,47.45 237.09,47.36 229.54,47.36 229.01,47.89 222.29,47.89 220.52,46.11 219.99,46.11 219.61,46.5 214.84,46.5 213.5,47.84 210.81,47.84 209.8,48.84 209.8,49.71 206.75,52.75 204.21,52.75 202.62,54.35 200.91,54.35 200.04,55.21 198.46,55.21 197.95,55.72 197.95,56.65 197.54,57.06 197.54,57.65 197.65,57.76 197.78,57.76 v1(197.88,57.65)
  BOTTOM w0.102: 197.87,57.67 v1(197.88,57.65) ; U49.E38 203.05,60.58 202.88,60.51 202.57,60.51 202.48,60.61 202.12,60.61 202.02,60.51 200.81,60.51 200.33,60.04 199.83,60.04 198.84,59.04 198.26,59.04 198.06,58.84 198.06,58.8
  BOTTOM w0.14: 197.87,57.67 197.73,57.81 197.73,58.48 198.06,58.8 ; v1(317.62,86.11) 317.62,86.1 317.3,85.78 316.9,85.78 316.77,85.91 CN10.2
PCIE_TXP_WLAN: length 110.4
  IN1 w0.086: v1(199.31,56.44) 199.07,56.44 198.86,56.22 198.86,55.95 199.03,55.78 200.26,55.78 201.06,54.98 202.79,54.98 204.46,53.31 206.98,53.31 210.92,49.37 214.18,49.37 214.95,48.6 214.95,47.33 215.23,47.05 219.54,47.05 220.98,48.49 229.2,48.49 229.77,47.92 236.68,47.92 236.77,48.01 239.69,48.01 240.23,48.54 241.49,48.54 241.78,48.83 245.16,48.83 246.2,49.87 246.2,50.36 246.53,50.69 249.23,50.69 249.65,51.11 254.04,51.11 254.83,51.9 264.15,51.9 265.15,52.9 270.05,52.9 271.69,54.53 273.59,54.53 273.92,54.86 276.18,54.86 279.26,57.94 279.26,58.78 279.78,59.31 280.74,59.31 281.29,59.85 281.29,62.28 284.61,65.6 284.61,66.63 284.46,66.79 284.27,66.79 v1(284.22,66.74)
  BOTTOM w0.102: v1(199.31,56.44) 199.04,56.7 199.04,57.52 199.22,57.69 199.22,58.56 200.05,59.4 200.35,59.4 200.98,60.04 202.42,60.04 U49.D39
  BOTTOM w0.14: C765.2 284.51,67.32 284.51,67.02 v1(284.22,66.74)
PCIE_TXP_WLAN_C: length 3.6
  BOTTOM w0.14: C765.1 284.35,67.93 284.55,67.93 284.72,68.1 284.72,69.3 284.29,69.72 284.09,69.72 283.86,69.49 CN12.35
PCIE_WAKE#: length 144.2
  TOP w0.14: v1(314.82,81.78) 314.46,82.14 312.24,82.14 311.76,82.62 311.76,82.74 311.61,82.89 311.61,83.78 311.28,84.11 311.13,84.11 310.66,84.58 Q27.3 ; Q38.3 285.3,75.88 284.42,76.76 v1(284.42,77.05)
  IN2 w0.089: v1(284.42,77.05) 282.18,74.81 282.18,72.05 281.92,71.79 281.53,71.79 281.37,71.63 281.31,71.63 279.9,70.21 279.9,69.69 277.65,67.44 277.65,62.88 278.81,61.71 278.81,59.85 278.1,59.14 278.1,57.92 276.95,56.77 276.95,55.64 273.79,52.47 271.01,52.47 270.09,53.4 269.5,53.4 268.9,54 266.89,54 265.15,52.26 258.96,52.26 258.35,51.66 254.87,51.66 254.57,51.36 249.57,51.36 249.17,50.96 244.21,50.96 243.85,50.6 238.89,50.6 238.56,50.93 234.11,50.93 232.9,52.14 231.62,52.14 231.4,51.92 230.09,51.92 229.58,51.41 228.18,51.41 227.45,52.14 213.57,52.14 212.52,53.19 v1(212.37,53.19)
  IN4 w0.086: v1(314.82,81.78) 314.44,82.16 314.04,82.16 313.13,83.07 311.08,83.07 310.32,82.31 309.63,82.31 308.56,81.24 308.56,78.89 306.94,77.27 303,77.27 302.33,76.59 301.94,76.59 300.78,75.43 298.52,75.43 297.06,76.9 294.92,76.9 294.41,77.41 293.3,77.41 292.89,77.81 288.83,77.81 288.12,77.1 284.47,77.1 v1(284.42,77.05)
  BOTTOM w0.102: 212.37,53.25 212.55,53.44 212.55,54.42 212.67,54.54 212.67,55.97 U49.AD47
  BOTTOM w0.14: 212.37,53.25 v1(212.37,53.19) 212.27,53.09 R1067.1
PCIECOMP_N: length 5.2
  BOTTOM w0.102: R946.2 198.72,74.73 198.78,74.66 198.78,74.58 198.89,74.48 199.14,74.48 199.86,73.77 199.86,73.25 200.12,72.99 201.45,72.99 201.88,73.42 201.88,73.52 201.78,73.62 201.63,73.62 U49.A13
PCIECOMP_P: length 5.3
  BOTTOM w0.102: U49.B13 202.08,73.33 201.54,72.78 200.03,72.78 199.65,73.17 199.65,73.68 199.14,74.19 199.12,74.19 199.03,74.28 R946.1
PCM_CLK: length 56.9
  IN3 w0.089: v1(269.7,59.61) 269.27,59.19 264.81,59.19 263.27,57.64 262.19,57.64 259.73,55.18 258.02,55.18 257.71,55.49 251.71,55.49 251.27,55.93 251.05,56.15 247.08,56.15 246.56,56.67 246.05,56.67 245.82,56.44 245.82,56.12 245.19,55.49 239.36,55.49 237.97,54.11 237.63,54.11 237.44,53.91 236.47,53.91 236.07,53.51 235.84,53.51 v1(235.46,53.14)
  BOTTOM w0.14: v1(235.46,53.14) 234.2,54.4 234.2,55.93 233.3,56.82 233.3,57.21 232.87,57.64 232.87,57.91 232.25,58.53 232.25,60.62 231.3,61.57 R1001.1 ; CN12.8 274.62,62.74 274.38,62.5 273.68,62.5 273.1,63.07 272.46,63.07 272.21,62.83 272.21,62.27 271.7,61.76 271.7,61.21 270.1,59.61 v1(269.7,59.61)
PCM_IN: length 56.2
  IN3 w0.089: v1(269.02,59.59) 268.89,59.46 264.81,59.46 263.19,57.83 262.11,57.83 259.66,55.38 258.09,55.38 257.79,55.68 251.78,55.68 251.13,56.34 247.16,56.34 246.64,56.87 245.97,56.87 245.63,56.52 245.63,56.2 245.12,55.68 239.28,55.68 237.89,54.3 237.55,54.3 237.48,54.23 236.22,54.23 v1(235.91,53.91)
  BOTTOM w0.14: CN12.12 273.89,63.74 273.5,63.35 272.34,63.35 271.93,62.94 271.93,62.38 271.42,61.87 271.42,61.32 270.19,60.09 269.53,60.09 v1(269.02,59.59) ; R998.1 231.63,62.14 231.63,61.81 232.53,60.91 232.53,58.65 233.15,58.03 233.15,57.75 233.58,57.32 233.58,56.94 235.91,54.61 v1(235.91,53.91)
PD: length 5.9
  TOP w0.203: Q6.3 279.34,210.8 279.13,211 278.61,211 v1(278.1,211.51) 277.29,212.32 277.29,212.66 277.61,212.98 C6.2 277.61,214.11 277.51,214.21 v1(277.51,214.22)
  BOTTOM w0.14: U36.15 277.36,213.69 277.5,213.83 277.5,214.21 v1(277.51,214.22)
PD#: length 23.4
  TOP w0.14: D21.2 308.34,81.49 D20.2 ; D21.2 v1(306.97,81.49) ; D21.2 309.53,81.49 v1(309.92,81.89) ; v1(305.8,72.27) 306.04,72.03 C400.1 R409.1 306.29,71.22 306.74,70.77 R425.2 306.74,70.4 307.41,69.73 307.41,69.56 308.73,68.23 U20.2
  IN4 w0.086: v1(305.8,72.27) 304.93,73.14 304.93,76.37 305.36,76.8 307.13,76.8 309.03,78.7 309.03,81 v1(309.92,81.89)
PD_I2C_INT#: length 174.8
  TOP w0.14: R315.1 215.27,78.42 214.51,77.66 v1(214.51,76.54)
  IN2 w0.089: v1(214.51,76.54) 213.89,76.54 212.98,75.64 212.98,74.84 211.98,73.84 211.66,73.84 211.37,74.13 211,74.13 210.77,73.9 210.77,73.45 210.54,73.22 209.98,73.22 209.1,72.33 209.1,72.09 208.53,71.53 208.07,71.53 207.55,72.05 206.09,72.05 205.85,72.29 205.24,72.29 204.95,72 204.95,71.27 204.35,70.67 202.9,70.67 201.89,69.66 200.55,69.66 198.83,71.37 195.13,71.37 192.46,74.05 190.82,74.05 190.56,73.79 188.43,73.79 187.42,74.8 182.06,74.8 180.99,75.86 173.46,75.86 172.85,75.25 169.71,75.25 169.63,75.17 166.61,75.17 166.14,75.64 164.43,75.64 163.97,75.17 162.35,75.17 162.22,75.3 162.22,75.6 161.86,75.96 161.06,75.96 160.79,76.23 159.06,77.96 153.71,77.96 153,77.25 151.68,77.25 151.18,76.75 150.38,76.75 149.09,75.45 145.44,75.45 145.05,75.06 143.25,75.06 142.86,75.45 138.61,75.45 137.24,76.83 130.03,76.83 129.27,76.07 119.78,76.07 119.78,76.07 116.57,76.07 114.75,77.89 112.47,77.89 111.09,79.28 110.18,79.28 109.65,79.81 105.5,79.81 104.96,80.35 103.62,80.35 101.48,78.22 99.46,78.22 96.8,80.88 76.36,80.88 74.34,82.91 v1(72.39,82.91)
  BOTTOM w0.102: v1(214.51,76.54) 214.18,76.87 U49.AE6
  BOTTOM w0.14: v1(72.39,82.91) 72.39,84.01 71.35,85.04 71.35,87.55 70.81,88.09 70.81,91.86 70.62,92.05 R844.1 69.68,92.6 Q105.3
PD_I2C_INT#_D: length 10.5
  TOP w0.079: v1(64.28,88.88) 63.95,88.88 63.74,89.09 63.14,89.09 62.68,88.63 62.32,88.63 U11.F2
  BOTTOM w0.14: R844.2 69.59,91.91 68.27,91.91 Q105.1 66.53,91.22 TP125.1 65.85,91.21 65.49,90.85 65.49,90.16 64.8,89.48 R853.1 64.45,88.89 64.29,88.89 v1(64.28,88.88)
PD_I2C_SCL: length 187.3
  IN1 w0.086: v1(90.23,78.68) 89.79,79.12 86.17,79.12 85.52,79.77 79.72,79.77 72.76,86.73 69.81,86.73 69.54,87 v1(68.47,87)
  IN2 w0.089: v1(90.23,78.68) 90.25,78.68 90.74,79.17 91.73,79.17 94.1,76.8 102.07,76.8 102.98,77.71 106.63,77.71 108.46,75.87 114.75,75.87 117.94,72.69 118.98,72.69 120.75,74.46 131.56,74.46 132.32,75.22 136.48,75.22 137.92,73.78 142.25,73.78 142.59,73.44 145.85,73.44 146.24,73.84 150.97,73.84 152.47,75.34 156.93,75.34 157.96,74.31 158.68,73.59 159.96,73.59 160.26,73.29 167.68,73.29 168.07,72.9 173.54,72.9 174.2,73.56 181.24,73.56 181.93,72.88 184.41,72.88 185.09,73.55 186.92,73.55 187.92,72.55 188.87,72.55 189,72.43 191.68,72.43 191.83,72.27 192.42,72.27 194.55,70.14 198.32,70.14 200.16,68.3 202.93,68.3 203.38,67.85 206.74,67.85 207.06,68.17 208.21,68.17 208.46,67.92 208.46,67.63 208.88,67.22 209.48,67.22 210.07,66.62 210.07,65.47 210.81,64.72 212.07,64.72 212.66,64.14 214.79,64.14 214.92,64.27 216.67,64.27 217.75,65.36 218.7,65.36 218.99,65.66 218.99,66.13 218.9,66.22 218.9,66.63 219.24,66.97 224.67,66.97 225.85,65.79 225.85,65.07 226.34,64.58 v1(226.34,64.58)
  BOTTOM w0.102: U49.BF33 223.9,63.43 223.94,63.4 224.36,63.4 224.78,63.81 225.57,63.81 v1(226.34,64.58) 226.75,64.17 227.61,64.17 227.87,64.43 R987.1
  BOTTOM w0.14: v1(68.47,87) 68.32,87.14 68.32,89.62 R848.1 67.4,89.47 Q106.6
PD_I2C_SDA: length 184.6
  IN1 w0.086: v1(69.34,86.46) 69.61,86.2 72.52,86.2 79.53,79.19 85.18,79.19 86.16,78.21 90.54,78.21 v1(90.87,78.54)
  IN2 w0.089: v1(225.3,65.6) 225.21,65.6 224.8,66.01 222.95,66.01 222.79,65.85 221.88,65.85 221.69,66.03 220.96,66.03 219.87,64.95 219.87,64.27 218.93,63.33 215.14,63.33 214.99,63.48 212.15,63.48 211.38,64.25 208.96,64.25 208.45,64.76 208.45,66.7 207.77,67.38 203.18,67.38 202.73,67.83 199.97,67.83 198.13,69.67 194.36,69.67 192.28,71.75 191.67,71.75 191.45,71.52 189.24,71.52 188.68,72.08 187.73,72.08 186.73,73.08 185.31,73.08 184.63,72.41 181.73,72.41 181.05,73.09 174.39,73.09 173.73,72.43 167.88,72.43 167.54,72.77 161.71,72.77 161.66,72.82 160.06,72.82 159.76,73.12 157.59,73.12 157.16,73.55 153.18,73.55 152.94,73.31 146.38,73.31 146.04,72.97 142.37,72.97 142.03,73.31 137.72,73.31 136.29,74.75 132.52,74.75 131.76,73.99 120.94,73.99 119.17,72.22 117.75,72.22 117.01,72.95 114.56,75.4 109.56,75.4 109.36,75.21 107.7,75.21 107.28,75.64 107.28,76.39 106.43,77.24 103.18,77.24 102.1,76.16 94.01,76.16 91.83,78.34 91.07,78.34 v1(90.87,78.54)
  BOTTOM w0.102: R983.1 226.98,66.51 225.56,66.51 225.3,66.26 v1(225.3,65.6) 225.25,65.6 224.72,66.13 224.07,66.13 223.82,65.88 223.14,65.88 222.84,66.18 222.08,66.18 221.95,66.05 221.95,65.07 U49.BB30
  BOTTOM w0.14: v1(69.34,86.46) 69.07,86.2 R871.1 68.72,86.5 69,86.78 69,87.57 Q106.3
PD_LDO_1V5: length 2.5
  BOTTOM w0.203: v1(64.11,90.06) 62.97,90.06 62.77,89.85 R851.1 62.6,89.46 R852.1
PD_LDO_3V3: length 6.6
  BOTTOM w0.203: R860.1 62.71,88.44 63.77,89.5 64.25,89.5 64.9,90.14 v1(64.9,91.17) ; R847.1 61.86,90.44 62.06,90.64 63.61,90.64 v1(64.01,91.05)
PDEC_I2C_IRQ#: length 133.3
  TOP w0.14: R363.2 184.08,74.49 184.08,73.45 184.15,73.38 v1(184.15,73.35) ; v1(84.66,78.37) 84.66,78.75 84.25,79.16 82.26,79.16 79.56,81.85 75.09,81.85 71.44,85.5 71.44,87.67 71.11,88 69.98,88 69.68,88.3 Q22.3 68.63,88.3 68.41,88.52 R193.1
  IN2 w0.089: v1(184.15,73.35) 183.67,73.83 181.64,73.83 180.56,74.91 173.86,74.91 173.56,74.61 173.56,74.22 173,73.67 168.39,73.67 167.83,74.22 166.21,74.22 165.75,74.69 165.26,74.69 164.63,74.06 161.43,74.06 160.74,74.75 159.34,74.75 158.36,75.73 158.36,76.19 157.54,77 154.12,77 153.41,76.3 152.08,76.3 151.58,75.8 150.78,75.8 149.48,74.5 145.84,74.5 145.44,74.11 142.85,74.11 142.46,74.5 138.19,74.5 136.81,75.88 132.05,75.88 131.29,75.12 119.38,75.12 119.38,75.12 116.17,75.12 114.95,76.34 108.65,76.34 106.82,78.18 102.79,78.18 101.88,77.27 94.3,77.27 91.88,79.69 89.76,79.69 88.01,77.94 87.32,77.94 86.81,78.45 84.74,78.45 v1(84.66,78.37)
PDEC_I2C_IRQ#_R: length 4.4
  TOP w0.14: R348.1 183.52,76.05 R363.1 183.29,75.5 182.84,75.05 C377.2 182.61,75.05 182.47,74.91 v1(182.47,74.37) 182.28,74.37 182.12,74.2 181.97,74.2 181.51,73.74 U23.98
PEG11_RXN0_SSD: length 160.3
  IN4 w0.086: v1(114.74,61.67) 114.46,61.96 114.46,63.01 116.94,65.49 118.35,66.23 118.88,66.97 119.91,67.7 120.64,68.74 121.94,69.64 122.6,70.44 123.19,70.68 123.69,70.68 124.32,70.79 125.57,70.57 126.37,70.72 126.83,70.91 128.07,72.14 128.98,72.14 130.52,72.41 131.62,72.22 132.47,72.36 133.77,72.14 135.55,72.14 135.82,72.25 140.23,76.67 140.23,78.57 140.47,79.01 140.73,79.18 142.35,79.53 143.64,79.3 144.79,79.5 146.04,79.28 147.09,79.47 148.32,79.25 148.34,79.24 149.73,79.49 150.54,79.82 154.33,79.82 155.26,79.66 156.28,79.84 157.44,79.64 158.69,79.86 159.94,79.64 161.03,79.83 163.03,79.48 167.1,79.48 168.1,79.7 168.81,79.58 168.89,79.61 169.76,79.97 170.74,79.8 171.59,79.95 173.02,79.7 174.07,79.88 175.15,79.69 176.78,79.98 178.22,79.73 179.24,79.91 180.38,79.71 182.73,80.12 183.4,80 184.53,80.2 187.44,80.2 189.94,82.7 190.23,83.4 190.23,88.09 190,88.65 189.91,88.74 189.65,89.37 189.65,90.73 189.87,91.26 190.08,91.48 190.23,91.83 190.23,102.23 188.85,103.61 188.85,107.31 184.99,111.17 184.99,119.96 178.49,126.47 178.49,129.1 178.35,129.91 178.54,130.99 178.38,131.89 178.6,133.14 178.28,134.93 177.6,135.91 176.01,137.03 175.48,137.79 174.23,138.66 173.6,139.56 173.06,139.93 171.98,141.02 171.06,141.02 170.65,141.43 170.65,141.63 170.31,141.97 169.2,141.97 169.09,142.09 169.09,142.33 169.19,142.43 v2(169.37,142.43)
  BOTTOM w0.102: v2(169.37,142.43) 169.08,142.14 U42.M22
  BOTTOM w0.14: R1008.1 112.74,60.66 114,60.66 114.54,61.2 114.54,61.47 v1(114.74,61.67)
PEG11_RXN0_SSD_R: length 2.9
  BOTTOM w0.14: R1008.2 111.93,60.79 111.56,60.79 111.07,60.3 110.73,60.3 110.61,60.18 CN13.41
PEG11_RXN1_SSD: length 162.4
  IN4 w0.086: v1(113.82,57.18) 114.17,57.18 114.28,57.29 114.28,58.07 114.47,59.17 114.38,59.72 114.67,60.42 115.79,61.54 115.79,63.5 116.94,64.65 116.94,64.66 117.75,64.99 119.05,65.66 119.51,66.33 120.55,67.06 121.28,68.1 122.31,68.82 122.78,69.49 123.44,69.84 123.61,69.84 123.77,69.86 124.56,69.73 125.63,69.91 126.04,69.84 127.02,70.25 127.02,70.25 128.31,71.54 135.9,71.54 135.99,71.58 140.3,75.89 142.72,76.89 143.3,76.79 144.55,77.01 145.18,76.9 145.9,76.9 146.05,76.75 148.15,76.75 149.05,77.22 149.55,77.94 150.82,78.82 151.68,79.18 154.09,79.18 154.87,78.95 156.18,79.18 157.36,78.98 158.8,79.23 160.02,79.01 161.11,79.2 163.13,78.85 167.12,78.85 167.12,78.85 168.05,79.01 169.71,78.73 170.16,78.78 171.01,79.13 171.93,79.23 172.09,79.2 172.86,79.07 174.07,79.28 175.15,79.09 176.78,79.38 178.22,79.12 179.24,79.3 180.38,79.1 182.42,79.46 183.15,79.33 184.45,79.56 187.65,79.56 190.48,82.39 190.82,83.22 190.82,88.26 190.53,88.96 190.46,89.03 190.25,89.55 190.25,90.44 190.5,91.05 190.69,91.24 190.82,91.57 190.82,102.48 189.5,103.81 189.5,107.5 185.59,111.41 185.59,120.21 179.19,126.61 179.19,129.16 179.02,130.12 179.21,131.2 179.09,131.89 179.21,132.54 179.31,133.14 178.89,135.54 178.29,136.69 177.42,137.55 176.09,138.1 175.78,138.55 175.78,138.55 175.49,138.96 174.76,139.47 174.3,140.13 173.26,140.86 172.82,141.49 172.41,141.9 171.13,141.9 170.94,142.08 170.94,142.36 170.81,142.49 v2(170.63,142.49)
  BOTTOM w0.102: v2(170.63,142.49) 170.38,142.25 U42.K22
  BOTTOM w0.14: R1044.1 112.87,57.74 113.91,57.74 114.05,57.6 114.05,57.4 v1(113.82,57.18)
PEG11_RXN1_SSD_R: length 2.9
  BOTTOM w0.14: CN13.29 110.61,57.18 110.73,57.3 111.18,57.3 111.62,57.74 111.93,57.74 R1044.2
PEG11_RXN2_SSD: length 174.6
  IN4 w0.086: v2(169.41,143.73) 169.22,143.54 169.22,143.33 169.32,143.23 172.07,143.23 172.64,143.81 172.64,144.15 173.17,144.67 176.73,144.67 178.41,143.98 178.5,143.88 180.19,141.47 180.87,140.99 180.88,140.98 180.89,140.98 182.46,138.75 182.52,138.61 183.29,135.95 183.34,135.06 183.28,134.71 183.28,134.2 183.47,133.14 183.25,131.89 183.47,130.64 183.27,129.54 183.28,129.51 183.28,128.13 189.55,121.85 189.55,113.06 193.67,108.94 193.67,105.25 194.79,104.12 194.79,81.24 194.24,79.92 189.33,75.01 187.57,75.01 187.32,74.75 183.04,74.75 182.42,74.5 181.6,74.5 180.97,73.87 168.68,73.87 168.65,73.88 168.65,73.88 167.99,74.15 167.3,74.15 165.5,73.41 151.16,73.41 148.94,71.19 147.5,70.6 145.95,70.87 144.5,70.61 143.17,70.85 142.05,70.6 139.17,67.72 137.76,67.13 134.72,67.13 134.33,66.97 133.97,66.72 133.69,66.32 133.57,66.2 133.25,65.74 132.25,65.04 131.87,64.5 131.05,63.95 130.42,63.69 126.63,63.69 122.36,59.42 119.65,59.42 118.52,58.3 117.48,57.56 116.95,56.82 116.17,56.49 115.01,56.49 114.71,56.19 114.71,55.89 v1(114.94,55.66)
  BOTTOM w0.102: U42.L24 169.73,143.41 v2(169.41,143.73)
  BOTTOM w0.14: R1062.1 112.87,54.69 114.32,54.69 114.65,55.02 114.65,55.37 v1(114.94,55.66)
PEG11_RXN2_SSD_R: length 2.9
  BOTTOM w0.14: CN13.17 110.61,54.18 110.73,54.3 111.21,54.3 111.61,54.69 111.93,54.69 R1062.2
PEG11_RXN3_SSD: length 176.9
  IN4 w0.086: v2(170.71,143.73) 170.89,143.91 170.89,144.21 171.16,144.48 172.12,144.48 172.51,144.86 172.51,145.11 173.11,145.72 176.63,145.72 177.92,145.18 178.73,144.78 178.97,144.53 179.45,143.85 179.46,143.84 179.47,143.83 179.48,143.81 180.59,142.22 181.24,141.81 183.13,139.12 183.79,137.51 184.13,135.63 184.13,135 184.04,134.48 184.04,134.27 184.24,133.14 184.02,131.89 184.24,130.64 184.04,129.5 184.04,128.46 190.31,122.18 190.31,113.37 194.48,109.21 194.48,105.54 195.55,104.47 195.55,80.98 194.94,79.52 189.67,74.24 187.9,74.24 187.62,73.97 183.27,73.97 182.71,73.74 181.91,73.74 181.28,73.11 168.48,73.11 167.79,73.39 167.49,73.39 165.68,72.65 151.48,72.65 148.47,69.63 148.02,69.63 146.34,69.93 145.09,69.71 144.12,69.88 142.19,69.55 142.16,69.54 138.79,66.16 138.08,65.87 134.59,65.87 134.28,65.71 134.05,65.37 132.79,64.49 132.46,64.01 132.23,63.79 131.27,63.15 130.54,62.85 126.87,62.85 122.69,58.66 120.06,58.66 118.12,56.72 118.12,56.2 v1(118.35,55.97)
  BOTTOM w0.102: v2(170.71,143.73) 171.04,143.41 U42.J24
  BOTTOM w0.14: R1084.1 112.8,51.58 114.53,51.58 118.14,55.19 118.14,55.76 v1(118.35,55.97)
PEG11_RXN3_SSD_R: length 2.9
  BOTTOM w0.14: CN13.5 110.61,51.18 110.73,51.3 111.3,51.3 111.65,51.65 111.93,51.65 R1084.2
PEG11_RXP0_SSD: length 160.3
  IN4 w0.086: v2(168.72,142.43) 168.93,142.22 168.93,142.02 169.13,141.81 170.24,141.81 170.49,141.56 170.49,141.36 171,140.86 171.91,140.86 172.96,139.81 173.48,139.44 174.11,138.54 175.36,137.67 175.89,136.91 177.48,135.79 178.13,134.87 178.43,133.14 178.21,131.89 178.37,130.99 178.18,129.91 178.32,129.09 178.32,126.4 184.83,119.89 184.83,111.1 188.69,107.24 188.69,103.54 190.06,102.17 190.06,91.86 189.94,91.57 189.73,91.36 189.49,90.77 189.49,89.33 189.77,88.64 189.86,88.56 190.06,88.06 190.06,83.43 189.8,82.8 187.37,80.36 184.51,80.36 183.4,80.17 182.73,80.29 180.38,79.88 179.24,80.08 178.22,79.9 176.78,80.15 175.15,79.86 174.07,80.05 173.02,79.87 171.59,80.12 170.74,79.97 169.75,80.14 169.7,80.12 168.89,79.79 168.79,79.75 168.09,79.87 167.08,79.65 163.05,79.65 161.03,80 159.94,79.81 158.69,80.03 157.44,79.81 156.28,80.01 155.26,79.83 154.34,79.99 150.51,79.99 149.69,79.65 148.52,79.45 148.34,79.41 147.09,79.63 146.04,79.45 144.79,79.67 143.64,79.47 142.35,79.7 140.66,79.34 140.34,79.12 140.07,78.61 140.07,76.73 135.72,72.39 135.51,72.3 133.78,72.3 132.47,72.53 131.62,72.38 130.52,72.58 128.97,72.3 128,72.3 126.74,71.05 126.33,70.87 125.57,70.74 124.32,70.96 123.68,70.85 123.16,70.85 122.5,70.58 121.82,69.77 120.52,68.86 119.8,67.82 118.76,67.09 118.24,66.36 116.84,65.62 114.29,63.08 114.29,61.88 114.08,61.67 v1(113.89,61.67)
  BOTTOM w0.102: v2(168.72,142.43) 168.72,142.21 U42.N22
  BOTTOM w0.14: R1004.1 112.62,61.09 112.79,60.92 113.89,60.92 114.28,61.31 114.28,61.53 114.14,61.67 v1(113.89,61.67)
PEG11_RXP0_SSD_R: length 2.9
  BOTTOM w0.14: R1004.2 111.93,61.06 111.45,61.06 110.96,60.56 110.73,60.56 110.61,60.68 CN13.43
PEG11_RXP1_SSD: length 162.4
  IN4 w0.086: v1(114.67,57.18) 114.44,57.41 114.44,58.05 114.64,59.17 114.55,59.7 114.81,60.32 115.96,61.47 115.96,63.44 117.04,64.52 117.82,64.84 119.16,65.54 119.63,66.21 120.67,66.94 121.4,67.98 122.43,68.7 122.89,69.36 123.48,69.67 123.63,69.67 123.77,69.7 124.56,69.56 125.63,69.75 126.06,69.67 127.11,70.11 128.38,71.38 135.94,71.38 136.08,71.44 140.39,75.75 142.74,76.72 143.3,76.62 144.55,76.84 144.86,76.79 145.17,76.73 145.83,76.73 145.98,76.59 148.19,76.59 149.16,77.09 149.67,77.82 150.9,78.68 151.72,79.02 154.06,79.02 154.86,78.78 156.18,79.02 157.36,78.81 158.8,79.06 160.02,78.84 161.11,79.04 163.11,78.68 167.14,78.68 168.05,78.84 169.7,78.56 170.2,78.62 171.06,78.97 171.93,79.06 172.09,79.03 172.86,78.9 174.07,79.11 175.15,78.92 176.78,79.21 178.22,78.96 179.24,79.14 180.38,78.94 182.42,79.29 183.15,79.17 184.47,79.4 187.72,79.4 190.62,82.3 190.99,83.19 190.99,88.29 190.67,89.05 190.6,89.12 190.41,89.58 190.41,90.41 190.64,90.95 190.83,91.15 190.99,91.53 190.99,102.55 189.66,103.87 189.66,107.57 185.75,111.48 185.75,120.28 179.35,126.68 179.35,129.18 179.19,130.12 179.38,131.2 179.26,131.89 179.48,133.14 179.05,135.59 178.42,136.79 177.52,137.69 176.2,138.24 175.61,139.08 174.88,139.59 174.42,140.25 173.38,140.97 172.94,141.6 172.48,142.06 171.19,142.06 171.11,142.15 171.11,142.27 v2(171.3,142.46)
  BOTTOM w0.102: U42.J22 171.04,142.2 v2(171.3,142.46)
  BOTTOM w0.14: R1028.1 112.87,58.01 114.02,58.01 114.31,57.71 114.31,57.54 v1(114.67,57.18)
PEG11_RXP1_SSD_R: length 2.9
  BOTTOM w0.14: CN13.31 110.61,57.68 110.73,57.56 111.07,57.56 111.51,58.01 111.93,58.01 R1028.2
PEG11_RXP2_SSD: length 174.6
  IN4 w0.086: v1(114.09,55.66) 114.46,55.66 114.54,55.75 114.54,56.26 114.94,56.66 116.14,56.66 116.85,56.95 117.36,57.68 118.42,58.42 119.58,59.59 122.3,59.59 126.56,63.86 130.38,63.86 130.97,64.1 131.75,64.62 132.13,65.16 133.13,65.86 133.44,66.31 133.57,66.43 133.85,66.83 133.87,66.85 134.25,67.12 134.69,67.3 137.73,67.3 139.08,67.86 141.97,70.75 142.19,70.8 143.16,71.02 144.5,70.78 145.95,71.04 147.48,70.77 148.84,71.33 151.09,73.58 165.47,73.58 167.26,74.32 168.03,74.32 168.72,74.03 180.9,74.03 181.53,74.66 182.39,74.66 183,74.92 187.25,74.92 187.5,75.17 189.26,75.17 194.1,80.01 194.62,81.27 194.62,104.06 193.5,105.18 193.5,108.88 189.39,112.99 189.39,121.78 183.11,128.06 183.11,129.5 183.11,129.54 183.3,130.64 183.08,131.89 183.3,133.14 183.11,134.19 183.11,134.73 183.17,135.07 183.13,135.93 182.36,138.55 182.31,138.67 180.79,140.83 180.78,140.83 180.75,140.87 180.07,141.35 178.37,143.78 178.31,143.84 176.69,144.51 173.24,144.51 172.81,144.08 172.81,143.74 172.14,143.07 169.25,143.07 169.06,143.26 169.06,143.61 168.93,143.73 v2(168.76,143.73)
  BOTTOM w0.102: U42.M24 169.08,143.41 v2(168.76,143.73)
  BOTTOM w0.14: R1059.1 112.87,54.96 114.21,54.96 114.38,55.13 114.38,55.37 v1(114.09,55.66)
PEG11_RXP2_SSD_R: length 2.9
  BOTTOM w0.14: R1059.2 111.93,54.96 111.5,54.96 111.1,54.56 110.73,54.56 110.61,54.68 CN13.19
PEG11_RXP3_SSD: length 176.9
  IN4 w0.086: v2(171.36,143.73) 171.19,143.73 171.06,143.86 171.06,144.15 171.22,144.31 172.19,144.31 172.67,144.79 172.67,145.04 173.18,145.55 176.6,145.55 177.85,145.03 178.63,144.64 178.85,144.43 179.33,143.74 179.34,143.71 179.35,143.71 180.48,142.1 181.12,141.69 182.98,139.04 183.64,137.47 183.96,135.61 183.96,135.01 183.87,134.5 183.87,134.25 184.07,133.14 183.85,131.89 184.07,130.64 183.87,129.51 183.87,128.39 190.15,122.12 190.15,113.3 194.31,109.14 194.31,105.47 195.38,104.4 195.38,81.01 195.09,80.31 194.8,79.61 189.6,74.41 187.83,74.41 187.56,74.14 183.23,74.14 182.67,73.9 181.84,73.9 181.21,73.27 168.52,73.27 167.83,73.56 167.46,73.56 165.65,72.81 151.41,72.81 148.4,69.8 148.03,69.8 146.34,70.1 145.09,69.87 144.12,70.05 142.19,69.71 142.08,69.7 138.69,66.31 138.05,66.04 134.55,66.04 134.17,65.84 133.93,65.49 132.68,64.61 132.33,64.12 132.13,63.92 131.19,63.29 130.51,63.01 126.8,63.01 122.62,58.83 119.99,58.83 117.95,56.79 117.95,55.96 117.84,55.85 117.62,55.85 v1(117.5,55.97)
  BOTTOM w0.102: v2(171.36,143.73) 171.69,143.41 U42.H24
  BOTTOM w0.14: R1071.1 112.62,51.98 112.76,51.84 114.42,51.84 117.87,55.3 117.87,55.83 117.73,55.97 v1(117.5,55.97)
PEG11_RXP3_SSD_R: length 2.9
  BOTTOM w0.14: CN13.7 110.61,51.68 110.73,51.56 111.19,51.56 111.54,51.91 111.93,51.91 R1071.2
PEG11_SSD_DBG#: length 159.6
  TOP w0.14: R375.1 216.56,74.74 v1(215.85,75.45) ; U25.2 95.94,63.34 94.72,62.12 93.88,62.12 92.84,63.16 92.84,77.39 v1(94.08,78.64)
  IN2 w0.089: v1(215.85,75.45) 215.16,76.14 213.76,76.14 213.17,75.56 213.17,74.76 212.06,73.65 211.68,73.65 210.66,72.63 210.66,72 210.19,71.53 209.51,71.53 209.38,71.67 208.94,71.67 208.61,71.34 207.99,71.34 207.55,71.78 206.86,71.78 205.56,70.48 202.98,70.48 201.97,69.47 200.47,69.47 198.75,71.18 195.05,71.18 192.38,73.86 190.9,73.86 190.64,73.6 188.35,73.6 188.04,73.9 187.36,74.59 182,74.59 180.91,75.67 173.54,75.67 172.92,75.06 169.79,75.06 169.71,74.98 166.53,74.98 166.06,75.45 164.51,75.45 164.05,74.98 162.27,74.98 162.02,75.23 162.02,75.53 161.78,75.77 160.98,75.77 158.98,77.77 153.79,77.77 153.08,77.06 151.76,77.06 151.26,76.56 150.46,76.56 149.16,75.26 145.52,75.26 145.13,74.87 143.17,74.87 142.78,75.26 138.54,75.26 137.16,76.64 130.1,76.64 129.35,75.88 119.7,75.88 119.7,75.88 116.49,75.88 114.67,77.7 112.27,77.7 111.71,78.26 110.93,78.26 109.58,79.61 105.43,79.61 104.88,80.16 103.69,80.16 101.56,78.03 99.38,78.03 98.3,79.11 96.99,79.11 96.51,78.64 v1(94.08,78.64)
  BOTTOM w0.102: U49.AL9 215.89,75.41 v1(215.85,75.45)
PEG11_TXN0_SSD: length 156.5
  IN4 w0.086: v1(118,63.44) 117.78,63.66 117.78,63.86 118.01,64.08 118.76,64.08 119.81,64.51 120.44,65.41 121.48,66.14 122.2,67.18 123.24,67.91 123.64,68.48 124.04,68.68 124.75,68.68 125.09,68.74 125.69,68.64 127.05,68.88 128.07,69.74 128.43,70.26 128.54,70.37 128.88,70.51 129.2,70.54 130.05,70.39 131.34,70.62 131.54,70.62 131.74,70.62 136.09,70.62 136.51,70.79 139.26,73.55 140.25,74.21 141.5,74.21 141.8,74.26 142.74,74.09 143.99,74.31 144.6,74.21 145.15,74.21 145.43,74.48 145.6,74.6 146.07,75.27 146.58,75.63 146.77,75.83 149.12,75.83 151.09,77.8 152.65,77.8 153.26,77.91 153.87,78.01 154.7,77.87 156.09,78.11 157.56,77.85 159.02,78.11 160.04,77.93 160.8,78.07 162.69,77.73 163.05,77.58 163.53,77.52 163.69,77.55 163.9,77.62 164.07,77.71 164.16,77.74 164.85,77.85 165.28,77.83 165.69,77.9 167.37,77.9 167.72,77.84 168.46,77.97 168.89,77.9 169.47,77.8 171.8,77.8 172.09,77.85 172.8,77.97 173.71,77.81 174.43,77.81 174.89,77.89 175.21,77.84 177.94,77.84 179.5,78.11 180.72,77.9 181.81,78.35 187.8,78.35 191.36,81.91 191.75,82.85 191.75,88.79 191.54,89.3 191.33,89.51 191.17,89.9 191.17,90.12 191.38,90.62 191.58,90.82 191.75,91.23 191.75,102.86 190.48,104.14 190.48,107.83 186.51,111.8 186.51,120.59 180.11,126.99 180.11,129.24 179.99,129.96 180.18,131.04 180.03,131.89 180.25,133.14 180.19,133.48 180.19,133.48 180.14,133.79 180.12,133.94 180.12,134.74 179.89,135.89 178.69,138.13 178.01,138.61 177.5,139.34 175.81,140.04 175.18,140.94 174.66,141.3 174.51,141.45 174.51,141.99 v2(174.72,142.2)
  BOTTOM w0.079: v2(174.72,142.2) 174.72,142.13 U42.D22
  BOTTOM w0.14: v1(118,63.44) 117.69,63.12 117.69,62.94 117.39,62.64 114.08,62.64 113.76,62.31 112.87,62.31 C781.2
PEG11_TXN0_SSD_R: length 2.9
  BOTTOM w0.14: C781.1 111.95,62.29 111.75,62.29 111.26,61.8 110.73,61.8 110.61,61.68 CN13.47
PEG11_TXN1_SSD: length 158.8
  IN4 w0.086: v1(117.85,61.68) 117.68,61.68 117.41,61.42 117.41,61.19 117.61,61 118.4,61 118.96,61.56 118.96,61.86 119.6,62.5 119.92,62.95 120.88,63.62 121.46,64.46 122.5,65.19 122.89,65.74 123.5,65.99 125.55,66.35 126.32,66.22 127.03,66.34 128.14,66.15 128.54,66.15 128.99,66.46 129.49,66.7 130.32,67.54 131.47,68.08 132.37,68.98 132.94,69.25 133.45,69.61 133.68,69.84 134.14,70.03 136.21,70.03 136.88,70.3 139.58,73.01 140.07,73.27 141.03,73.46 145.38,73.46 147.16,75.23 149.4,75.23 151.37,77.2 160.28,77.2 161.18,76.83 163.14,76.83 163.98,77 164.57,77.16 164.58,77.16 164.96,77.2 181.83,77.2 182.38,77.75 188.08,77.75 189.52,79.2 189.97,79.2 191.97,81.21 192.34,82.1 192.34,103.11 191.07,104.38 191.07,108.08 187.11,112.04 187.11,120.84 180.72,127.23 180.72,129.29 180.65,129.67 180.84,130.75 180.64,131.88 180.87,133.14 180.72,133.97 180.72,135.17 180.43,136.6 179.52,138.04 179.09,138.65 178.34,139.17 177.78,139.97 176.71,140.53 176.34,140.89 176.34,141.87 v2(176.01,142.2)
  BOTTOM w0.079: v2(176.01,142.2) 176.01,141.94 175.85,141.77 U42.B22
  BOTTOM w0.14: v1(117.85,61.68) 117.59,61.42 117.59,60.97 117.26,60.64 115.28,60.64 113.88,59.24 112.85,59.24 C791.2
PEG11_TXN1_SSD_R: length 2.9
  BOTTOM w0.14: CN13.35 110.61,58.68 110.73,58.8 111,58.8 111.47,59.27 111.93,59.27 C791.1
PEG11_TXN2_SSD: length 168.7
  IN4 w0.086: v2(173.48,143.12) 173.33,143.12 173.22,143.23 173.22,143.46 173.3,143.55 176.66,143.55 177.51,143.2 179.5,140.83 180.22,140.32 181.64,138.29 182.38,134.97 182.33,134.63 182.33,134.12 182.5,133.14 182.28,131.89 182.5,130.64 182.31,129.54 182.33,129.43 182.33,127.77 188.63,121.47 188.63,112.67 192.73,108.58 192.73,104.88 193.86,103.74 193.86,81.44 193.46,80.47 188.95,75.96 187.2,75.96 186.92,75.68 182.86,75.68 182.24,75.42 180.96,75.42 180.08,75.27 179.36,75.39 178.06,75.16 176.63,75.41 175.39,75.2 174.21,75.4 173.04,75.2 172.09,75.37 171.96,75.39 171.17,75.25 170.2,75.42 166.28,75.42 165.14,74.95 164.45,75.07 163.06,74.83 162.09,75 160.88,74.79 159.91,74.96 158.05,74.37 150.69,74.37 149.58,73.26 147.7,73.26 146.26,71.82 141.96,71.82 139.17,69.03 137.91,68.5 134.86,68.5 134.36,68.3 134.18,68.12 133.47,67.63 132.98,66.92 132.86,66.8 132.66,66.51 131.54,65.73 131.13,65.13 130.15,64.63 126.25,64.63 121.97,60.35 119.22,60.35 117.94,59.07 116.74,59.07 116.41,59.4 116.41,59.7 116.57,59.87 v1(116.9,59.87)
  BOTTOM w0.079: U42.E23 173.71,142.89 v2(173.48,143.12)
  BOTTOM w0.14: C806.2 112.87,56.22 113.49,56.22 113.59,56.32 115.55,56.32 116.54,57.3 116.54,59.73 116.68,59.87 v1(116.9,59.87)
PEG11_TXN2_SSD_R: length 2.9
  BOTTOM w0.14: CN13.23 110.61,55.68 110.73,55.8 111.26,55.8 111.68,56.22 111.93,56.22 C806.1
PEG11_TXN3_SSD: length 165.1
  IN4 w0.086: v1(121.08,61.67) 120.72,61.32 120.72,61.19 120.81,61.11 121.66,61.11 122.79,62.24 123.44,63.17 124.2,63.7 125.02,64.86 125.77,65.39 129.69,65.39 132.07,67.06 132.79,68.1 133.71,68.74 133.86,68.89 133.86,68.89 134.06,69.09 134.64,69.27 136.36,69.27 137.39,69.69 140.09,72.39 140.59,72.6 145.85,72.6 147.72,74.47 149.72,74.47 150.56,75.32 151.07,75.67 151.37,76.1 152.13,76.42 153.22,76.23 154.36,76.43 155.34,76.25 156.19,76.4 160.11,76.4 160.75,76.13 162.7,75.75 163.09,75.71 163.48,75.71 164.62,76.18 182.09,76.18 182.71,76.44 183.64,76.44 184.17,76.97 188.42,76.97 189.84,78.39 190.25,78.39 192.74,80.88 193.1,81.74 193.1,103.43 191.96,104.56 191.96,108.26 187.87,112.36 187.87,121.15 181.48,127.54 181.48,129.36 181.44,129.54 181.64,130.64 181.42,131.89 181.64,133.14 181.48,134.04 181.48,134.71 181.52,134.97 181.22,136.69 180.88,137.51 179.45,139.93 178.38,140.68 177.13,142.46 176.91,142.58 175.84,142.58 175.63,142.78 175.63,142.89 v2(175.35,143.17)
  BOTTOM w0.079: U42.C23 175.01,142.82 v2(175.35,143.17)
  BOTTOM w0.14: v1(121.08,61.67) 120.75,61.34 120.75,60.15 116.5,55.9 116.5,54.85 115.11,53.45 114.64,53.45 114.35,53.17 112.87,53.17 C821.2
PEG11_TXN3_SSD_R: length 2.9
  BOTTOM w0.14: C821.1 111.93,53.17 111.65,53.17 111.28,52.8 110.73,52.8 110.61,52.68 CN13.11
PEG11_TXP0_SSD: length 156.5
  IN4 w0.086: v2(174.02,142.2) 174.26,142.2 174.35,142.12 174.35,141.38 174.55,141.17 175.06,140.82 175.7,139.91 175.7,139.9 177.39,139.2 177.89,138.49 178.57,138.02 179.74,135.83 179.96,134.72 179.96,133.93 179.97,133.76 180.08,133.14 179.86,131.89 180.01,131.04 179.82,129.96 179.95,129.23 179.95,126.93 186.35,120.52 186.35,111.73 190.31,107.77 190.31,104.07 191.58,102.8 191.58,91.27 191.44,90.91 191.24,90.72 191.01,90.15 191.01,89.86 191.19,89.41 191.4,89.21 191.58,88.76 191.58,82.88 191.22,82 187.74,78.52 181.78,78.52 180.7,78.07 179.5,78.28 177.92,78 175.22,78 174.89,78.06 174.42,77.98 173.73,77.98 172.8,78.14 172.09,78.02 171.79,77.96 169.49,77.96 168.46,78.14 167.72,78.01 167.39,78.07 165.67,78.07 165.27,78 164.84,78.01 164.11,77.9 164.01,77.86 163.84,77.77 163.65,77.71 163.53,77.69 163.09,77.74 162.73,77.89 160.8,78.23 160.04,78.1 159.02,78.28 157.56,78.02 156.09,78.28 154.7,78.04 153.87,78.18 152.63,77.96 151.02,77.96 149.05,75.99 146.71,75.99 146.47,75.76 145.95,75.39 145.48,74.72 145.32,74.61 145.08,74.37 144.62,74.37 143.99,74.48 142.74,74.26 141.8,74.43 141.48,74.37 140.2,74.37 139.16,73.68 136.42,70.94 136.05,70.78 131.74,70.78 131.54,70.78 131.33,70.78 130.05,70.56 129.2,70.71 128.84,70.67 128.45,70.51 128.31,70.36 127.95,69.85 126.97,69.03 125.69,68.81 125.09,68.91 124.73,68.85 124,68.85 123.53,68.6 123.13,68.02 122.09,67.3 121.36,66.26 120.32,65.53 119.7,64.65 118.73,64.25 117.94,64.25 117.62,63.93 117.62,63.64 117.42,63.44 v1(117.15,63.44)
  BOTTOM w0.079: U42.E22 174.02,142.09 v2(174.02,142.2)
  BOTTOM w0.14: v1(117.15,63.44) 117.42,63.17 117.42,63.05 117.28,62.91 113.97,62.91 113.65,62.58 112.87,62.58 C777.2
PEG11_TXP0_SSD_R: length 2.9
  BOTTOM w0.14: CN13.49 110.61,62.18 110.73,62.06 111.15,62.06 111.64,62.56 111.9,62.56 C777.1
PEG11_TXP1_SSD: length 158.8
  IN4 w0.086: v1(117,61.68) 117.25,61.43 117.25,61.12 117.54,60.83 118.47,60.83 119.13,61.49 119.13,61.79 119.73,62.39 120.04,62.83 121,63.5 121.58,64.34 122.62,65.07 123,65.61 123.55,65.83 125.55,66.18 126.32,66.05 127.03,66.17 128.12,65.98 128.59,65.98 129.07,66.32 129.58,66.56 130.42,67.4 131.57,67.94 132.46,68.84 132.74,68.97 132.74,68.97 133.02,69.11 133.56,69.48 133.77,69.7 134.17,69.86 136.24,69.86 136.97,70.16 139.68,72.87 140.12,73.11 141.05,73.29 145.45,73.29 147.23,75.07 149.47,75.07 151.44,77.04 160.25,77.04 161.14,76.67 163.15,76.67 164.02,76.84 164.6,77 164.97,77.03 181.9,77.03 182.45,77.59 188.14,77.59 189.59,79.03 190.04,79.03 192.11,81.11 192.51,82.06 192.51,103.18 191.24,104.45 191.24,108.15 187.27,112.11 187.27,120.91 180.88,127.3 180.88,129.31 180.82,129.67 181.01,130.75 180.81,131.88 181.03,133.14 180.88,133.99 180.88,135.18 180.59,136.65 180.59,136.67 179.66,138.13 179.21,138.77 178.46,139.29 177.9,140.1 176.8,140.67 176.51,140.96 176.51,141.88 v2(176.83,142.2)
  BOTTOM w0.079: v2(176.83,142.2) 176.73,142.2 U42.A22
  BOTTOM w0.14: v1(117,61.68) 117.32,61.36 117.32,61.08 117.15,60.91 115.17,60.91 113.77,59.51 112.9,59.51 C783.2
PEG11_TXP1_SSD_R: length 2.9
  BOTTOM w0.14: C783.1 111.93,59.53 111.35,59.53 110.89,59.07 110.73,59.07 110.61,59.18 CN13.37
PEG11_TXP2_SSD: length 168.7
  IN4 w0.086: v1(116.05,59.87) 116.25,59.67 116.25,59.33 116.67,58.9 118.01,58.9 119.29,60.18 122.04,60.18 126.32,64.46 130.19,64.46 131.24,65.01 131.66,65.61 132.78,66.39 132.98,66.69 133.11,66.81 133.59,67.51 134.29,68 134.45,68.16 134.89,68.34 137.95,68.34 139.27,68.89 142.03,71.65 146.32,71.65 147.77,73.1 149.65,73.1 150.76,74.21 158.08,74.21 159.92,74.79 160.88,74.62 162.09,74.83 163.06,74.66 164.45,74.9 165.16,74.78 166.31,75.26 170.18,75.26 171.17,75.08 171.96,75.22 172.09,75.2 173.04,75.03 174.21,75.24 175.39,75.03 176.63,75.25 178.06,75 179.36,75.23 180.08,75.1 180.97,75.26 182.27,75.26 182.89,75.52 186.99,75.52 187.27,75.8 189.02,75.8 193.6,80.38 194.03,81.4 194.03,103.81 192.89,104.95 192.89,108.64 188.79,112.74 188.79,121.54 182.49,127.84 182.49,129.45 182.47,129.54 182.67,130.64 182.45,131.89 182.67,133.14 182.49,134.13 182.49,134.62 182.55,134.97 181.8,138.36 180.34,140.44 179.61,140.95 177.61,143.33 176.69,143.71 173.24,143.71 173.05,143.53 173.05,143.31 v2(172.86,143.12)
  BOTTOM w0.079: U42.F23 173.05,142.93 v2(172.86,143.12)
  BOTTOM w0.14: C804.2 112.87,56.48 113.38,56.48 113.48,56.59 115.44,56.59 116.27,57.41 116.27,59.64 v1(116.05,59.87)
PEG11_TXP2_SSD_R: length 2.9
  BOTTOM w0.14: C804.1 111.93,56.48 111.57,56.48 111.15,56.06 110.73,56.06 110.61,56.18 CN13.25
PEG11_TXP3_SSD: length 165.1
  IN4 w0.086: v1(120.23,61.67) 120.56,61.34 120.56,61.12 120.74,60.94 121.72,60.94 122.92,62.14 123.56,63.05 124.32,63.58 125.13,64.74 125.82,65.22 129.74,65.22 132.18,66.94 132.91,67.98 133.81,68.61 134.14,68.94 134.67,69.1 136.39,69.1 137.49,69.55 140.18,72.25 140.63,72.43 145.91,72.43 147.79,74.31 149.79,74.31 150.67,75.19 151.19,75.55 151.47,75.96 152.15,76.24 153.22,76.06 154.36,76.26 155.34,76.08 156.21,76.24 160.08,76.24 160.71,75.98 162.67,75.59 163.08,75.55 163.52,75.55 164.65,76.02 182.12,76.02 182.74,76.27 183.71,76.27 184.24,76.8 188.49,76.8 189.91,78.22 190.32,78.22 192.89,80.79 193.27,81.71 193.27,103.49 192.13,104.63 192.13,108.33 188.03,112.43 188.03,121.22 181.64,127.61 181.64,129.37 181.61,129.54 181.8,130.64 181.58,131.89 181.81,133.14 181.64,134.06 181.64,134.69 181.69,134.97 181.38,136.74 181.03,137.59 179.58,140.05 178.49,140.8 177.24,142.59 176.95,142.74 175.91,142.74 175.8,142.84 175.8,142.97 v2(176,143.16)
  BOTTOM w0.079: U42.B23 175.66,142.82 v2(176,143.16)
  BOTTOM w0.14: v1(120.23,61.67) 120.48,61.42 120.48,60.26 116.24,56.01 116.24,54.96 115,53.72 114.52,53.72 114.24,53.44 112.87,53.44 C818.2
PEG11_TXP3_SSD_R: length 2.9
  BOTTOM w0.14: C818.1 111.93,53.44 111.54,53.44 111.17,53.06 110.73,53.06 110.61,53.18 CN13.13
PEG12_RXN0_SSD: length 155.4
  IN1 w0.086: v1(114.11,85.9) 114.4,86.2 114.72,86.2 114.9,86.02 115.65,85.49 116.21,84.69 117.01,84.13 117.9,82.86 118.64,82.34 119.56,81.96 135.61,81.96 137.3,81.26 138.05,81.26 138.3,81.36 138.78,81.84 139.23,82.03 148.88,82.03 149.98,81.57 149.98,81.57 150.96,81.17 159.45,81.17 160.04,81.22 160.51,81.32 186.13,81.32 187.29,82.09 190.07,84.87 190.23,85.26 190.23,88.14 190.06,88.54 189.83,88.77 189.61,89.31 189.61,90.76 189.72,91.03 190.08,91.39 190.23,91.74 190.23,106.02 189.78,107.12 189.18,107.54 189.16,107.56 188.45,108.58 187.21,109.45 186.48,110.49 185.64,111.08 184.92,112.11 184.84,112.16 183.76,113.24 183.34,114.26 183,115.07 183,115.59 182.85,117.35 182.99,118.2 182.73,119.7 182.61,120.77 182.14,122.08 181.93,122.39 181.33,122.99 179.75,125.36 179.07,127 178.87,128.13 179.07,129.3 178.8,130.86 179.05,132.31 178.83,133.6 178.94,135.14 178.76,136.08 178.35,138.42 177.42,139.75 176.15,140.64 175.77,141.18 173.25,141.68 172.95,141.8 172.73,142.03 172.73,142.64 172.25,143.12 168.1,143.12 167.74,143.48 167.74,144.02 167.97,144.26 168.98,144.26 169.21,144.49 169.21,144.7 v2(169.41,144.9)
  BOTTOM w0.102: U42.M26 169.41,144.54 v2(169.41,144.9)
  BOTTOM w0.14: v1(114.11,85.9) 113.81,86.19 113.51,86.19 R872.1
PEG12_RXN0_SSD_R: length 3.7
  BOTTOM w0.14: R872.2 112.6,86.15 112.06,86.15 111.24,85.33 110.72,85.33 110.62,85.23 CN6.41
PEG12_RXN1_SSD: length 160.5
  IN1 w0.086: v1(170.71,144.9) 170.86,144.9 171.03,144.73 171.03,144.44 171.21,144.26 172.48,144.26 172.72,144.5 177.32,144.5 179.96,141.86 180.57,140.69 181.28,136.57 181.12,135.65 181.27,134.79 181.05,133.54 181.33,131.94 181.11,130.67 181.31,129.52 181.24,129.07 181.24,127.56 181.3,127.17 181.67,126.29 182.75,124.67 184.04,123.38 184.53,122.78 184.97,121.72 185.11,120.44 184.94,119.45 185.18,118.07 185.05,117.34 185.17,116.1 185.22,115.6 185.24,115.51 185.46,114.98 186.04,114.12 186.09,114.08 186.61,113.56 186.92,113.12 187.24,112.67 188.07,112.08 188.8,111.04 190.04,110.17 190.75,109.15 190.77,109.13 191.54,108.59 191.57,108.56 192.34,106.69 192.34,84.56 192.04,83.83 188.64,80.43 188.55,80.32 188.4,80.21 188.09,79.68 187.26,78.66 187.22,78.62 187.04,78.56 186.56,78.53 184.63,78.54 184.1,78.56 183.48,78.9 182.42,79.14 181.03,78.89 179.75,79.12 178.72,78.94 177.53,79.15 170.72,79.15 170.38,78.8 163.07,78.8 162.47,79.05 151.86,79.05 150.99,78.79 150.48,78.79 150.29,78.87 149.5,79.39 148.38,79.86 140.25,79.86 139.89,79.71 139.5,79.32 139.08,79.14 136.35,79.14 134.86,79.76 134.21,79.64 133.28,79.81 132.16,79.61 130.82,79.84 128.24,79.84 127.14,79.65 126.11,79.83 124.71,79.59 123.41,79.81 122.27,79.61 121.11,79.82 120.39,79.69 119.76,79.69 119.22,79.47 118.91,79.16 118.91,79 v1(118.5,78.59)
  BOTTOM w0.102: v1(170.71,144.9) 170.38,144.57 U42.K26
  BOTTOM w0.14: v1(118.5,78.59) 118.76,78.59 118.91,78.73 118.91,79.89 116.26,82.53 114.52,82.53 113.91,83.14 113.51,83.14 R908.1
PEG12_RXN1_SSD_R: length 3.7
  BOTTOM w0.14: CN6.29 110.61,82.23 110.73,82.35 111.18,82.35 111.97,83.14 112.56,83.14 R908.2
PEG12_RXN2_SSD: length 175.6
  IN1 w0.086: v2(169.41,146.07) 169.24,146.07 169.11,146.2 169.11,146.4 169.27,146.56 169.92,146.56 171,147.64 172.49,147.64 172.81,147.96 178.1,147.96 179.05,147.29 179.42,146.76 180.45,146.04 181.16,145.02 182.15,144.33 182.82,143.37 183.31,143.02 184.25,141.85 184.47,140.6 184.36,139.97 184.75,137.75 184.35,135.53 184.49,134.75 184.27,133.5 184.63,131.42 184.47,130.51 184.77,128.86 184.62,128.04 184.7,127.62 184.99,127.06 187.44,124.6 187.44,124.43 187.62,124.26 188.2,122.84 188.2,122.33 188.43,121.05 188.18,119.64 188.26,119.18 188.35,118.66 188.35,118.05 188.47,116.85 188.72,116.24 189.24,115.57 189.43,115.21 189.47,115.09 190.62,114.29 191.44,113.12 191.6,112.89 192.64,112.17 193.1,111.5 193.32,111.2 194.01,110.71 194.44,110.11 195.38,107.83 195.38,83.41 194.99,82.46 194.22,81.69 193.1,80.03 188.77,75.69 187.53,75.18 184.32,74.83 183.11,74.87 181.12,75.23 180.66,75.15 179.38,75.38 178.19,75.17 176.95,75.39 175.68,75.16 174.44,75.38 173.3,75.18 172.22,75.37 170.89,75.14 170.22,75.26 169.43,75.12 168.23,75.39 167.05,75.18 166.47,75.28 165.89,75.38 165.4,75.33 164.11,74.78 161.59,74.78 158.48,75.4 156.3,75.4 155.89,75.57 144.83,75.57 143.96,75.4 138.1,75.4 137.29,75.24 136.41,74.88 135.44,74.77 134.84,74.87 133.69,74.67 132.44,74.89 131.19,74.67 130.26,74.84 129.01,74.61 127.43,74.89 126.18,74.67 124.93,74.89 123.68,74.67 122.43,74.89 121.18,74.67 119.93,74.89 119.32,74.79 118.91,74.87 118.67,74.97 118.08,75.09 117.39,75.09 117.16,75.18 114.83,77.52 114.22,78.42 113.99,78.99 113.99,79.46 114.02,79.53 114.56,80.08 114.76,80.56 114.76,80.83 114.9,80.97 v1(115.22,80.97)
  BOTTOM w0.102: U42.L28 169.73,145.74 v2(169.41,146.07)
  BOTTOM w0.14: R919.1 113.51,80.09 114.54,80.09 114.84,80.39 114.84,80.83 114.98,80.97 v1(115.22,80.97)
PEG12_RXN2_SSD_R: length 3.7
  BOTTOM w0.14: CN6.17 110.61,79.23 110.73,79.35 111.37,79.35 112.11,80.09 112.56,80.09 R919.2
PEG12_RXN3_SSD: length 166.9
  IN1 w0.086: v2(170.71,146.07) 170.9,146.26 170.9,146.48 171.41,146.99 172.4,146.99 173.04,147.63 177.7,147.63 183.43,141.9 183.71,140.32 183.65,139.93 184.07,137.46 183.74,135.54 183.88,134.73 183.66,133.48 183.96,131.8 183.76,130.7 184.1,128.77 183.95,127.89 184.02,127.48 184.37,126.81 186.84,124.34 187.56,122.6 187.56,121.88 187.76,120.75 187.66,120.21 187.66,120.21 187.57,119.67 187.7,118.93 187.7,118.62 187.71,117.68 187.84,116.46 187.97,116.15 188.74,115.24 189,114.67 189.89,114.04 190.54,113.12 190.82,112.71 191.86,111.99 192.57,110.97 192.59,110.95 193.18,110.53 193.93,109.78 194.79,107.71 194.79,83.61 194.43,82.74 193.71,82.02 193.47,81.75 192.14,80 192.13,79.99 188.39,76.25 187.31,75.77 183.48,75.6 182.58,75.85 181.49,76 165.06,76 163.45,75.49 161.33,75.86 160.66,75.74 159.56,76.2 156.38,76.2 155.75,76.17 145.38,76.17 145.35,76.18 144.1,76.7 143.74,76.7 142.65,76.51 141.58,76.7 140.44,76.5 139.51,76.66 138.61,76.5 138.38,76.54 136.94,76.24 136.29,75.81 135.58,75.59 135.18,75.59 134.56,75.48 133.31,75.7 131.46,75.37 129.98,75.63 129.33,75.52 128.3,75.7 127.05,75.48 125.8,75.7 124.55,75.48 123.3,75.7 122.05,75.48 120.8,75.7 119.96,75.55 119.11,75.7 117.48,75.7 116.81,76.38 116.81,76.5 116.63,76.68 v1(116.52,76.68)
  BOTTOM w0.102: U42.J28 171.04,145.74 v2(170.71,146.07)
  BOTTOM w0.14: v1(116.52,76.68) 116.73,76.89 116.73,77.17 116.25,77.66 115.8,77.66 115.72,77.58 114.59,77.58 114.1,77.09 113.55,77.09 R934.1
PEG12_RXN3_SSD_R: length 3.6
  BOTTOM w0.14: CN6.5 110.61,76.23 110.73,76.35 111.23,76.35 111.93,77.05 112.56,77.05 R934.2
PEG12_RXP0_SSD: length 155.4
  IN1 w0.086: v1(114.11,86.75) 114.11,86.6 114.34,86.36 114.79,86.36 115,86.15 115.77,85.61 116.33,84.81 117.13,84.25 118.02,82.97 118.72,82.49 119.59,82.12 135.64,82.12 137.34,81.42 138.01,81.42 138.21,81.5 138.69,81.98 139.19,82.19 148.91,82.19 150.08,81.71 150.99,81.33 159.44,81.33 160.01,81.39 160.5,81.48 186.08,81.48 187.19,82.22 189.93,84.96 190.06,85.29 190.06,88.11 189.92,88.44 189.69,88.68 189.44,89.28 189.44,90.79 189.58,91.12 189.94,91.48 190.06,91.77 190.06,105.99 189.64,107.01 189.06,107.42 189.04,107.44 188.33,108.46 187.09,109.33 186.36,110.37 185.52,110.96 184.8,111.99 184.73,112.03 183.62,113.15 183.21,114.13 182.83,115.04 182.83,115.58 182.68,117.36 182.83,118.2 182.57,119.68 182.45,120.73 181.99,122.01 181.8,122.29 181.2,122.89 179.6,125.28 178.91,126.95 178.7,128.13 178.91,129.3 178.63,130.86 178.89,132.31 178.66,133.59 178.78,135.13 178.6,136.05 178.19,138.35 177.3,139.63 176.03,140.52 175.67,141.03 175.67,141.03 173.2,141.52 173.04,141.59 173.04,141.59 172.86,141.66 172.56,141.96 172.56,142.57 172.18,142.95 168.03,142.95 167.57,143.41 167.57,144.09 167.9,144.42 168.92,144.42 169.05,144.55 169.05,144.8 168.95,144.9 v2(168.76,144.9)
  BOTTOM w0.102: v2(168.76,144.9) 168.76,144.54 U42.N26
  BOTTOM w0.14: R868.1 113.51,86.46 113.81,86.46 v1(114.11,86.75)
PEG12_RXP0_SSD_R: length 3.7
  BOTTOM w0.14: R868.2 112.52,86.42 111.95,86.42 111.13,85.6 110.73,85.6 110.6,85.73 CN6.43
PEG12_RXP1_SSD: length 160.4
  IN1 w0.086: v2(171.36,144.9) 171.19,144.73 171.19,144.51 171.28,144.43 172.41,144.43 172.65,144.67 177.39,144.67 180.1,141.95 180.11,141.93 180.72,140.75 181.45,136.57 181.29,135.65 181.44,134.79 181.22,133.54 181.5,131.94 181.28,130.67 181.48,129.52 181.4,129.06 181.4,127.57 181.46,127.21 181.81,126.37 182.88,124.77 184.16,123.49 184.68,122.87 185.13,121.76 185.28,120.43 185.1,119.45 185.35,118.07 185.22,117.33 185.32,116.25 185.39,115.62 185.4,115.56 185.61,115.06 186.16,114.23 186.2,114.2 186.74,113.67 187.36,112.78 188.19,112.2 188.92,111.16 190.16,110.29 190.89,109.25 191.65,108.72 191.71,108.66 192.51,106.72 192.51,84.53 192.18,83.74 188.76,80.32 188.67,80.2 188.52,80.1 188.23,79.59 187.45,78.63 187.38,78.54 187.3,78.48 187.08,78.39 186.56,78.37 184.62,78.37 184.05,78.4 183.64,78.63 183.42,78.75 182.42,78.97 181.03,78.73 179.75,78.95 178.72,78.77 177.52,78.98 170.79,78.98 170.45,78.64 163.04,78.64 162.44,78.89 151.88,78.89 151.01,78.62 150.44,78.62 150.21,78.72 149.42,79.25 148.65,79.57 148.35,79.69 140.28,79.69 139.99,79.57 139.59,79.18 139.12,78.98 136.32,78.98 134.84,79.59 134.21,79.48 133.28,79.64 132.16,79.44 130.81,79.68 128.25,79.68 127.14,79.48 126.11,79.66 124.71,79.42 123.41,79.65 122.27,79.44 121.11,79.65 120.41,79.52 119.79,79.52 119.31,79.33 119.08,79.09 119.08,78.86 v1(119.35,78.59)
  BOTTOM w0.102: v2(171.36,144.9) 171.04,144.57 U42.J26
  BOTTOM w0.14: R892.1 113.51,83.41 114.02,83.41 114.63,82.8 116.37,82.8 119.17,80 119.17,78.76 v1(119.35,78.59)
PEG12_RXP1_SSD_R: length 3.7
  BOTTOM w0.14: R892.2 112.56,83.41 111.86,83.41 111.07,82.61 110.73,82.61 110.61,82.73 CN6.31
PEG12_RXP2_SSD: length 175.5
  IN1 w0.086: v1(114.37,80.97) 114.6,80.74 114.6,80.59 114.42,80.17 113.88,79.63 113.82,79.49 113.82,78.96 113.84,78.93 114.08,78.34 114.7,77.41 117.07,75.04 117.36,74.92 118.06,74.92 118.62,74.81 118.87,74.71 119.32,74.62 119.93,74.72 121.18,74.5 122.43,74.72 123.68,74.5 124.93,74.72 126.18,74.5 127.43,74.72 129.01,74.45 130.26,74.67 131.19,74.5 132.44,74.72 133.69,74.5 134.84,74.71 135.43,74.6 136.45,74.71 137.34,75.08 138.12,75.24 143.98,75.24 144.85,75.41 155.85,75.41 156.27,75.24 158.46,75.24 161.57,74.62 164.14,74.62 165.44,75.16 165.89,75.22 167.05,75.01 168.22,75.22 169.43,74.95 170.22,75.09 170.89,74.97 172.22,75.21 173.3,75.02 174.44,75.22 175.68,75 176.95,75.22 178.19,75 179.38,75.21 180.66,74.98 181.12,75.06 183.09,74.71 184.32,74.67 187.57,75.02 188.87,75.55 193.23,79.92 194.34,81.58 195.13,82.37 195.55,83.38 195.55,107.86 194.58,110.19 194.13,110.83 193.44,111.32 193.22,111.62 192.76,112.28 191.72,113.01 191.64,113.12 190.74,114.41 189.61,115.2 189.58,115.28 189.47,115.48 189.38,115.66 188.87,116.33 188.63,116.89 188.52,118.06 188.52,118.68 188.4,119.33 188.35,119.64 188.6,121.05 188.37,122.34 188.37,122.87 187.76,124.35 187.61,124.5 187.61,124.67 185.12,127.16 184.85,127.67 184.79,128.04 184.93,128.86 184.64,130.51 184.8,131.42 184.44,133.5 184.49,133.82 184.52,133.97 184.65,134.75 184.52,135.53 184.92,137.75 184.53,139.97 184.58,140.26 184.64,140.6 184.41,141.92 183.43,143.14 182.94,143.49 182.27,144.45 181.28,145.14 180.57,146.15 179.54,146.87 179.16,147.41 178.15,148.12 172.74,148.12 172.43,147.8 170.93,147.8 169.85,146.72 169.2,146.72 168.94,146.47 168.94,146.25 v2(168.76,146.07)
  BOTTOM w0.102: U42.M28 169.08,145.74 v2(168.76,146.07)
  BOTTOM w0.14: R918.1 113.51,80.36 114.43,80.36 114.57,80.5 114.57,80.77 v1(114.37,80.97)
PEG12_RXP2_SSD_R: length 3.7
  BOTTOM w0.14: R918.2 112.56,80.36 112,80.36 111.25,79.61 110.73,79.61 110.61,79.73 CN6.19
PEG12_RXP3_SSD: length 166.9
  IN1 w0.086: v2(171.36,146.07) 171.18,146.07 171.07,146.18 171.07,146.41 171.48,146.83 172.47,146.83 173.11,147.47 177.63,147.47 183.28,141.82 183.41,141.07 183.54,140.32 183.48,139.93 183.91,137.46 183.57,135.54 183.71,134.73 183.49,133.48 183.79,131.8 183.6,130.7 183.94,128.77 183.78,127.89 183.86,127.42 184.24,126.71 186.7,124.25 187.39,122.57 187.39,121.87 187.59,120.75 187.5,120.24 187.4,119.67 187.53,118.92 187.54,118.46 187.55,117.67 187.68,116.42 187.83,116.06 188.6,115.15 188.86,114.56 189.47,114.13 189.77,113.92 190.7,112.6 191.74,111.87 192.45,110.86 192.47,110.83 193.07,110.41 193.79,109.69 194.62,107.68 194.62,83.64 194.29,82.84 193.59,82.14 193.58,82.13 193.35,81.86 192.01,80.1 188.3,76.39 187.27,75.94 183.5,75.76 182.61,76.01 181.5,76.16 165.03,76.16 163.44,75.66 161.33,76.03 160.68,75.92 159.6,76.36 156.38,76.36 155.75,76.33 145.41,76.33 145.41,76.33 144.13,76.87 143.72,76.87 142.65,76.68 141.58,76.86 140.44,76.66 139.51,76.83 138.61,76.67 138.38,76.71 136.87,76.39 136.22,75.96 135.55,75.75 135.17,75.75 134.56,75.65 133.31,75.87 131.46,75.54 129.98,75.8 129.33,75.69 128.3,75.87 127.05,75.65 125.8,75.87 124.55,75.65 123.3,75.87 122.05,75.65 120.8,75.87 119.96,75.72 119.12,75.87 117.55,75.87 116.97,76.44 116.97,76.71 117.06,76.8 117.26,76.8 v1(117.37,76.68)
  BOTTOM w0.102: v2(171.36,146.07) 171.69,145.74 U42.H28
  BOTTOM w0.14: R929.1 113.46,77.36 113.99,77.36 114.48,77.84 115.61,77.84 115.69,77.92 116.36,77.92 117,77.28 117,76.82 117.14,76.68 v1(117.37,76.68)
PEG12_RXP3_SSD_R: length 3.6
  BOTTOM w0.14: R929.2 112.56,77.31 111.82,77.31 111.12,76.61 110.73,76.61 110.61,76.73 CN6.7
PEG12_SSD_DBG#: length 135.9
  TOP w0.14: U12.2 99.32,85.28 99.55,85.51 100.51,85.51 102.88,83.14 v1(103.53,83.14) ; R328.1 216.67,77.07 216.47,76.87 v1(216.47,76.62)
  IN2 w0.089: v1(103.53,83.14) 106.68,80 109.73,80 110.26,79.47 111.17,79.47 112.55,78.09 116.22,78.09 117.22,77.08 120.38,77.08 121.2,76.26 129.19,76.26 129.95,77.02 137.32,77.02 138.69,75.64 142.93,75.64 143.33,75.25 144.97,75.25 145.36,75.64 149.01,75.64 150.31,76.94 151.11,76.94 151.6,77.44 152.92,77.44 153.69,78.21 159.08,78.21 161.14,76.15 161.94,76.15 162.41,75.68 162.41,75.45 162.5,75.36 163.89,75.36 164.36,75.83 166.22,75.83 166.69,75.36 169.55,75.36 169.63,75.44 172.77,75.44 173.38,76.05 181.07,76.05 182.14,74.99 187.5,74.99 188.51,73.98 190.48,73.98 190.74,74.24 192.54,74.24 195.21,71.56 198.91,71.56 200.63,69.85 201.81,69.85 202.82,70.86 204.27,70.86 204.76,71.35 204.76,72.08 205.16,72.48 205.93,72.48 206.17,72.24 208.07,72.24 208.16,72.33 208.83,72.33 209.91,73.41 210.46,73.41 210.58,73.52 210.58,73.98 210.92,74.32 211.45,74.32 211.74,74.03 211.9,74.03 212.73,74.85 212.73,75.65 214.02,76.95 214.74,76.95 215.66,76.04 216.18,76.04 216.47,76.32 v1(216.47,76.62)
  BOTTOM w0.102: v1(216.47,76.62) 216.74,76.35 U49.AM8
