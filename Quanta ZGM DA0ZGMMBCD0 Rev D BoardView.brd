# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LCDVCC_CONN: length 1.5
  TOP w0.14: R40.2 v1(265.43,207.41)
LCDVCC_CTL_EC: length 162
  TOP w0.14: v1(171.22,60.15) 171.22,61.25 171.13,61.34 171.13,61.93 170.56,62.5 U23.23
  IN1 w0.086: v1(200.33,71.85) 200.12,71.64 200.12,70.11 200.41,69.82 200.41,67.11 199.32,66.01 198.96,66.01 198.54,65.6 198.54,63.59 196.38,61.42 196.38,60.69 195.03,59.34 190.13,59.34 188.92,60.56 187.73,60.56 187.23,60.06 185.98,60.06 185.87,59.95 184.57,59.95 184.22,59.6 175.54,59.6 175.18,59.24 173.01,59.24 172.1,60.15 v1(171.22,60.15) ; v1(209.61,98.73) 210.06,99.18 210.06,100.26 210.66,100.85 210.66,103.84 211.5,104.68 211.5,109.31 212.65,110.47 212.65,111.26 213.1,111.7 246.29,111.7 248.87,114.28 251.87,114.28 252.34,114.75 252.34,117.54 254.69,119.89 254.69,121.71 254.11,122.29 254.11,123.56 255.28,124.73 260.75,124.73 261.74,125.72 262.39,125.72 262.62,125.48 264.68,125.48 265.04,125.84 265.04,126.13 265.48,126.56 265.61,126.56 v1(265.77,126.73)
  IN3 w0.089: v1(200.33,71.85) 200.65,71.85 201.05,72.26 202.39,72.26 202.73,72.6 202.73,74.65 202.41,74.97 202.41,76.86 202.86,77.3 202.86,78.58 203.19,78.91 204.67,78.91 205.34,79.58 205.34,81.71 204.99,82.06 204.55,82.06 203.61,83 203.61,87.52 202.34,88.78 202.34,89.45 202.94,90.05 202.94,93.12 208.56,98.73 v1(209.61,98.73)
  BOTTOM w0.14: v1(265.77,126.73) 265.54,126.5 264.78,126.5 264.44,126.84 R813.1
LCDVCC_CTL_PCH: length 142.8
  TOP w0.14: v1(209.84,54.08) 209.37,54.55 R589.1
  IN1 w0.086: v1(210.16,101.47) 210.16,101.77 210.47,102.07 210.47,103.92 211.31,104.76 211.31,109.39 212.47,110.55 212.47,111.33 213.02,111.89 246.21,111.89 249.62,115.3 251.3,115.3 251.69,115.7 251.69,119.31 252.5,120.11 252.5,122.23 252.84,122.58 252.84,123.22 254.54,124.92 260.68,124.92 261.66,125.91 262.46,125.91 262.7,125.67 264.6,125.67 264.85,125.92 264.85,126.21 264.98,126.33 v1(264.98,126.96)
  IN3 w0.089: v1(210.16,101.47) 210.16,100.88 202.48,93.19 202.48,90.14 201.92,89.58 201.92,88.66 202.59,88 202.59,85.6 202.35,85.36 202.35,81.74 203.22,80.87 203.22,79.48 201.59,77.85 201.59,77.09 202.03,76.65 202.03,74.81 202.35,74.49 202.35,72.76 202.23,72.64 200.28,72.64 199.74,72.1 199.74,71.61 199.99,71.35 199.99,68.8 200.4,68.4 200.4,66.59 200.04,66.23 200.04,65.47 199.01,64.44 199.01,61.25 199.1,61.16 v1(199.86,61.16)
  IN4 w0.086: v1(199.86,61.16) 199.86,61.04 201.86,59.04 202.85,59.04 203.56,58.33 203.56,57.72 204.59,56.69 208.17,56.69 209.84,55.02 v1(209.84,54.08)
  BOTTOM w0.102: U49.Y47 211,56.56 210.8,56.36 210.8,55.92 210.48,55.6 210.48,55.01 209.84,54.37 v1(209.84,54.08)
  BOTTOM w0.14: R812.1 264.35,127.35 264.74,126.96 v1(264.98,126.96)
LED_B1: length 91.7
  TOP w0.508: v1(164.8,218.73) 164.21,218.15 R4.2 ; v1(186.06,205.58) 186.06,205.07 187.6,203.53 R47.2
  IN1 w0.508: v1(173.33,213.16) 172.09,214.4 172.09,217.12 171.02,218.19 168.2,218.19 166.91,216.9 166.91,214.14 166.4,213.63 165.68,213.63 165.18,214.14 v1(165.18,214.33) 165.18,214.35 165.4,214.57 165.4,216.93 166.16,217.69 166.16,218.41 165.68,218.89 164.96,218.89 v1(164.8,218.73) 162.53,218.73 161.14,217.35 161.14,216.63 161.52,216.25 161.52,211.62 159.65,209.75 158.88,209.75 157.9,208.78 154,208.78 150.04,212.74 150.04,214.19 v1(145.8,218.44)
  IN2 w0.508: v1(186.06,205.58) 185.41,205.58 184.68,204.84 175.74,204.84 175.64,204.74 174.68,204.74 173.21,206.21 173.21,213.03 v1(173.33,213.16)
  BOTTOM w0.508: v1(145.8,218.44) 145.8,218.11 145.15,217.46 142.25,217.46 R683.2 ; Q76.3 166.02,212.41 165.18,213.25 v1(165.18,214.33) 165.4,214.56 165.4,215.96 165.84,216.4 R682.2
LED_B2: length 48.7
  TOP w0.381: Q2.3 249.99,218.8
  TOP w0.508: R11.2 228.37,217.34 v1(228.37,216.8) ; 249.99,218.8 250.38,218.8 v1(251.5,217.68) ; v1(243.54,210.4) 243.59,210.4 244.1,209.89 245.24,209.89 246.44,211.1 v1(246.44,214.21) 246.44,215.67 246.63,215.85 R14.1 247.39,216.29 v1(247.72,215.97)
  IN1 w0.508: v1(228.37,216.8) 228.37,216.75 227.83,216.21 226.04,216.21 225.36,215.53 223.75,215.53 222.75,216.53 v1(222.75,216.82)
  IN4 w0.508: v1(247.72,215.97) 247.24,216.45 247.24,217.17 247.75,217.68 v1(251.5,217.68) ; v1(228.37,216.8) 230.33,216.8 231.52,215.61 232.03,215.61 232.16,215.74 233.3,215.74 233.94,215.1 233.94,214.59 234.7,213.83 234.7,212.08 237.9,208.88 240.82,208.88 241.26,209.31 242.45,209.31 v1(243.54,210.4)
  BOTTOM w0.508: R678.2 222.75,218.23 v1(222.75,216.82)
LED_G1: length 95.7
  TOP w0.508: v1(190.38,206.21) 190.3,206.13 190.3,205.61 190.13,205.44 190.13,203.88 190.64,203.38 R49.2 ; v1(164.12,216.3) 164.12,216.73 164.68,217.3 166.43,217.3 166.68,217.05 168.15,217.05 170.46,214.75 171.72,214.75 173.61,216.64 R5.2
  IN1 w0.508: v1(164.12,216.3) 164.09,216.3 163.25,215.46 163.25,213.26 163.84,212.67 166.35,212.67 169.4,209.62 169.96,209.62 171.48,208.1 171.48,207.01 174.41,204.08 189,204.08 190.3,205.37 190.3,206.13 v1(190.38,206.21)
  IN2 w0.508: v1(150.82,215.51) 150.82,216.06 149.71,217.16 140.74,217.16 140.35,217.55 135.73,217.55 v1(135.05,216.88)
  BOTTOM w0.381: v1(135.05,216.88) 135.37,217.2 Q73.6
  BOTTOM w0.508: v1(150.82,215.51) 150.38,215.51 149.51,214.65 R697.2 149.51,213.27 154.19,208.59 157.88,208.59 160.99,211.7 161.66,211.7 163.09,213.12 R694.2 163.19,213.62 164.6,215.03 164.6,215.81 v1(164.12,216.3)
LED_G2: length 47.1
  TOP w0.508: R8.2 235.3,217.57 v1(235.3,216.79) ; v1(253.75,217.26) 252.99,217.26 252.55,216.82 Q4.3 251.64,216.57 251.28,216.94 v1(250.95,216.94)
  IN1 w0.508: v1(231.21,216.91) 231.21,215.94 232.01,215.15 232.01,213.68 231.85,213.53 231.85,212.81 232.29,212.38 233.49,212.38 236.81,209.06 236.81,207.54 237.32,207.04 240.51,207.04 241.97,208.49 243.68,208.49 246.46,211.28 246.46,214.56 246.18,214.85 246.18,216.04 247.76,217.62 250.32,217.62 250.92,217.03 250.92,216.97 v1(250.95,216.94)
  IN3 w0.508: v1(231.21,216.91) 232.12,217.82 234.79,217.82 235.3,217.31 v1(235.3,216.79)
  BOTTOM w0.508: R680.2 231.02,217.12 231.21,216.92 v1(231.21,216.91) ; v1(250.95,216.94) 250.95,217.11 250.09,217.97 R679.1
LED_PWR_CTL1: length 8.8
  TOP w0.203: U1.12 144.35,205.39 v1(144.19,205.56)
  IN2 w0.254: v1(145.58,210.1) 145.83,209.85 145.83,207.21 v1(144.19,205.56)
  BOTTOM w0.254: Q74.2 146.05,211.32 R703.1 146.08,210.94 145.58,210.43 v1(145.58,210.1)
LED_PWR_CTL2: length 16.4
  TOP w0.203: v1(144.17,204.89) 144.19,204.89 144.29,205 U1.13
  IN1 w0.254: v1(144.17,204.89) 143.97,204.89 143.44,205.42 143.44,206.44 143.03,206.85 143.03,209.49 145.21,211.67 145.6,211.67 146.17,212.24 146.17,215.65 v1(146.49,215.97)
  BOTTOM w0.254: Q74.5 146.05,214.66 146.26,214.87 R689.1 146.26,215.74 v1(146.49,215.97)
LED_PWR_CTL3: length 40
  TOP w0.203: U1.14 144.53,204.59 143.49,203.56 v1(143.49,203.24)
  TOP w0.254: v1(165.44,218.22) 165.65,218.43 R2.1 166.93,218.43 167.08,218.28 Q1.2
  IN1 w0.254: v1(165.44,218.22) 164.64,218.22 162.41,215.99 162.41,210.44 162.16,210.18 161.03,210.18 159.93,209.08 159.2,209.08 157.08,206.96 157.08,204.88 153.09,200.89 151.11,200.89 150.43,201.57 148.76,201.57 148.2,202.13 147.2,202.13 145.34,203.98 144.5,203.98 143.76,203.24 v1(143.49,203.24)
LED_PWR_CTL4: length 52.1
  TOP w0.203: U1.15 144.56,204.19 144.05,203.69 144.05,203.04 143.53,202.51 v1(143.33,202.51)
  TOP w0.254: Q1.5 R3.1 170.34,217.58 v1(170.38,217.54)
  IN1 w0.254: v1(170.38,217.54) 170.38,216.86 168.8,215.28 168.8,214.8 167.16,213.15 164.07,213.15 163.82,213.4 163.82,213.88 164.91,214.97 164.91,216.5 164.49,216.93 163.85,216.93 162.77,215.85 162.77,210.24 162.36,209.83 161.18,209.83 160.08,208.73 159.35,208.73 157.43,206.81 157.43,204.74 153.23,200.54 150.96,200.54 150.28,201.22 148.38,201.22 147.82,201.77 147.05,201.77 145.2,203.63 144.65,203.63 143.54,202.51 v1(143.33,202.51)
LED_PWR_CTL5: length 107
  TOP w0.203: v1(143.28,201.87) 143.57,201.87 144.36,202.66 144.36,203.49 144.67,203.79 U1.16
  TOP w0.254: v1(221.85,218.81) 222.87,218.81 223.1,218.58 223.81,218.58 224.35,219.12 225.54,219.12 225.76,218.9 225.76,218.25 226.04,217.98 Q3.2 227.54,217.98 R9.1
  IN4 w0.254: v1(221.85,218.81) 221.85,217.72 221.21,217.08 221.21,210.43 221.89,209.76 221.89,205.69 221.06,204.87 201.43,204.87 199.54,206.76 194.95,206.76 193.06,204.87 175.79,204.87 172.5,201.58 169.83,201.58 169.08,200.83 164.27,200.83 163.88,200.45 162.54,200.45 161.72,201.26 153.88,201.26 153.39,200.78 144.66,200.78 143.56,201.87 v1(143.28,201.87)
LED_PWR_CTL6: length 102.8
  TOP w0.203: 145.48,201.85 145.8,202.17 U1.17
  TOP w0.254: v1(221.82,216.98) 222.16,216.98 222.82,217.64 R6.1 224.25,217.64 224.58,217.97 225.07,217.97 225.07,217.98 Q3.5 ; v1(143.41,201.23) 144.86,201.23 145.48,201.85
  IN4 w0.254: v1(221.82,216.98) 221.57,216.73 221.57,210.58 222.24,209.9 222.24,205.55 221.21,204.51 200.39,204.51 198.5,206.4 195.1,206.4 193.21,204.51 175.94,204.51 172.65,201.22 169.98,201.22 169.23,200.47 164.42,200.47 163.99,200.04 162.44,200.04 161.65,200.83 153.95,200.83 153.54,200.42 144.22,200.42 v1(143.41,201.23)
LED_PWR_CTL7: length 121.2
  TOP w0.203: U1.18 146.2,201.91 146.15,201.87
  TOP w0.254: v1(161.4,200.24) 161.4,200.26 160.8,200.86 157.06,200.86 156.92,200.72 148.55,200.72 148.21,200.38 146.51,200.38 145.91,200.98 145.91,201.62 146.15,201.87 ; v1(247.51,213.99) 247.54,213.96 247.55,213.96 248.08,213.43 Q5.2 248.08,212.63 247.67,212.22 R27.1
  IN2 w0.254: v1(247.51,213.99) 247.54,213.96 247.55,213.96 248.52,212.99 248.52,212.15 243.83,207.46 241.96,207.46 241.27,206.77 236.46,206.77 235.64,205.96 234.55,205.96 233.25,207.25 232.26,207.25 231.63,207.89 226.85,207.89 226.02,207.07 226.02,206.02 224.16,204.16 219.87,204.16 219.29,204.74 213.47,204.74 212.9,204.16 202.14,204.16 200.26,206.04 200.26,206.36 199.52,207.1 195.57,207.1 194.85,206.38 194.85,205.53 193.35,204.03 188.87,204.03 188.64,204.27 186.07,204.27 185.4,203.59 176.36,203.59 176.13,203.37 174.78,203.37 174.43,203.01 173.69,203.01 171.53,200.85 164.47,200.85 164.06,200.45 161.62,200.45 161.42,200.24 v1(161.4,200.24)
LED_PWR_CTL_L: length 7.5
  TOP w0.203: U1.19 146.6,202.11
  TOP w0.254: 146.6,202.11 146.6,201.43 v1(146.43,201.26)
  BOTTOM w0.254: v1(146.43,201.26) 146.26,201.42 v1(144.91,201.42) 144.14,201.42 143.84,201.73 143.84,202.28 144.09,202.54 145.01,202.54 ; R720.1 145.01,202.54 ; 145.01,202.54 145.05,202.54 145.41,202.54 145.42,202.53 Q79.2
LED_PWR_CTL_LOGO: length 143.4
  TOP w0.14: R1211.1 254.49,211.42 254.25,211.19 Q125.2 253.61,210.64 252.86,209.89 251.64,209.89 251.44,210.1 248.8,210.1 248.08,209.39 248.08,208.27 v1(248.8,207.56) ; U1.11 144.59,205.79 144.22,206.16 144,206.16 143.98,206.18 v1(143.97,206.18)
  IN1 w0.086: v1(143.97,206.18) 143.97,206.52 143.54,206.95 143.54,208.88 145.27,210.61 149.13,210.61 v1(149.53,211.01)
  IN3 w0.089: v1(149.53,211.01) 149.84,211.32 151.77,211.32 153.09,210 153.29,210 154.1,209.18 158.05,209.18 162.01,213.15 166.4,213.15 167.31,212.23 167.91,212.23 171.68,208.45 171.68,208.01 173.21,206.49 173.21,205.54 174.49,204.26 175.96,204.26 177.69,205.99 179.47,205.99 181.12,204.34 189.83,204.34 190.59,203.58 193.49,203.58 195.21,205.3 195.21,206.47 195.84,207.1 199.53,207.1 200.41,206.22 200.41,205.45 201.43,204.43 213.36,204.43 213.98,205.05 219.35,205.05 219.94,204.46 221.29,204.46 221.87,205.03 221.87,209.38 223.65,211.16 224.92,211.16 225.43,211.67 226.57,211.67 226.84,211.94 226.84,212.22 228.2,213.58 230.51,213.58 231.4,212.69 234.01,212.69 234.81,211.89 235.11,211.15 237.66,208.6 244.12,208.6 245.16,207.56 v1(248.8,207.56)
  BOTTOM w0.14: v1(149.53,211.01) 149.13,211.42 v1(148.97,211.42)
LED_PWR_CTL_R: length 11.1
  TOP w0.203: U1.20 147,202.35
  TOP w0.254: 147,202.35 147,201.49 147,201.02 147.25,200.77 147.76,200.77 148.13,201.14 151.08,201.14 v1(151.31,201.38)
  BOTTOM w0.254: v1(151.31,201.38) 150.85,201.38 149.63,202.6 149.2,202.6 149.01,202.41 R719.1 148.35,202.41 148.23,202.53 Q79.5
LED_PWR_CTL_TURBO: length 128.6
  TOP w0.508: 151.57,202.95 v1(156.59,202.95) 159.12,202.95 159.23,202.84 159.95,202.84 160.61,203.49 161.32,203.49 162.04,202.77 162.95,202.77 v1(163.06,202.87)
  IN1 w0.508: v1(264.06,192.5) 261.21,189.65 250.71,189.65 250.07,190.28 241.99,190.28 241.31,189.61 237.78,189.61 237.51,189.34 223.41,189.34 222.78,189.98 220,189.98 219.57,189.55 212.6,189.55 211.54,188.48 208.33,188.48 206.4,190.41 201.27,190.41 200.2,189.34 190.66,189.34 185.59,194.4 181.56,194.4 181.07,194.9 179.44,194.9 176.79,197.55 175.81,197.55 172.82,200.54 172.82,202.48 171.45,203.84 171.45,204.84 169.94,206.35 167.36,206.35 167.14,206.57 166.25,206.57 165.85,206.17 164.44,206.17 163.61,205.35 163.61,203.43 v1(163.06,202.87)
LED_PWR_LEFT: length 252.8
  IN1 w0.635: v1(254.21,63.12) 253.11,64.21 253.11,66.84 254.31,68.04 255.02,68.04 v1(255.02,68.04) ; v1(249.12,83.44) 246.52,80.83 245.68,80.83 245.11,80.26 237.41,80.26 236.6,81.07 235.1,81.07 233.48,82.69 233.48,84.79 231,87.26 226.16,87.26 224.71,88.72 220.57,88.72 219.16,87.31 217.68,87.31 217.05,87.94 217.05,88.56 216.21,89.4 216.21,95.14 215.19,96.15 214.49,96.15 213.29,97.36 213.29,98.24 211.69,99.83 v1(211.69,101.48)
  IN2 w0.635: v1(211.69,101.48) 211.2,101.97 211.2,104.45 208.89,106.76 208.44,106.76 207.62,107.59 207.62,108.87 202.08,114.4 198.4,114.4 188.09,124.71 188.09,161.58 185.68,164 185.68,167.08 180.06,172.7 180.06,176.77 178.41,178.43 178.41,179.8 178.56,179.94 178.56,184.25 180.81,186.51 180.81,188.55 175.33,194.03 170.07,194.03 169.02,195.08 164.9,195.08 164.51,195.47 162.53,195.47 161.48,196.51 160.2,196.51 158.69,195 155.56,195 151.17,199.39 v1(149.81,199.39)
  BOTTOM w0.635: v1(254.21,63.12) 254.21,62.64 255.04,61.8 255.04,60.16 254.27,59.39 252.65,59.39 251.94,58.68 251.94,52.78 251.62,52.45 251.62,48.71 252.49,47.83 257.67,47.83 258.4,48.56 CN14.1 ; v1(255.02,68.04) 255.02,69.98 257.04,72 257.04,73.38 257.7,74.04 257.7,79.61 254.32,82.98 249.58,82.98 v1(249.12,83.44)
LED_PWR_LOGO: length 21.6
  TOP w0.762: v1(255.27,208.75) 253.88,208.75 253.77,208.64 Q125.3
  IN2 w0.762: v1(255.27,208.75) 255.27,207.73 256.16,206.85 257.94,206.85 258.96,205.83 260.1,205.83 260.35,206.08 264.31,206.08 265.2,205.19 265.2,204.2 264.29,203.29 264.29,198.21
  vias: v1(264.34,197.32) v1(265.05,196.84)
LED_PWR_RIGHT: length 297.7
  IN1 w0.635: v1(80.22,93.97) 85.97,99.71 90.3,99.71 93.15,102.56 100.13,102.56 106.87,109.31 106.87,111.54 108.88,113.55 108.88,126.48 112.46,130.06 112.46,137.85 116.37,141.77 116.37,144.6 117.29,145.51 117.29,153.5 112.79,158 112.79,164.43 114.74,166.38 114.74,169.24 117.2,171.69 117.2,176.79 118.95,178.54 118.95,184.06 119.52,184.63 119.52,191.06 120.93,192.47 125.83,192.47 126.85,191.45 131.4,191.45 132.31,192.37 134.42,192.37 135.44,191.35 140.29,191.35 141.68,189.95 157.36,189.95 160.19,192.79 160.19,199.14 158.31,201.02 154.78,201.02 153.39,199.63 150.79,199.63 150.1,200.32 146.37,200.32 145.27,201.43 145.27,202.69 v1(144.88,203.08)
  IN4 w0.635: v1(47.58,37.81) 45.2,40.19 45.2,42.09 42.37,44.92 42.37,50.36 43.05,51.04 59.17,51.04 60.32,49.88 63.66,49.88 64.06,49.48 71.94,49.48 72.45,49.99 v1(72.45,50.2)
  BOTTOM w0.635: v1(80.22,93.97) 79.66,93.4 79.66,89.63 82,87.29 82,54.77 81.25,54.02 81.25,50.16 80.58,49.48 73.17,49.48 v1(72.45,50.2) ; CN22.1 44.25,37.17 44.88,37.81 v1(47.58,37.81)
LED_PWR_TURBO: length 5.1
  TOP w0.305: v1(268.93,195.25) 268.75,195.42 267.69,195.42 267.07,196.05 CN1.12
  BOTTOM w0.508: v1(270.13,194.91) 269.61,194.38 Q85.3 269.12,195.06 v1(268.93,195.25)
LED_R1: length 75.9
  TOP w0.508: v1(188.34,205.65) 188.51,205.49 188.51,203.79 188.77,203.53 R48.2
  IN1 w0.508: v1(168.3,212.66) 169.25,212.66 169.94,211.97 170.54,211.97 171.45,211.05 171.45,209.97 172.09,209.34 172.09,207.27 174.67,204.69 187.81,204.69 188.34,205.22 v1(188.34,205.65)
  IN3 w0.508: v1(168.3,212.66) 168.3,213.88 166.84,215.34 166.84,216.22 166,217.06 163.36,217.06 162.14,215.84 v1(160.91,215.84)
  IN4 w0.508: v1(143.76,215.38) 145.65,215.38 146.94,214.08 148.69,214.08 151.51,211.27 151.51,210.96 152.99,209.49 153.24,209.49 153.9,208.83 158.12,208.83 161.27,211.98 161.27,215.48 v1(160.91,215.84)
  BOTTOM w0.381: Q73.3 138.49,215.9
  BOTTOM w0.508: 138.49,215.9 138.65,215.74 139.37,215.74 139.92,215.19 140.53,215.19 140.95,215.61 142.7,215.61 143.29,216.19 R686.2 143.76,216.03 v1(143.76,215.38) ; R696.2 167.64,213.56 168.3,212.9 v1(168.3,212.66) ; R695.2 161.65,215.1 v1(160.91,215.84)
LED_R2: length 47.8
  TOP w0.508: v1(246.5,217.34) 246.67,217.5 Q2.6 ; v1(233.9,216.88) 233.87,216.91 232.14,216.91 231.26,217.78 R7.2
  IN1 w0.508: v1(233.9,216.88) 232.96,216.88 232.26,217.59 227.03,217.59 226.55,217.11 225.89,217.11 225.02,216.24 224.01,216.24 223.45,216.8 v1(223.45,216.9)
  IN4 w0.508: v1(244.86,210.78) 245.46,210.78 246.4,211.73 246.4,217.24 v1(246.5,217.34)
  BOTTOM w0.508: v1(233.9,216.88) 232.2,215.18 232.2,213.77 231.8,213.37 231.8,212.82 232.31,212.31 233.65,212.31 237.14,208.83 242.91,208.83 v1(244.86,210.78) ; R685.2 246.88,216.86 246.5,217.24 v1(246.5,217.34) ; v1(223.45,216.9) 223.41,216.87 223.41,216.43 224.86,214.98 R690.2
LID#: length 281.1
  TOP w0.14: D1.1 268.39,196.99 268.14,197.25 267.86,197.25 v1(267.56,197.54) 267.55,197.55 CN1.9 ; R333.1 171.25,77.53 170.88,77.89 v1(170.88,78.46)
  IN1 w0.086: v1(267.56,197.54) 267.62,197.49 270.53,197.49 270.82,197.78 270.82,199.96 271.27,200.41 272.22,200.41 272.95,199.68 v1(272.95,198.79)
  IN3 w0.089: v1(180.44,60) 180.77,59.67 181.87,59.67 181.96,59.58 184.04,59.58 185.27,58.35 186.79,58.35 187.8,57.33 189.46,57.33 189.83,57.7 191.78,57.7 193.13,59.05 194.46,59.05 195.68,60.26 195.68,61.86 195.22,62.31 195.22,65.83 194.86,66.19 194.86,77.92 195.01,78.07 195.01,87.79 196.02,88.81 196.02,98.69 199.25,101.92 199.25,102.81 200.62,104.18 201.83,104.18 203.17,105.52 203.37,105.52 205.19,107.34 205.19,111.76 211.13,117.69 215.66,117.69 216.78,118.81 224.74,118.81 225.66,119.74 231.11,119.74 233.5,122.13 236.03,122.13 238.22,119.93 240.04,119.93 241.22,121.12 242.94,121.12 244.46,119.6 245.62,119.6 245.85,119.83 246.3,119.83 247.35,118.77 252.04,118.77 252.32,119.05 254.21,119.05 255.08,119.92 255.08,121.8 255.79,122.51 256.76,122.51 258.44,124.18 259.88,124.18 261.62,125.92 262.96,125.92 264.69,127.66 266.39,127.66 269.08,130.34 271.65,130.34 276.73,135.42 276.73,135.68 279.56,138.52 279.56,152.83 281.01,154.28 281.01,186.28 277.67,189.62 272.66,189.62 272.33,189.28 268.78,189.28 268.12,189.95 268.12,190.52 268.3,190.71 268.3,192.19 269.5,193.38 269.5,195.61 v1(267.56,197.54)
  BOTTOM w0.14: U40.2 273.5,199.01 273.28,198.79 v1(272.95,198.79) ; v1(170.88,78.46) 171.43,77.92 176.28,77.92 178.1,76.09 179.88,76.09 181.06,74.91 181.06,74.33 179.75,73.02 179.75,69.27 178.72,68.24 178.72,63.64 179.45,62.91 179.45,61.91 178.68,61.15 178.68,60.44 178.96,60.17 180.27,60.17 v1(180.44,60)
LID#_EC_L: length 6.4
  TOP w0.14: U23.118 173.51,73.76 173.18,74.09 173.18,74.8 173,74.98 173,75.74 173.15,75.89 v1(173.15,76.33) 173.05,76.43 D24.1 172.93,77.41 C350.2 171.85,77.08 R333.2
LINEOUT_LED: length 164.6
  TOP w0.14: v1(319.54,70.45) 319.76,70.22 C422.2 R434.1 C421.2 R435.1
  IN1 w0.086: v1(319.54,70.45) 319.28,70.7 318.44,70.7 317.88,70.14 317.37,70.14 316.69,70.82 316.69,74.28 315.22,75.76 311.3,75.76 309.99,74.45 309.99,73.56 309.42,72.99 309.42,69.65 308.64,68.87 295.35,68.87 294.47,67.98 288.78,67.98 286.14,65.35 286.14,64.89 283.09,61.83 283.09,58.97 276.41,52.3 271.68,52.3 266.58,47.21 256.39,47.21 255.95,47.65 251.21,47.65 249.14,45.58 249.14,45.07 247.91,43.84 245.8,43.84 244.63,45.01 243.86,45.01 243.5,44.66 242.41,44.66 242.07,44.99 241.42,44.99 241.3,44.87 237.37,44.87 237.04,45.2 223.93,45.2 222.69,43.95 219.02,43.95 218.64,44.34 213.94,44.34 212.65,45.63 208.2,45.63 207.9,45.93 207.9,46.57 207.66,46.81 204.31,46.81 204.11,46.61 201.03,46.61 200.54,47.11 195.71,47.11 193.6,49.21 191.52,49.21 v1(191.49,49.19)
  BOTTOM w0.14: U54.4 186.4,50.47 186.86,50.47 187.54,49.79 R1117.1 189.63,49.79 189.8,49.62 191.06,49.62 v1(191.49,49.19)
LINEOUT_LED_C: length 7.3
  BOTTOM w0.14: CN19.2 187.15,46.02 187.28,46.14 187.28,46.58 187.05,46.81 186.81,46.81 186.67,46.94 R1146.2 186.67,47.41 186.81,47.55 187.57,47.55 187.71,47.69 U54.1 187.71,48.8 187.92,49.01 R1117.2 189.13,48.73 v1(188.57,48.17)
LINLVP: length 22.6
  TOP w0.203: U21.22 302.62,62.36 303.21,61.77 v1(303.21,61.68)
  IN2 w0.762: 303.47,63.09 303.47,64.4 302.25,65.62 300.36,65.62 299.09,66.89 299.09,70.99 297.85,72.23 290.93,72.23 290.35,71.64 v3(290.35,70.88)
LIP: length 21.3
  TOP w0.203: U21.21 302.22,62.32 302.57,61.98 v1(302.57,61.76)
  IN2 w0.762: v3(288.04,70.83) 288.04,70.19 288.72,69.51 294.59,69.51 294.77,69.69 297.06,69.69 297.95,68.8 297.95,66.42 299.89,64.47 301.78,64.47 302.6,63.65 302.6,63.09
LTE_BODY_SAR1: length 3.2
  BOTTOM w0.14: D70.1 273.06,57.14 273.45,57.54 v1(273.92,57.54) 274.13,57.33 274.13,57.15 R1187.1 275,56.83 275.14,56.97 R1050.2
LTE_BODY_SAR2: length 4.5
  TOP w0.14: R1188.1 282.72,55.69 282.95,55.92 v1(282.95,56.29) 282.95,56.64 v1(282.65,56.94) 282.41,56.94 282.2,56.72 D45.1
  BOTTOM w0.14: R1055.2 281.62,56.66 281.89,56.94 v1(282.65,56.94)
LVDS_BLON1: length 99.9
  TOP w0.14: TP3.1 279.07,201.22 v1(278.66,201.22) ; v1(282.24,191.68) 282.07,191.51 282.07,190.06 280.46,188.45 280.46,156.19 279.85,155.58 279.85,136.44 v1(278.08,134.67)
  IN2 w0.089: v1(278.66,201.22) 279.33,201.22 280.68,202.57 281.51,202.57 281.82,202.26 281.82,201.84 283.51,200.15 283.51,192.18 283.02,191.68 v1(282.24,191.68)
  IN3 w0.089: v1(278.08,134.67) 273.27,129.86 269.28,129.86 266.57,127.14 v1(266.57,126.45)
  BOTTOM w0.14: U45.4 266.09,125.98 v1(266.57,126.45) ; R718.2 R722.1 278.04,201.84 v1(278.66,201.22) 278.66,199.38 277.6,198.31 277.04,198.31 276.64,198.72 U39.1
LVN: length 27.8
  TOP w0.203: v1(303.57,60.54) 303.57,61.14 303.77,61.34 303.77,61.86 303.44,62.19 303.22,62.19 303.02,62.39 U21.23
  IN2 w0.762: v3(288.93,73.6) 289.08,73.45 295.84,73.45 295.91,73.37 298.33,73.37 303.38,68.32 303.38,66.11 304.45,65.04 304.45,63.45 305.12,62.77 305.12,61.69 304.48,61.05
M2_WWAN_PERST_L: length 12.4
  TOP w0.14: R181.2 310.72,89.54 D15.2 310.56,88.56 310.42,88.43 C263.1 310.42,87.48 310.67,87.24 D18.2 310.67,86.7 310.06,86.09 310.06,85.8 R1232.1 310.06,85.78 v1(310.06,84.76)
  BOTTOM w0.14: v1(310.06,84.76) 310.07,84.75 310.45,84.75 310.94,84.27 310.94,82.92 v1(310.49,82.47) 309.73,82.47 309.46,82.2 309.46,81.26 309.21,81 CN7.50
M_A_A0: length 58
  IN1 w0.127: v2(148.42,130.21) 148.07,129.86 148.07,129.65 148.46,129.26 148.65,129.26 149.18,129.78 149.39,129.78 149.55,129.61 149.55,129.43 149.27,129.16 149.27,128.98 150.04,128.21 150.04,112.11 154.84,107.31 154.84,101.68 154.44,101.27 154.44,95.39 158.88,90.95 158.88,88.87 158.73,88.72 158.73,85.61 158.45,85.33 158.45,84.04 158.24,83.83 158.24,83.57 158.37,83.45 158.74,83.45 158.88,83.3 158.88,82.91 158.75,82.79 157.66,82.79 v1(157.51,82.63)
  BOTTOM w0.102: v2(148.42,130.21) 148.35,130.21 U42.BE4
  BOTTOM w0.216: JDIM2.144 157.03,82.12 157.48,82.58 157.48,82.61 v1(157.51,82.63)
M_A_A1: length 58.7
  IN1 w0.127: v1(155.04,87.45) 154.81,87.45 154.64,87.62 154.64,89.39 154.77,89.52 154.92,89.52 155.05,89.65 155.05,89.9 154.92,90.03 154.77,90.03 154.64,90.16 154.64,90.59 150.01,95.21 150.01,103.71 149.88,103.85 149.61,103.85 149.48,103.98 149.48,104.22 149.61,104.35 150.59,104.35 150.72,104.48 150.72,104.74 150.59,104.87 149.61,104.87 149.48,105 149.48,105.25 149.61,105.38 150.59,105.38 150.72,105.51 150.72,105.75 150.59,105.87 149.61,105.87 149.48,106 149.48,106.25 149.61,106.38 150.09,106.38 150.21,106.51 150.21,106.81 150.09,106.93 149.76,106.93 149.56,107.14 149.56,107.6 149.66,107.71 149.66,107.89 149.49,108.06 149.29,108.06 149.2,107.96 149.02,107.96 148.84,108.14 148.84,108.32 148.93,108.41 148.93,108.62 148.76,108.78 148.58,108.78 148.48,108.68 148.3,108.68 148.12,108.86 148.12,109.04 148.22,109.14 148.22,109.33 148.05,109.5 147.86,109.5 147.76,109.4 147.58,109.4 147.4,109.58 147.4,109.76 147.5,109.86 147.5,110.04 147.33,110.21 147.13,110.21 147.04,110.12 146.86,110.12 146.68,110.3 146.68,110.48 146.78,110.57 146.78,110.75 146.6,110.93 146.41,110.93 146.32,110.84 146.14,110.84 145.84,111.14 145.84,123.72 145.71,123.84 145.42,123.84 145.29,123.97 145.29,124.22 145.42,124.35 145.71,124.35 145.84,124.48 145.84,125.52 145.37,125.98 145.37,127.49 145.25,127.62 144.99,127.62 144.86,127.75 144.86,128 144.99,128.12 145.25,128.12 145.37,128.25 145.37,128.79 v2(145.48,128.89)
  BOTTOM w0.102: v2(145.48,128.89) 145.53,128.89 U42.BH1
  BOTTOM w0.216: JDIM2.133 154.28,88.22 v1(155.04,87.45)
M_A_A2: length 59
  IN1 w0.127: v2(146.2,128.21) 145.81,127.82 145.81,126.16 146.27,125.7 146.27,111.9 151.15,107.01 151.15,101.34 150.46,100.65 150.46,100.28 150.82,99.93 150.82,99.67 150.45,99.3 150.45,97.06 150.57,96.93 151.07,96.93 151.2,96.8 151.2,96.55 151.07,96.42 150.57,96.42 150.45,96.29 150.45,95.39 152.62,93.21 153.49,92.34 155.48,90.36 155.48,89.84 155.6,89.71 155.87,89.71 156,89.58 156,89.33 155.87,89.2 155.6,89.2 155.48,89.07 155.48,86 155.35,85.87 154.93,85.87 154.78,85.72 154.78,85.42 154.94,85.26 155.86,85.26 155.94,85.18 155.99,85.13 155.99,84.95 155.6,84.55 155.45,84.55 155.12,84.22 155.12,84.04 155.75,83.42 155.75,83.22 155.58,83.04 155.4,83.04 154.8,83.64 154.54,83.64 v1(154.24,83.34)
  BOTTOM w0.102: v2(146.2,128.21) 146.55,128.56 U42.BG1
  BOTTOM w0.216: v1(154.24,83.34) 153.86,82.96 153.86,82.47 154.03,82.31 JDIM2.132
M_A_A3: length 57.3
  IN1 w0.127: v2(144.02,127.04) 144.3,127.04 144.43,126.91 144.43,125.19 144.35,125.11 144.35,123.16 144.48,123.03 144.84,123.03 144.97,122.91 144.97,122.65 144.84,122.53 144.48,122.53 144.35,122.4 144.35,122.15 144.48,122.02 144.84,122.02 144.97,121.89 144.97,121.64 144.84,121.51 144.48,121.51 144.35,121.38 144.35,121.13 144.48,121 144.84,121 144.97,120.88 144.97,120.62 144.84,120.49 144.48,120.49 144.35,120.37 144.35,120.11 144.48,119.99 144.84,119.99 144.97,119.86 144.97,119.61 144.84,119.48 144.48,119.48 144.35,119.35 144.35,119.1 144.48,118.97 144.84,118.97 144.97,118.84 144.97,118.59 144.84,118.46 144.48,118.46 144.35,118.34 144.35,118.08 144.48,117.95 144.84,117.95 144.97,117.83 144.97,117.57 144.84,117.45 144.48,117.45 144.35,117.32 144.35,117.07 144.48,116.94 144.84,116.94 144.97,116.81 144.97,116.56 144.84,116.43 144.48,116.43 144.35,116.3 144.35,116.05 144.48,115.92 144.84,115.92 144.97,115.79 144.97,115.54 144.84,115.41 144.48,115.41 144.35,115.29 144.35,115.04 144.48,114.91 144.84,114.91 144.97,114.78 144.97,114.53 144.84,114.4 144.48,114.4 144.35,114.27 144.35,114.02 144.48,113.89 144.84,113.89 144.97,113.76 144.97,113.51 144.84,113.38 144.48,113.38 144.35,113.26 144.35,113.01 144.48,112.87 144.84,112.87 144.97,112.75 144.97,112.5 144.84,112.37 144.48,112.37 144.35,112.24 144.35,111.41 148.62,107.14 148.62,95.39 153.78,90.23 v1(153.78,88.26)
  BOTTOM w0.102: U42.BM2 143.38,128.92 143.38,128.4 143.56,128.21 143.56,127.5 v2(144.02,127.04)
  BOTTOM w0.216: JDIM2.131 v1(153.78,88.26)
M_A_A4: length 55
  IN1 w0.127: v1(153,82.67) 153.78,83.45 153.78,84.16 154.21,84.59 154.21,86.08 154.33,86.21 154.63,86.21 154.76,86.33 154.76,86.59 154.63,86.72 154.33,86.72 154.21,86.84 154.21,90.41 149.58,95.03 149.58,96.19 149.46,96.32 149.18,96.32 149.05,96.44 149.05,96.7 149.18,96.83 149.46,96.83 149.58,96.95 149.58,103.05 149.05,103.58 149.05,107.32 145.4,110.96 145.4,123.09 144.86,123.63 144.86,127.09 144.43,127.52 144.43,129.14 v2(144.04,129.54)
  BOTTOM w0.102: v2(144.04,129.54) 143.71,129.86 U42.BM3
  BOTTOM w0.216: JDIM2.128 153.03,82.62 153,82.64 v1(153,82.67)
M_A_A5: length 56.5
  IN1 w0.127: v2(144.04,125.74) 143.92,125.62 143.92,110.36 144.18,110.1 144.36,110.1 144.57,110.32 144.81,110.32 144.96,110.17 144.96,109.99 144.88,109.91 144.88,109.73 145.06,109.55 145.24,109.55 145.33,109.63 145.51,109.63 145.69,109.45 145.69,109.28 145.6,109.19 145.6,109.01 145.78,108.83 145.96,108.83 146.05,108.92 146.23,108.92 146.41,108.74 146.41,108.56 146.32,108.47 146.32,108.29 146.5,108.11 146.68,108.11 146.74,108.17 146.92,108.17 147.1,107.99 147.1,107.81 147.04,107.75 147.04,107.57 147.27,107.34 147.27,106.9 148.19,105.98 148.19,95.21 153.32,90.08 153.32,86.45 153.44,86.32 153.64,86.32 153.78,86.19 153.78,85.94 153.65,85.82 153.44,85.82 153.32,85.69 153.32,85.29 153.42,85.19 153.64,85.19 153.78,85.05 153.78,84.82 153.65,84.69 153.44,84.69 153.32,84.57 153.32,84.33 v1(152.96,83.97)
  BOTTOM w0.102: v2(144.04,125.74) 143.2,126.58 143.2,129.33 143.19,129.34 143.19,129.58 U42.BN3
  BOTTOM w0.216: v1(152.96,83.97) 152.53,83.53 JDIM2.126
M_A_A6: length 56.5
  IN1 w0.127: v2(144.04,128.24) 143.49,127.69 143.49,109.64 143.79,109.34 143.97,109.34 144.23,109.59 144.4,109.59 144.58,109.41 144.58,109.23 144.33,108.98 144.33,108.8 144.51,108.62 144.69,108.62 144.94,108.87 145.12,108.87 145.3,108.69 145.3,108.51 145.05,108.26 145.05,108.08 145.23,107.9 145.41,107.9 145.66,108.15 145.85,108.15 146.02,107.97 146.02,107.79 145.77,107.54 145.77,107.36 145.95,107.18 146.13,107.18 146.38,107.43 146.56,107.43 146.74,107.26 146.74,107.08 146.49,106.82 146.49,106.64 147.28,105.85 147.28,105.37 147.41,105.25 147.63,105.25 147.76,105.12 147.76,104.87 147.63,104.74 147.41,104.74 147.28,104.61 147.28,104.36 147.41,104.23 147.63,104.23 147.76,104.1 147.76,103.85 147.63,103.72 147.41,103.72 147.28,103.6 147.28,101.27 147.41,101.14 147.62,101.14 147.74,101.02 147.76,101 147.76,100.76 147.63,100.63 147.41,100.63 147.28,100.5 147.28,100.25 147.41,100.12 147.63,100.12 147.76,100 147.76,99.75 147.62,99.61 147.41,99.61 147.28,99.49 147.28,99.28 147.55,99 147.55,98.82 147.28,98.55 147.28,97.12 147.41,96.99 147.61,96.99 147.76,96.85 147.76,96.61 147.63,96.48 147.41,96.48 147.28,96.35 147.28,96.1 147.76,95.63 147.76,95.03 152.84,89.94 152.84,87.02 v1(152.52,86.7)
  BOTTOM w0.102: U42.BM1 144,128.24 v2(144.03,128.24)
  BOTTOM w0.216: v1(152.52,86.7) 152.92,87.1 152.92,88.45 152.78,88.59 JDIM2.127
M_A_A7: length 54.2
  IN1 w0.127: v1(150.98,84.11) 151.44,84.57 151.44,89.51 145.43,95.52 145.43,105.86 144.6,106.7 142.19,109.11 142.19,127.09 141.79,127.49 141.79,128.85 v2(141.11,129.53)
  BOTTOM w0.102: v2(141.11,129.53) 141.09,129.55 140.26,129.55 U42.BV3
  BOTTOM w0.216: JDIM2.122 151.53,83.57 v1(150.98,84.11)
M_A_A8: length 57
  IN1 w0.127: v1(152.41,88.23) 152.41,89.76 147.32,94.85 147.32,95.31 147.14,95.49 146.68,95.49 146.4,95.77 146.4,95.89 146.53,96.02 146.7,96.02 146.85,96.17 146.85,96.49 146.72,96.62 146.43,96.62 146.3,96.75 146.3,97 146.43,97.13 146.72,97.13 146.85,97.25 146.85,99.17 146.69,99.32 146.43,99.32 146.3,99.46 146.3,99.71 146.43,99.83 146.69,99.83 146.85,99.99 146.85,101.27 146.72,101.39 146.43,101.39 146.3,101.52 146.3,101.77 146.43,101.9 146.72,101.9 146.85,102.03 146.85,105.67 143.05,109.46 143.05,128.18 143.35,128.48 143.35,129.05 142.92,129.49 142.92,132.38 143.06,132.52 143.45,132.52 143.58,132.39 143.58,130.16 143.67,130.07 143.91,130.07 v2(144.04,130.19)
  BOTTOM w0.102: v2(144.04,130.19) 143.78,130.19 143.67,130.29 U42.BM4
  BOTTOM w0.216: v1(152.41,88.23) 152.28,88.36 JDIM2.125
M_A_A9: length 59.1
  IN1 w0.127: v1(150.07,85.01) 149.24,85.85 149.24,89.27 142.81,95.69 142.81,106.04 140.04,108.81 140.04,130.34 140.75,131.04 141.82,131.04 142.02,130.84 v2(142.51,130.84)
  BOTTOM w0.102: v2(142.51,130.84) 142.03,130.84 141.79,130.6 141.79,130.21 U42.BP3
  BOTTOM w0.216: JDIM2.121 151.28,86.27 150.55,85.54 150.53,85.54 150.07,85.07 v1(150.07,85.01)
M_A_A10: length 58.2
  IN1 w0.127: v1(159.53,82.69) 159.89,83.05 159.89,85.11 159.59,85.41 159.59,88.36 159.74,88.52 159.74,91.4 155.99,95.15 155.99,100.24 156.24,100.5 156.24,107.13 156.12,107.26 150.9,112.47 150.9,113.28 151.03,113.41 151.15,113.41 151.28,113.53 151.28,113.79 151.15,113.91 151.03,113.91 150.9,114.04 150.9,114.29 151.03,114.42 151.15,114.42 151.28,114.55 151.28,114.8 151.15,114.93 151.03,114.93 150.9,115.06 150.9,115.31 151.03,115.44 151.15,115.44 151.28,115.56 151.28,115.82 151.15,115.95 151.03,115.95 150.9,116.07 150.9,116.33 151.03,116.45 151.15,116.45 151.28,116.58 151.28,116.83 151.15,116.96 151.03,116.96 150.9,117.09 150.9,117.34 151.03,117.47 151.15,117.47 151.28,117.6 151.28,117.85 151.15,117.98 151.03,117.98 150.9,118.1 150.9,118.36 151.03,118.49 151.15,118.49 151.28,118.61 151.28,118.87 151.15,118.99 151.03,118.99 150.9,119.12 150.9,119.37 151.03,119.5 151.15,119.5 151.28,119.63 151.28,119.88 151.15,120.01 151.03,120.01 150.9,120.14 150.9,120.39 151.03,120.52 151.15,120.52 151.28,120.64 151.28,120.9 151.15,121.03 151.03,121.03 150.9,121.15 150.9,121.41 151.03,121.53 151.15,121.53 151.28,121.66 151.28,121.91 151.15,122.04 151.03,122.04 150.9,122.17 150.9,122.42 151.03,122.55 151.15,122.55 151.28,122.68 151.28,122.93 151.15,123.06 151.03,123.06 150.9,123.18 150.9,123.44 151.03,123.57 151.15,123.57 151.28,123.69 151.28,123.95 151.15,124.07 151.03,124.07 150.9,124.2 150.9,124.45 151.03,124.58 151.15,124.58 151.28,124.71 151.28,124.96 151.15,125.09 151.03,125.09 150.9,125.22 150.9,125.65 151.28,126.02 151.28,126.48 v2(150.86,126.89)
  BOTTOM w0.102: v2(150.86,126.89) 150.82,126.89 149.15,128.56 U42.BD1
  BOTTOM w0.216: v1(159.53,82.69) JDIM2.146
M_A_A11: length 56.1
  IN1 w0.127: v1(151.06,82.66) 151.87,83.48 151.87,83.87 152,84 152.43,84 152.56,84.13 152.56,84.36 152.42,84.51 152,84.51 151.87,84.63 151.87,84.89 152,85.01 152.47,85.01 152.59,85.14 152.59,85.4 152.47,85.52 152,85.52 151.87,85.65 151.87,89.69 145.87,95.69 145.87,103.71 145.99,103.84 146.29,103.84 146.42,103.97 146.42,104.22 146.29,104.35 145.99,104.35 145.87,104.48 145.87,104.73 145.99,104.86 146.29,104.86 146.42,104.98 146.42,105.24 146.29,105.36 145.99,105.36 145.87,105.49 145.87,106.04 142.62,109.28 142.62,128.81 v2(142.52,128.91)
  BOTTOM w0.102: U42.BP2 142.22,129.21 v2(142.52,128.91)
  BOTTOM w0.216: JDIM2.120 151.03,82.63 v1(151.06,82.66)
M_A_A12: length 56.7
  IN1 w0.127: v2(142.52,130.2) 142.36,130.04 141.93,130.04 141.35,130.61 140.92,130.61 140.47,130.16 140.47,118.39 140.6,118.26 140.77,118.26 140.89,118.13 140.89,117.88 140.77,117.75 140.6,117.75 140.47,117.62 140.47,117.37 140.6,117.24 140.77,117.24 140.89,117.12 140.89,116.86 140.77,116.73 140.6,116.73 140.47,116.61 140.47,116.35 140.6,116.23 140.77,116.23 140.89,116.1 140.89,115.85 140.77,115.72 140.6,115.72 140.47,115.59 140.47,115.34 140.6,115.21 140.77,115.21 140.89,115.08 140.89,114.83 140.77,114.7 140.6,114.7 140.47,114.58 140.47,114.32 140.6,114.19 140.77,114.19 140.89,114.07 140.89,113.81 140.77,113.69 140.6,113.69 140.47,113.56 140.47,113.31 140.6,113.18 140.77,113.18 140.89,113.05 140.89,112.8 140.77,112.67 140.6,112.67 140.47,112.54 140.47,112.29 140.6,112.16 140.77,112.16 140.89,112.04 140.89,111.78 140.77,111.65 140.6,111.65 140.47,111.53 140.47,111.27 140.6,111.15 140.77,111.15 140.89,111.02 140.89,110.77 140.77,110.64 140.6,110.64 140.47,110.51 140.47,110.26 140.6,110.13 140.77,110.13 140.89,110 140.89,109.75 140.77,109.62 140.6,109.62 140.47,109.5 140.47,108.99 143.69,105.77 143.69,95.43 149.67,89.45 149.67,88.08 150.08,87.67 v1(150.08,87.62)
  BOTTOM w0.102: U42.BP4 142.21,130.51 v2(142.52,130.2)
  BOTTOM w0.216: JDIM2.119 150.78,88.25 150.32,87.8 150.25,87.8 v1(150.08,87.62)
M_A_A13: length 61.5
  IN1 w0.127: v1(163.51,84.13) 163.01,83.63 163.01,82.91 162.88,82.79 162.3,82.79 162.17,82.91 162.17,84.34 163.14,85.31 163.32,85.31 164.3,84.33 164.53,84.33 164.71,84.51 164.71,84.73 163.66,85.78 163.66,85.96 164.13,86.43 164.13,92.51 161.33,95.31 161.33,95.49 161.54,95.7 161.54,96.03 161.29,96.28 161.29,96.46 161.54,96.71 161.54,96.96 161.41,97.09 161.4,97.09 161.27,97.22 161.27,103.39 161.4,103.52 161.41,103.52 161.54,103.64 161.54,103.9 161.41,104.02 161.4,104.02 161.27,104.15 161.27,104.4 161.4,104.53 161.41,104.53 161.54,104.66 161.54,104.91 161.41,105.04 161.4,105.04 161.27,105.17 161.27,105.42 161.4,105.55 161.41,105.55 161.54,105.67 161.54,105.93 161.41,106.06 161.4,106.06 161.27,106.18 161.27,106.44 161.4,106.56 161.41,106.56 161.54,106.69 161.54,106.94 161.41,107.07 161.4,107.07 161.27,107.2 161.27,107.6 158.4,110.47 158.4,121.19 157.53,122.06 157.53,124.3 156.71,125.13 156.71,127.93 156.55,128.08 155.93,128.08 v2(155.91,128.05)
  BOTTOM w0.102: U42.AM2 156.57,128.89 156.57,128.29 156.36,128.08 155.93,128.08 v2(155.91,128.05)
  BOTTOM w0.216: v1(163.51,84.13) 162.53,83.15 JDIM2.158
M_A_ACT#: length 54.3
  IN1 w0.127: v2(138.06,128.24) 137.91,128.24 137.6,127.93 137.6,127.47 138.34,126.73 138.34,108.68 140.86,106.16 140.86,101.02 140.61,100.77 140.61,96.07 146.19,90.48 146.19,86.73 148,84.92 148,83.83 148.55,83.28 v1(149.03,83.28)
  BOTTOM w0.102: v2(138.06,128.24) 138.52,128.24 138.77,128.48 138.77,128.8 U42.BW2
  BOTTOM w0.216: v1(149.03,83.28) 149.03,83.27 149.53,82.78 JDIM2.114
M_A_ALERT#: length 92.1
  IN1 w0.114: v1(150.03,82.63) 150.35,82.63 150.99,81.99 159.86,81.99 160.03,82.16 185.88,82.16 186.53,82.8 186.53,85 187.21,85.69 187.21,88.77 186.95,89.04 186.95,96.94 186.85,97.04 186.85,99.2 186.73,99.31 186.73,105.08 181.96,109.86 181.96,119.38 175.71,125.62 175.71,128.22 v2(173.79,130.14)
  BOTTOM w0.102: U42.D3 174.06,129.86 v2(173.79,130.14)
  BOTTOM w0.14: v1(150.03,82.63) JDIM2.116
M_A_BA0: length 60.3
  IN1 w0.127: v1(159.26,84.14) 159.19,84.14 158.88,84.45 158.88,85.1 159.16,85.38 159.16,88.54 159.31,88.7 159.31,91.13 156.9,93.54 155.79,94.64 155.56,94.88 155.56,95.31 155.43,95.44 155,95.44 154.87,95.57 154.87,95.82 154.99,95.95 155.43,95.95 155.56,96.07 155.56,96.33 155.43,96.45 154.99,96.45 154.87,96.58 154.87,96.84 154.99,96.96 155.43,96.96 155.56,97.09 155.56,100.42 155.81,100.68 155.81,103.76 155.68,103.88 155.4,103.88 155.28,104.01 155.28,104.26 155.4,104.39 155.68,104.39 155.81,104.52 155.81,104.77 155.68,104.9 155.4,104.9 155.28,105.03 155.28,105.28 155.4,105.41 155.68,105.41 155.81,105.53 155.81,105.79 155.68,105.91 155.4,105.91 155.28,106.04 155.28,106.3 155.4,106.42 155.68,106.42 155.81,106.55 155.81,106.95 150.47,112.29 150.47,128.83 150.36,128.95 150.36,129.97 150.48,130.1 150.81,130.1 150.94,129.97 150.94,129.45 151.08,129.31 151.26,129.31 151.38,129.43 v2(151.38,129.54)
  BOTTOM w0.102: v2(151.38,129.54) 151.7,129.86 U42.AW3
  BOTTOM w0.216: v1(159.26,84.14) 160.53,82.88 JDIM2.150
M_A_BA1: length 60.7
  IN1 w0.127: v2(151.38,130.19) 151.47,130.28 151.72,130.28 151.85,130.16 151.85,129.94 151.97,129.82 152.31,129.82 152.44,129.95 152.44,130.89 152.56,131 152.95,131 153.08,130.87 153.08,130.56 153.48,130.16 153.81,130.16 153.94,130.03 153.94,129.78 153.81,129.65 153.5,129.65 153.37,129.52 153.37,129.27 153.5,129.14 153.81,129.14 153.94,129.02 153.94,128.76 153.81,128.63 153.5,128.63 153.37,128.51 153.37,127.97 152.98,127.57 152.98,123.23 153.57,122.64 153.57,111.64 157.54,107.67 157.54,103.44 158.01,102.97 158.01,102.15 158.28,101.89 158.28,101.63 158.15,101.51 158.14,101.51 158.01,101.38 158.01,100.55 157.8,100.34 157.8,100.09 157.93,99.96 158.15,99.96 158.28,99.83 158.28,99.58 158.15,99.45 157.93,99.45 157.8,99.33 157.8,99.07 157.93,98.95 158.15,98.95 158.28,98.82 158.28,97.24 158.13,97.1 157.94,97.1 157.8,96.96 157.8,96.74 157.94,96.6 158.15,96.6 158.28,96.48 158.28,96.22 158.15,96.09 157.93,96.09 157.8,95.97 157.8,95.72 157.93,95.59 158.15,95.59 158.28,95.46 158.28,94.7 161.04,91.93 161.04,91.41 161.16,91.28 161.2,91.28 161.33,91.16 161.33,90.9 161.2,90.78 161.16,90.78 161.04,90.65 161.04,90.39 161.09,90.34 161.16,90.27 161.2,90.27 161.33,90.14 161.33,89.89 161.2,89.76 161.16,89.76 161.04,89.63 161.04,89.38 161.16,89.25 161.2,89.25 161.33,89.12 161.33,88.87 161.2,88.74 161.16,88.74 161.04,88.62 161.04,87.53 161.21,87.36 161.21,86.87 160.99,86.65 v1(160.48,86.65)
  BOTTOM w0.102: U42.AY3 151.32,130.19 v2(151.38,130.19)
  BOTTOM w0.216: v1(160.48,86.65) 160.33,86.65 159.28,87.71 JDIM2.145
M_A_BG#0: length 55.7
  IN1 w0.127: v1(150.07,86.33) 150.41,86.33 150.57,86.49 150.57,89.15 144.12,95.61 144.12,96.04 144.25,96.17 144.44,96.17 144.57,96.29 144.57,96.55 144.44,96.67 144.25,96.67 144.12,96.8 144.12,99.68 144.41,99.97 144.41,100.48 144.12,100.77 144.12,105.95 141.57,108.51 141.33,108.75 141.33,118.31 140.91,118.73 140.91,119.16 141.03,119.29 141.2,119.29 141.33,119.42 141.33,119.67 141.2,119.8 141.03,119.8 140.91,119.92 140.91,120.18 141.03,120.31 141.2,120.31 141.33,120.43 141.33,120.69 141.2,120.81 141.03,120.81 140.91,120.94 140.91,121.19 141.03,121.32 141.2,121.32 141.33,121.45 141.33,121.7 141.2,121.83 141.03,121.83 140.91,121.96 140.91,122.21 141.03,122.34 141.2,122.34 141.33,122.46 141.33,122.72 141.2,122.85 141.03,122.85 140.91,122.97 140.91,123.23 141.03,123.35 141.2,123.35 141.33,123.48 141.33,123.73 141.2,123.86 141.03,123.86 140.91,123.99 140.91,124.24 141.03,124.37 141.2,124.37 141.33,124.5 141.33,124.75 141.2,124.88 141.03,124.88 140.91,125 140.91,125.26 141.03,125.39 141.2,125.39 141.33,125.51 141.33,125.77 141.2,125.89 141.03,125.89 140.91,126.02 140.91,128.06 v2(141.1,128.26)
  BOTTOM w0.102: U42.BP1 141.83,128.26 141.11,128.26 v2(141.1,128.26)
  BOTTOM w0.216: JDIM2.115 149.78,88.65 149.59,88.47 149.59,86.78 149.86,86.51 149.88,86.51 150.07,86.33 v1(150.07,86.33)
M_A_BG#1: length 53.6
  IN1 w0.127: v1(148.82,87.44) 148.15,88.1 148.15,89.75 142.38,95.51 142.38,96.15 142.26,96.27 141.62,96.27 141.47,96.42 141.47,96.66 141.6,96.78 142.26,96.78 142.38,96.91 142.38,103.98 142.26,104.11 141.85,104.11 141.72,104.24 141.72,104.49 141.85,104.62 142.26,104.62 142.38,104.74 142.38,105.86 139.2,109.04 139.2,119.21 139.33,119.34 139.45,119.34 139.57,119.47 139.57,119.72 139.45,119.85 139.33,119.85 139.2,119.97 139.2,120.23 139.33,120.36 139.46,120.36 139.58,120.48 139.58,120.74 139.46,120.86 139.33,120.86 139.2,120.99 139.2,121.24 139.33,121.37 139.48,121.37 139.61,121.5 139.61,121.75 139.48,121.88 139.33,121.88 139.2,122.01 139.2,122.26 139.33,122.39 139.48,122.39 139.61,122.51 139.61,122.77 139.48,122.9 139.33,122.9 139.2,123.02 139.2,123.28 139.33,123.4 139.48,123.4 139.61,123.53 139.61,123.78 139.48,123.91 139.33,123.91 139.2,124.04 139.2,124.29 139.33,124.42 139.48,124.42 139.61,124.55 139.61,124.8 139.48,124.93 139.33,124.93 139.2,125.05 139.2,125.31 139.33,125.44 139.48,125.44 139.61,125.56 139.61,126.46 v2(139.24,126.84)
  BOTTOM w0.102: v2(139.24,126.84) 139.62,127.23 139.62,128.23 U42.BV1
  BOTTOM w0.216: v1(148.82,87.44) 149.28,87.9 JDIM2.113
M_A_CAS#: length 61.4
  IN1 w0.127: v2(155.87,129.54) 155.7,129.37 155.54,129.37 155.42,129.49 155.42,132.32 155.24,132.5 154.92,132.5 154.75,132.33 154.75,128.44 155.03,128.16 155.03,128.16 155.03,123.24 155.36,122.91 155.36,121.37 156.24,120.49 156.24,112.65 156.11,112.53 155.56,112.53 155.44,112.4 155.44,112.15 155.56,112.02 156.11,112.02 156.24,111.89 156.24,110.8 159.98,107.06 159.98,94.83 161.94,92.86 162.63,92.18 162.63,86.1 v1(160.98,84.45)
  BOTTOM w0.102: U42.AN3 v2(155.87,129.54)
  BOTTOM w0.216: v1(160.98,84.45) 162.03,83.4 JDIM2.156
M_A_CB0: length 2.2
  TOP w0.203: v1(144.03,82.86) 143.95,82.78 R265.2
  BOTTOM w0.14: v1(144.03,82.86) JDIM2.92
M_A_CB1: length 3
  TOP w0.14: R199.2 144.2,87.52 v1(144.25,87.48)
  BOTTOM w0.14: v1(144.25,87.48) 143.78,87.95 JDIM2.91
M_A_CB2: length 4.2
  TOP w0.203: v1(145.75,86.25) 145.73,86.22 R212.2
  BOTTOM w0.14: JDIM2.101 146.28,86.77 v1(145.75,86.25)
M_A_CB3: length 2.2
  TOP w0.14: v1(147.28,88.25) 147.3,88.28 R188.2
  BOTTOM w0.14: JDIM2.105 v1(147.28,88.25)
M_A_CB4: length 2
  TOP w0.203: R270.2 143.03,82.67 v1(143.03,82.67)
  BOTTOM w0.14: v1(143.03,82.67) JDIM2.88
M_A_CB5: length 2.1
  TOP w0.14: v1(142.87,88.22) 142.85,88.24 R191.2
  BOTTOM w0.14: v1(142.87,88.22) 142.78,88.31 JDIM2.87
M_A_CB6: length 2.2
  TOP w0.203: R268.2 146.07,82.7 146.03,82.75 v1(146.03,82.75)
  BOTTOM w0.14: v1(146.03,82.75) JDIM2.100
M_A_CB7: length 3.6
  TOP w0.203: R267.2 148.16,82.77 147.62,83.31 v1(147.5,83.31)
  BOTTOM w0.14: JDIM2.104 147.03,82.84 v1(147.5,83.31)
M_A_CKE0: length 52
  IN1 w0.127: v1(148.81,86.14) 148.1,86.14 147.72,86.53 147.72,89.57 141.04,96.25 141.04,99.72 141.23,99.92 141.82,99.92 141.95,100.04 141.95,103.17 141.29,103.83 141.29,106.34 138.77,108.86 138.77,127.64 v2(139.21,128.07)
  BOTTOM w0.102: v2(139.21,128.07) 139.19,128.09 U42.BW1
  BOTTOM w0.216: v1(148.81,86.14) 148.8,86.14 148.61,86.33 148.49,86.33 148.28,86.54 JDIM2.109
M_A_CKE1: length 55.3
  IN1 w0.127: v2(141.39,127.07) 141.39,126.96 141.76,126.59 141.76,108.93 144,106.68 145,105.68 145,105.25 144.88,105.12 144.68,105.12 144.55,105 144.55,104.74 144.68,104.61 144.88,104.61 145,104.49 145,104.23 144.88,104.11 144.68,104.11 144.55,103.98 144.55,103.73 144.68,103.6 144.88,103.6 145,103.47 145,95.34 151.01,89.33 151.01,84.89 150.38,84.27 149.71,84.27 149.43,84.55 v1(148.9,84.55)
  BOTTOM w0.102: U42.BN1 142.9,128.56 141.41,127.07 v2(141.39,127.07)
  BOTTOM w0.216: JDIM2.110 148.53,84.18 v1(148.9,84.55)
M_A_CLKN0: length 59
  IN1 w0.127: v1(156.18,87.29) 156.18,87.09 156.32,86.95 156.76,86.95 156.9,87.09 156.9,87.55 156.64,87.81 156.64,90.1 151.33,95.4 151.33,95.78 151.75,96.21 152.12,96.21 152.25,96.33 152.25,96.81 151.83,97.22 151.83,99.69 151.43,100.1 151.43,100.6 151.83,101.01 151.83,103.52 152.1,103.79 152.53,103.79 152.66,103.92 152.66,104.37 152.53,104.5 152.06,104.5 151.79,104.77 151.79,105.36 152.06,105.63 152.53,105.63 152.66,105.75 152.66,106.14 152.53,106.26 152.06,106.26 151.79,106.53 151.79,107.28 146.9,112.16 146.9,113.1 147.29,113.49 147.29,113.76 146.92,114.14 146.92,114.61 147.29,114.99 147.29,115.26 146.92,115.64 146.92,116.11 147.29,116.49 147.29,116.76 146.92,117.14 146.92,117.61 147.29,117.99 147.29,118.26 146.92,118.64 146.92,119.11 147.34,119.53 147.34,119.71 146.92,120.13 146.92,120.61 147.29,120.98 147.29,121.26 146.92,121.63 146.92,122.11 147.29,122.48 147.29,122.75 146.92,123.13 146.92,123.8 147.29,124.18 147.29,124.53 146.9,124.93 146.9,125.55 147.34,125.99 147.34,126.54 146.86,127.03 146.5,127.03 v1(146.32,126.84)
  BOTTOM w0.102: v1(146.32,126.84) 146.32,127.02 146.22,127.13 145.64,127.13 144.75,128.02 144.75,128.4 144.75,128.57 144.75,128.72 145.09,129.07 U42.BK2
  BOTTOM w0.152: JDIM2.139 155.78,88.4 155.74,88.36 155.74,87.2 155.9,87.04 156.02,87.04 156.18,87.19 v1(156.18,87.29)
M_A_CLKN1: length 57.5
  IN1 w0.127: v1(156.36,83.59) 156.36,83.59 156.57,83.8 157.24,83.8 157.65,84.21 157.65,85.96 158.02,86.32 158.02,88.37 157.75,88.64 157.75,90.56 153.37,94.95 153.37,103.01 153.78,103.42 153.78,106.87 148.46,112.19 148.46,127.01 147.8,127.67 147.8,129.02 147.16,129.65 146.69,129.65 146.29,130.05 145.61,130.05 v2(145.48,130.19)
  BOTTOM w0.102: U42.BK4 145.15,130.51 v2(145.48,130.19)
  BOTTOM w0.152: JDIM2.140 156.03,82.43 155.93,82.53 155.93,83.68 156.08,83.83 156.28,83.83 156.36,83.75 156.36,83.59 v1(156.36,83.59)
M_A_CLKP0: length 59
  IN1 w0.127: v1(156.18,86.46) 156.43,86.71 156.86,86.71 157.14,86.99 157.14,87.65 156.88,87.91 156.88,90.2 151.57,95.5 151.57,95.68 151.85,95.97 152.22,95.97 152.49,96.23 152.49,96.91 152.07,97.32 152.07,99.79 151.67,100.2 151.67,100.5 152.07,100.91 152.07,103.42 152.2,103.55 152.63,103.55 152.9,103.82 152.9,104.47 152.63,104.74 152.16,104.74 152.03,104.87 152.03,105.26 152.16,105.39 152.63,105.39 152.9,105.65 152.9,106.24 152.63,106.51 152.16,106.51 152.03,106.63 152.03,107.38 147.14,112.26 147.14,113 147.54,113.39 147.54,113.86 147.16,114.24 147.16,114.51 147.54,114.89 147.54,115.36 147.16,115.74 147.16,116.01 147.54,116.39 147.54,116.86 147.16,117.24 147.16,117.51 147.54,117.89 147.54,118.36 147.16,118.74 147.16,119.01 147.58,119.43 147.58,119.81 147.16,120.23 147.16,120.51 147.54,120.88 147.54,121.36 147.16,121.73 147.16,122.01 147.54,122.38 147.54,122.85 147.16,123.23 147.16,123.7 147.54,124.07 147.54,124.63 147.14,125.03 147.14,125.45 147.58,125.89 147.58,126.64 146.96,127.27 146.55,127.27 v2(146.32,127.49)
  BOTTOM w0.102: U42.BK1 144.95,128.43 144.95,128.1 145.73,127.33 146.16,127.33 v2(146.32,127.49)
  BOTTOM w0.152: v1(156.18,86.46) 156.18,86.64 156.02,86.8 155.8,86.8 155.5,87.1 155.5,88.29 155.28,88.51 JDIM2.137
M_A_CLKP1: length 57.5
  IN1 w0.127: v1(156.36,84.41) 156.36,84.2 156.52,84.04 157.14,84.04 157.41,84.31 157.41,86.06 157.78,86.42 157.78,88.27 157.51,88.54 157.51,90.46 153.13,94.85 153.13,103.11 153.54,103.52 153.54,106.77 148.22,112.09 148.22,126.91 147.56,127.57 147.56,128.92 147.06,129.41 146.59,129.41 146.19,129.81 145.6,129.81 145.48,129.68 v2(145.48,129.54)
  BOTTOM w0.102: U42.BK3 145.15,129.86 v2(145.48,129.54)
  BOTTOM w0.152: v1(156.36,84.41) 156.36,84.26 156.17,84.08 155.98,84.08 155.69,83.78 155.69,82.59 155.53,82.43 JDIM2.138
M_A_CS#0: length 60.9
  IN1 w0.127: v2(152.91,129.52) 152.67,129.28 151.89,129.28 151.77,129.15 151.77,128.69 151.9,128.57 152.43,128.57 152.54,128.45 152.54,127.93 152.42,127.8 151.96,127.8 151.83,127.67 151.83,127.38 151.95,127.25 152.42,127.25 152.54,127.12 152.54,122.74 152.7,122.59 153,122.59 153.13,122.46 153.13,122.21 153.01,122.08 152.65,122.08 152.52,121.95 152.52,121.7 152.65,121.57 153.01,121.57 153.13,121.45 153.13,121.19 153.01,121.06 152.65,121.06 152.52,120.94 152.52,120.69 152.65,120.56 152.98,120.56 153.13,120.41 153.13,120.18 153.01,120.05 152.65,120.05 152.52,119.92 152.52,119.67 152.65,119.54 152.99,119.54 153.13,119.4 153.13,119.16 153.01,119.03 152.65,119.03 152.52,118.91 152.52,118.65 152.65,118.52 153,118.52 153.13,118.39 153.13,118.14 153.01,118.02 152.65,118.02 152.52,117.89 152.52,117.64 152.65,117.51 153,117.51 153.13,117.38 153.13,117.13 153.01,117 152.65,117 152.52,116.87 152.52,116.63 152.65,116.49 152.93,116.49 153.05,116.37 153.05,116.12 152.93,115.99 152.49,115.99 152.36,115.86 152.36,115.61 152.49,115.48 153,115.48 153.13,115.35 153.13,115.1 153,114.97 152.27,114.97 152.14,114.84 152.14,114.59 152.27,114.46 152.93,114.46 153.05,114.33 153.05,114.08 152.93,113.95 152.27,113.95 152.14,113.83 152.14,113.62 152.31,113.44 153.01,113.44 153.13,113.32 153.13,113.06 153.01,112.94 152.4,112.94 152.27,112.81 152.27,112.33 157.11,107.49 157.11,100.77 157.37,100.51 157.37,94.99 160.61,91.76 160.61,88.16 v1(160.44,87.99)
  BOTTOM w0.102: v2(152.91,129.52) 152.88,129.52 U42.AV3
  BOTTOM w0.216: v1(160.44,87.99) 160.28,88.16 JDIM2.149
M_A_CS#1: length 58.6
  IN1 w0.127: v1(163.26,86.84) 163.69,87.28 163.69,92.33 160.84,95.19 160.84,107.42 157.97,110.29 157.97,111.29 157.96,111.31 157.84,111.42 157.23,111.42 157.1,111.55 157.1,111.8 157.23,111.93 157.84,111.93 157.97,112.06 157.97,112.31 157.84,112.44 157.24,112.44 157.1,112.57 157.1,112.82 157.23,112.94 157.84,112.94 157.97,113.07 157.97,113.33 157.84,113.45 157.24,113.45 157.1,113.59 157.1,113.83 157.23,113.96 157.84,113.96 157.97,114.09 157.97,121.01 157.1,121.88 157.1,124.12 156.27,124.95 156.27,127.33 155.99,127.61 155.74,127.61 155.48,127.88 155.48,128.25 155.73,128.51 156.94,128.51 157.06,128.64 157.06,129.26 156.94,129.39 156.43,129.39 156.3,129.52 156.3,129.7 156.8,130.2 156.8,130.38 156.58,130.59 156.35,130.59 155.95,130.19 v2(155.87,130.19)
  BOTTOM w0.102: U42.AN4 v2(155.87,130.19)
  BOTTOM w0.216: v1(163.26,86.84) 162.28,87.82 JDIM2.157
