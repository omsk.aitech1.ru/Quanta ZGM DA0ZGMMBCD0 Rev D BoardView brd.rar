# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Nets (continued)
N19241257: PR22.2 PR23.2 PR27.2
N19647217: PC10.1 PR81.1 PR88.1 PR116.1
N19940934: PC213.2 PR296.2
N19940963: PC503.1 PC509.1 PJ16.2 PL25.2 PR633.2 PR634.2
N19940984: PC222.1 PR307.2
N19940986: PC223.1 PC490.1 PC493.1 PC497.1 PJ14.2 PQ66.2
N19941004: PR634.1 PU15.14
N19941046: PR282.2 PR289.1 PR293.1 PU15.7
N19941069: PC488.1 PC492.1 PC495.1 PC496.1 PJ13.1 PQ65.2 PR300.2
N19941106: PC501.1 PC507.1 PJ17.2 PL24.1 PR629.1
N19941188: PC224.1 PR308.2
N19941230: PC212.2 PR295.1
N20974301: PC421.1 PC422.1 PC423.1 PJ12.1 PL22.2 PR610.2
N20974305: PC467.1 PR566.2 PU37.4(VIN)
N20974309: PR568.1 PR610.1
N20974323: PR539.2 PR540.2 PR549.1
N20974337: PR568.2 PR611.1 PU37.6
N20974353: PC424.2 PR549.2 PU37.1
N20974362: PR571.2 PU37.5
N21715576: PC189.1 PR259.1 PU11.1 PU11.2
N21715582: PC190.1 PR254.1 PR255.1 PU11.6 PU11.7
N21715612: PC177.1 PC178.1 PR208.1 PR209.1 PU11.8 PU11.9(VOUT2#2)
N21715630: PC201.1 PR261.1 PU11.4
N21715632: PC166.1 PU11.12
N21715634: PC167.1 PU11.10
N21715657: PC175.1 PC176.1 PR214.2 PU11.13 PU11.14
N21715675: PC202.1 PR253.2 PU11.5
N21715683: PC200.1 PR252.1 PU11.3
N21716526: PC196.1 PR264.1 PR265.1 PU12.1 PU12.2
N21716532: PC197.1 PR266.1 PR267.1 PU12.6 PU12.7
N21716562: PC184.1 PC185.1 PR215.1 PR216.1 PU12.8 PU12.9(VOUT2#2)
N21716580: PC203.1 PR257.2 PU12.4
N21716582: PC170.1 PU12.12
N21716584: PC171.1 PU12.10
N21716605: PC182.1 PC183.1 PR217.2 PR218.2 PU12.13 PU12.14
N21716627: PC205.1 PR258.1 PU12.5
N21716633: PC204.1 PR256.2 PU12.3
N23334321: PC512.1 PR652.2 PU38.4
N23334329: PC500.2 PR637.1
N23334507: PR653.1 PU38.3
N23334555: PC268.1 PR339.2
N24995566: PC393.1 PR513.2 PU27.5(VCC)
N24995570: PR511.1 PU27.1
N24995581: PR512.1 PU27.3
N25272034: PR617.2 PR618.1 PR619.1
N25272043: PC207.1 PR268.2
N25272083: PC208.1 PC209.1 PJ5.2 PR615.1 PU14.9 PU14.10(VIN#2)
N25430994: PQ23.3 PR270.2
N25431520: PQ22.3 PR614.2
N25506978: PQ30.2 PQ33.2 PQ34.3 PQ35.2 PR310.2 PR311.1
N25507004: PQ35.3 PR309.2
N27093787: R837.2 U9.J6
N31779326: C315.2 R277.2
N31996495: Q110.2 Q111.3 R985.2
N32113508: CN6.56 TP128.1
N32113521: CN6.58 TP127.1
N36119360: PD1.2 PQ13.3 PR127.1
N36119368: PQ13.2 PQ63.3 PQ64.2 PR518.1 PR526.2
N36119381: PR534.2 PU28.3
N36119386: PQ64.3 PR133.2
N36119389: PC120.1 PQ63.2 PR132.1 PR135.2 PU28.4
N36119404: PC408.1 PC410.1 PQ14.5 PR536.1 PR538.1
N36119409: PC398.1 PR530.2
N36392478: Q111.2 R519.2 R1002.1
N45101115: C455.2 U21.28
N45105751: C413.2 U21.2
N45109965: C489.2 U21.19(VREF)
N45110431: C488.2 C501.1 U21.18
N45113988: D31.2 D37.2 R372.2 R373.1 R404.2 R418.2 U21.11
N46786228: PC46.2 PR477.1
N46786420: PC29.2 PR99.2
N46787062: PR92.2 PR483.2
N46788466: PC12.2 PR57.2
N46789361: PC10.2 PR71.2
N46789649: PC7.2 PR53.2
N46792326: PR59.1 PR68.2
N47371767: CN13.58 TP151.1
N47371769: CN13.56 TP152.1
N47375149: CN6.10 R930.1
N48158653: PC278.2 PR350.1 PR357.1 PR358.1 PR359.1 PR360.2
N48158687: PR397.2 PR398.1 PR481.2
N48158704: PC301.2 PR387.2
N48158713: PC311.1 PR390.1
N48158820: PR393.1 PR396.1 PR482.1
N49353207: CN13.10 R1072.1
N49355730: CN12.38 TP150.1
N49355733: CN12.40 TP148.1
N49355736: CN12.42 TP147.1
N53255970: R441.2 U18.29
N53256180: R386.2 U18.19
N53256182: R384.2 U18.21
N53564538: C691.1 CN3.2 Q100.3 R819.2 R820.2
N53564570: Q99.2 R816.2
N53565581: Q35.2 R293.1
N53565628: C289.1 CN8.2 Q31.3 R273.2 R274.2
N53716068: PQ15.3 PR137.2
N53716070: PQ15.2 PQ16.3 PR139.2 PR140.1
N53788150: PQ4.2 PQ5.3 PR36.2 PR45.1
N53788267: PQ5.2 PR35.1 PR43.1
N53788269: PC279.1 PR351.2 PR352.2
N53788407: PQ4.3 PR365.2
N53788559: PQ1.2 PQ2.3 PR1.1 PR30.2
N53788585: PC30.1 PR100.1
N53788806: PC331.1 PR429.1
N53789031: PQ1.3 PR11.2
N53789209: PQ2.2 PR20.2
N54130914: R490.1 U18.1(VSB)
N54227218: TP59.1 U24.6
N54227279: TP60.1 U24.7
N54443582: T6.1 U56.27
N54443594: T5.1 U56.26
N54443678: T3.1 U56.38
N54443680: T4.1 U56.35
N54443682: T2.1 U56.3
N55927396: PC413.2 PR541.1
N55927404: PR559.2 PU29.31(ZCSET)
N55927441: PC475.1 PR569.2
N55927461: PR575.2 PU29.35
N55927578: PR574.2 PU29.36
N55927589: PR572.2 PU29.39
N55927593: PR573.2 PU29.37
N55927597: PU29.6 PU29.41 TP117.1
N55927792: PC465.1 PR551.2 PU29.3
N55928956: PC414.2 PR542.1
N55928964: PR558.2 PU30.31(ZCSET)
N55929001: PC474.1 PR567.2
N55929021: PR578.2 PU30.35
N55929149: PR570.2 PU30.39
N55929153: PR576.2 PU30.37
N55929157: PU30.6 PU30.41 TP116.1
N55929352: PC466.1 PR550.2 PU30.3
N55940902: PC420.2 PR543.1
N55940967: PC476.1 PR583.2
N55940969: PC468.1 PR552.2 PU31.3
N55940971: PR582.1 PU31.35
N55940973: PR581.1 PU31.36
N55940977: PR580.2 PU31.37
N55940983: PU31.6 PU31.41 TP123.1
N55940988: PR563.2 PU31.31(ZCSET)
N55941017: PR564.2 PU32.31(ZCSET)
N55941021: PC415.2 PR544.1
N55941039: PC477.1 PR588.2
N55941042: PR587.1 PU32.35
N55941044: PR586.1 PU32.36
N55941048: PR585.2 PU32.37
N55941050: PR584.1 PU32.39
N55941056: PU32.6 PU32.41 TP120.1
N55941092: PR560.2 PU33.31(ZCSET)
N55941096: PC416.2 PR545.1
N55941113: PC478.1 PR593.2
N55941116: PR592.1 PU33.35
N55941118: PR591.1 PU33.36
N55941122: PR590.2 PU33.37
N55941124: PR589.1 PU33.39
N55941130: PU33.6 PU33.41 TP119.1
N55941168: PR561.2 PU34.31(ZCSET)
N55941172: PC417.2 PR546.1
N55941190: PC479.1 PR598.2
N55941193: PR597.1 PU34.35
N55941195: PR596.1 PU34.36
N55941199: PR595.2 PU34.37
N55941201: PR594.1 PU34.39
N55941207: PU34.6 PU34.41 TP121.1
N55941243: PR565.2 PU35.31(ZCSET)
N55941247: PC418.2 PR547.1
N55941265: PC480.1 PR603.2
N55941268: PR602.1 PU35.35
N55941270: PR601.1 PU35.36
N55941274: PR600.2 PU35.37
N55941276: PR599.1 PU35.39
N55941282: PU35.6 PU35.41 TP118.1
N55941318: PR562.2 PU36.31(ZCSET)
N55941322: PC419.2 PR548.1
N55941340: PC481.1 PR608.2
N55941343: PR607.1 PU36.35
N55941345: PR606.1 PU36.36
N55941347: PR605.2 PU36.37
N55941349: PR604.1 PU36.39
N55941355: PU36.6 PU36.41 TP122.1
N55941374: PC469.1 PR553.2 PU32.3
N55941387: PC470.1 PR554.2 PU33.3
N55941398: PC471.1 PR555.2 PU34.3
N55941409: PC472.1 PR556.2 PU35.3
N55941420: PC473.1 PR557.2 PU36.3
N56077694: C562.1 C563.1 Q69.3 Q70.3 Q71.2 Q71.5 Q72.2 Q72.5 R675.2
N56077756: Q68.3 Q69.2 R674.2
N56077770: Q72.1(S) Q72.4
N56077935: Q67.3 Q70.2 R673.2
N56085203: C544.2 R640.1 U29.1(VOUT)
N56199005: R1168.2 U55.10
N56202137: CN18.13 R1171.2
N56214175: PR579.1 PU31.39
N56249919: Q71.1(S) Q71.4
N56249956: R621.2 U29.3
N56250018: C525.1 R618.1 U29.4 U29.5
N56253576: PR577.2 PU30.36
N56276780: C173.2 Q18.2 R132.1
N56849294: C343.1 C347.1 C352.1 C361.1 Q41.3 R295.1
N56849590: C391.2 Q41.2 R403.2 R416.2 R611.2
N56881941: R671.1 U34.1 U34.5(VCC)
N58459581: PQ30.3 PR297.2
N59747615: PQ25.2 PQ26.3 PR287.2 PR288.1
N59747617: PQ25.3 PR271.2
N59809104: Q12.3 Q13.2 R63.1 R64.2
N59809106: Q13.3 R68.2
N60121159: PC377.1 PQ58.1 PQ58.2 PQ58.3(S3) PQ59.1 PQ59.2 PQ59.3(S3) PR470.1
N60121164: PC241.1 PL26.2 PQ36.1 PQ36.2 PQ36.3(S3) PR320.1 PR622.2 PR631.1
N60121172: PC377.2 PC383.2 PQ58.4 PQ59.4 PR485.1
N60121246: PC270.1 PR345.2
N60121264: PC259.2 PR327.2
N60121271: PQ59.5 PR486.1 PR500.1
N60121298: PQ37.2 PQ70.2 PR330.1 PR335.1 PR336.1 PU18.10
N60121308: PC241.2 PQ36.4 PR314.1
N60121335: PC243.1 PR318.1 PU18.28(VCC)
N60121339: PR333.1 PU18.11
N60121341: PR334.1 PU18.12
N60121342: PR319.1 PU18.7
N60121344: PR325.1 PU18.9
N60121361: PR317.1 PU18.5
N60121365: PR340.2 PR657.2 PU18.15
N60121374: PR322.1 PU18.8
N60121443: PQ38.2 PQ70.3 PR338.1
N60121447: PQ38.3 PR331.2
N60121455: PQ37.3 PQ68.2 PR643.1
N60121459: PQ68.3 PR648.2
N60121483: PD3.3(COMMON ANODE) PR318.2
N60415319: PC353.2 PQ46.4 PQ47.4 PR457.1 PR466.2
N60415322: PQ55.1(S) PR465.2
N60415324: PQ55.3 PR466.1
N60415329: PC353.1 PQ46.1 PQ46.2 PQ46.3(S3) PQ47.1 PQ47.2 PQ47.3(S3) PR457.2
N60415356: PC364.2 PQ48.4 PQ49.4 PR467.1 PR469.2
N60415361: PQ51.3 PR469.1
N60415366: PC364.1 PQ48.1 PQ48.2 PQ48.3(S3) PQ49.1 PQ49.2 PQ49.3(S3) PR467.2
N60419650: PR97.2 PR412.1 PR426.2 PR428.1
N60434551: PC379.1 PQ54.2 PR472.1 PR478.2
N60434568: PQ54.3 PR473.1
N60434570: PC360.2 PQ45.4 PQ50.4 PR464.1 PR473.2
N60434578: PC360.1 PQ45.1 PQ45.2 PQ45.3(S3) PQ50.1 PQ50.2 PQ50.3(S3) PR464.2
N60447029: PC381.1 PQ57.2 PR475.1
N60481587: PQ60.4 PR509.2 PR510.1
N60536855: PC363.1 PQ51.2 PR468.1
N60538244: PQ57.3 PR472.2
N60539202: PC380.1 PQ53.2 PR471.1
N60539593: PC378.1 PQ55.2 PR476.1
N60539854: PQ53.3 PR465.1
N60541902: PC53.1 PR112.2 PU6.3(V+)
N60541904: PR104.1 PU6.1
N60541918: PR103.2 PU6.6
N62866854: PR58.1 PR61.1 PR62.1 PU1.1
N62866877: PU1.3 PU5.6
N62866886: PR38.2 PR48.2 PU1.2
N62866953: PC54.1 PR115.2 PU5.3(V+)
N62867585: PR111.2 PU5.1
N63146067: PC388.1 PQ62.2 PR503.2
N63146116: PC387.1 PQ12.2 PR502.2
N63146153: PQ62.3 PR504.2
N63146169: PQ12.1(S) PR504.1
N63146173: PC392.1 PQ12.3 PQ61.2 PR505.2 PR506.1
N63148268: PR506.2 PR507.2 PR508.2 PR509.1
N63148362: PQ61.3 PR510.2
N64129205: R800.2 U42.CT24
N64186431: TP158.1 U49.BC48
N64265500: R948.1 U49.BG13
N65800419: PQ6.3 PQ7.2 PR410.2
N65800425: PQ6.2 PR401.1 PR409.1
N65858536: PR93.1 PR94.2 PR98.1 PR413.1
N65858616: PQ9.2 PQ40.3 PR90.2
N65858620: PQ40.2 PR76.1 PR84.1
N65865868: PQ7.3 PR97.1
N65865900: PQ9.3 PR413.2
N66086348: PQ8.2 PR95.2
N66086758: PQ10.2 PR411.2
N66087447: PR61.2 Q8.2
N78693073: Q96.2 Q96.3 R798.2
N78693124: Q96.5 R799.2 R801.2 U41.4
N78802721: TP93.1 U42.BD40
N78802728: TP101.1 U42.BD41
N78802735: TP92.1 U42.BD37
N78802737: TP100.1 U42.BD36
N78802759: TP105.1 U42.BP40
N78802926: TP91.1 U42.AM41
N78802933: TP89.1 U42.AM40
N78802940: TP96.1 U42.AN41
N78963500: TP155.1 U49.C36
N78963508: TP154.1 U49.D36
N78963515: TP71.1 U49.L36
N78963531: TP74.1 U49.J37
N78983942: D71.2 R1157.2
N78983951: D71.1 R1160.2
N79012469: TP53.1 U49.AM15
N79039454: TP51.1 U49.AC11
N79039460: TP52.1 U49.AC12
N79070746: TP72.1 U49.AW37
N79156031: JDIM2.162 TP42.1
N79156044: JDIM2.165 TP32.1
N79156113: Q33.2 R308.2
N79244319: JDIM1.162 TP26.1
N79244333: JDIM1.165 TP24.1
N79250891: R935.2 U16.J6
N79252860: Q19.2 R142.2
N79254828: C256.2 R189.2
N79287073: C437.2 R440.1
N79287127: C440.1 U23.12
N79287181: R574.2 U23.66
N79287203: C446.1 R474.2 U23.82
N79287219: R362.1 U23.99
N79287231: R317.1 R318.1 R334.2 R335.2 R348.2
N79287237: C395.1 R406.2 U23.2
N79287238: C369.1 R353.2 U23.128
N79287282: C513.1 Q53.2 Q53.3 R581.1
N79287301: R578.1 R581.2 R584.1
N79287317: R493.1 U23.20
N79287363: R528.1 U23.24
N79287372: R538.1 U23.25
N79287384: R455.2 U23.87
N79287387: R477.2 U23.15
N79287457: Q56.3 R615.2
N79287463: R483.2 U23.16
N79287499: TP77.1 U23.64
N79287500: TP76.1 U23.65
N79447335: QG15.5 QG15.6 RG106.1
N79447337: CG401.1 QG8.2 QG8.5 QG15.3 RG93.1
N79449214: QG22.2 QG23.3 RG171.2
N79450667: QG10.2 QG10.5 RG85.1
N79453383: RG133.1 UG7.7(\\S\P\I\_\H\O\L\D)
N79546811: RG169.2 UG11.1
N79546831: RG92.2 RG173.2 UG11.2
N79546869: RG172.2 UG10.1
N79546889: RG91.2 RG170.2 UG10.2
N79558552: QG15.2 RG99.2
N79558559: RG94.2 RG99.1
N79575148: CG403.1 RG95.1 RG96.1 UG2.5
N79575380: DG1.3(COMMON ANODE) QG14.2 RG88.2
N79575434: CG405.1 QG14.5 QG14.6 RG104.2
N79667727: QG13.2 RG97.1 RG98.1
N79956292: PC255.1 PC269.1 PC273.1 PC274.1 PC275.1 PC276.1 PC516.1 PC517.1 PC518.1 PC519.1 PC524.2 PC525.2 PC526.2 PJ7.1 PL27.2 PR644.2
N79956312: PC277.2 PR346.1
N79964562: PR194.1 PR198.2 PR204.2
N79964568: PQ19.3 PQ20.2 PR179.1 PR182.2
N79964844: PC165.2 PC169.1 PC180.1 PR212.1 PR221.2 PR241.1
N79965031: PC165.1 PR240.1
N79965205: PC192.1 PC194.1 PR247.1 PR251.1
N79965238: PC157.1 PR163.1 PR166.1 PR178.1
N79965309: PC192.2 PR234.1
N79965319: PC188.1 PR233.1 PR612.1
N79965429: PR164.1 PR165.1
N79965651: PR231.2 PR245.2
N79966658: PQ18.3 PR162.2
N79966696: PQ17.3 PQ18.2 PR144.1 PR146.2
N79966767: PQ17.2 PR145.1
N80010015: QG12.2 QG12.5 RG103.1
N80011119: QG11.2 QG11.5 RG101.1
N80538567: R814.1 U43.4(Y) U44.2
N80539359: Q80.3 R723.2
N80539361: Q80.2 Q84.3 R728.2 R732.1
N80546240: Q82.3 R727.1
N80546897: R82.2 R83.1 R85.1 U4.2
N80546937: R79.1 R80.2 R81.2 U4.5
N80547209: QG2.2 QG2.3 R88.1
N80570435: C422.1 R434.2 U20.35
N80570444: C421.1 R435.2 U20.36
N80571375: R454.2 U20.33
N80571553: C445.2 U20.32
N80572115: C469.1 U20.25
N80572629: C407.2 U20.38(VREF)
N80572801: C755.2 R957.2 U20.39
N80576314: R383.1 R390.2 R398.2 U20.1
N80631277: C483.1 C490.1 L22.1 U20.20
N80631343: C778.1 U20.21
N80633779: C485.1 U20.19
N81193871: R147.2 U8.6
N81193876: C189.2 U8.5
N81194222: C220.1 U8.11(VREG)
N81194306: TP27.1 U8.3
N81194319: TP25.1 U8.4
N81194476: R162.2 R163.1 U8.9
N81195388: C322.2 U15.5
N81195415: R284.2 U15.6
N81195478: TP45.1 U15.3
N81195507: TP44.1 U15.4
N81195511: R341.2 R342.1 U15.9
N81195559: C356.1 U15.11(VREG)
N81212064: Q9.3 U1.3
N81221610: LED2.2 R686.1
N81221622: LED2.1 R683.1
N81221647: LED2.4 LED2.5 LED2.6 Q74.6
N81221898: LED3.4 LED3.5 LED3.6 Q74.3
N81221918: LED3.1 R4.1
N81221920: LED3.2 R695.1
N81221922: LED3.3 R694.1
N81223341: LED4.4 LED4.5 LED4.6 Q1.6
N81223347: LED1.4 LED1.5 LED1.6 Q1.3
N81223387: LED4.1 R682.1
N81223389: LED4.2 R696.1
N81223391: LED4.3 R5.1
N81223393: LED1.1 R47.1
N81223395: LED1.2 R48.1
N81223397: LED1.3 R49.1
N81224802: LED5.4 LED5.5 LED5.6 Q3.6
N81224808: LED6.4 LED6.5 LED6.6 Q3.3
N81224848: LED5.1 R678.1
N81224850: LED5.2 R690.1
N81224852: LED5.3 R680.1
N81224854: LED6.1 R11.1
N81224856: LED6.2 R7.1
N81224858: LED6.3 R8.1
N81228094: Q36.3 R330.2
N81228098: Q34.3 R289.2
N81229156: Q66.3 R650.2
N81229158: Q65.3 R649.2
N81229164: Q65.6 R654.2
N81246200: Q81.3 R730.2
N81246208: Q81.6 R724.2
N81246213: Q86.3 R729.2
N81660210: CN19.9 R1143.2
N81660211: CN19.8 R1144.2
N81660387: CN19.1 R1151.2 R1152.2
N81714774: R1126.2 R1146.1 U54.3
N81715455: Q114.3 R1152.1
N81715916: Q61.3 R631.2 R643.1
N81715961: C545.1 Q61.2 Q64.3 R642.2
N81716020: C874.1 Q64.2 R645.1 R1233.2
N81719173: Q58.3 R644.2 R646.1
N81719224: C541.1 Q58.2 Q59.3 R634.2
N81719273: C875.1 Q59.2 R635.1 R1234.2
N81807638: PC146.1 PL2.1 PU9.6 PU9.30 PU9.31
N81807642: PC149.2 PL2.2 PU9.19 PU9.26 PU9.27
N81807662: PC146.2 PU9.7
N81807690: PC149.1 PU9.18
N81807757: PC124.1 PC125.1 PC135.1 PC521.2 PR138.1 PU9.1 PU9.2 PU9.3 PU9.4 PU9.5 PU9.32
N81807781: PC123.1 PC134.1 PC136.1 PC145.1 PC523.2 PR136.1 PR141.2 PU9.17 PU9.20 PU9.21 PU9.22 PU9.23 PU9.24 PU9.25
N81807999: PR141.1 PR147.1
N81808027: PR142.2 PR143.1 PU9.8
N81808059: PR147.2 PR153.1 PU9.10
N81808076: PR152.2 PR154.1 PU9.13
N81808078: PC151.1 PR148.2 PU9.11
N81808084: PR149.2 PU9.14
N81808086: PR150.2 PU9.15
N81808088: PR151.2 PU9.16
N81808152: PC152.1 PR148.1
N81980636: Q117.3 R1175.1
N81980639: Q117.6 R1176.1
N81981614: Q52.1(S) R556.2 R563.2 R569.2
N82151523: C267.1 Q24.3 R207.2 R211.1 R228.2
N82151584: C255.1 Q21.3 Q24.2 R182.2
N82154411: TP30.1 U11.H6
N82154412: TP39.1 U11.A6
N82154792: TP135.1 U11.C6
N82161843: R187.1 U11.E8
N82161861: R263.1 U11.A4
N82161876: R888.1 U11.A3(VSYS)
N82161891: R887.1 U11.B4
N82161906: R196.1 U11.D8
N82284456: Q116.2 R1170.1 R1172.2
N82291980: CN7.6 R835.2 R836.2 R839.2
N82294378: CN7.24 TP131.1
N82296250: D65.1 LG8.1 R1018.2 R1026.1
N82296273: D63.1 LG6.1 R1022.1
N82296311: D64.1 LG7.1 R1025.1
N82364605: C805.1 R1045.1 U50.C1
N82364645: C810.1 R1060.1 U50.C2(VDD)
N82368376: C809.1 R1051.1 U51.C1
N82368414: C813.1 R1063.1 U51.C2(VDD)
N82537287: C620.1 C621.1 Q91.1(S) R747.2
N82537484: Q14.2 Q15.3 R76.1
N82537501: R67.2 R69.2 U3.1
N82537584: Q15.2 R77.2 R78.2
N82538045: C612.1 C616.1 C618.2 Q89.1(S) R743.2
N82538223: R745.1 U2.4
N82538249: R70.2 U2.1
N82538267: Q87.3 R738.2
N82555593: Q60.3 R625.1 R630.2
N82846357: Q39.2 Q39.3 R374.2
N82850179: CN10.35 R420.2
N82850388: Q16.3 Q17.2 R110.2
N82850432: Q16.2 R108.2 R109.2
N82853033: Q98.1(S) R809.2 R810.2
N82853047: Q97.2 R810.1
N82984178: R812.2 R813.2 U44.1
N82987111: CN12.58 R381.1
N82987114: CN12.60 R366.1
N82991704: R429.1 U23.3
N83064721: PC15.1 PR82.1 PR399.2
N83065191: PC1.1 PR5.1 PR6.2 PR7.1 PR17.2
N83065260: PR16.1 PR17.1 PU2.23
N83065359: PR25.1 PR32.1 PU2.24
N83065483: PR73.2 PU2.8
N83068063: PQ11.2 PR91.2
N83068069: PQ11.3 PR26.2
N83072148: Q54.2 R590.1 R609.1
N83075521: PC100.1 PC394.1 PC395.1 PJ2.1 PU7.2 PU7.3 PU7.4
N83075806: PR120.2 PR121.2 PR123.1
N83075814: PC101.2 PR122.2 PU7.9
N83075884: PC99.2 PR120.1 PR516.1 PU7.11
N83075891: PC99.1 PR121.1
N83076272: PC92.1 PC93.1 PC94.1 PC95.1 PJ1.2 PL13.2 PR123.2
N83080882: PC96.1 PU7.13(VCC)
N83081355: PR514.2 PR515.1 PU7.10
N83081712: PR118.1 PU7.7
N83083660: PC97.2 PL13.1 PR124.2 PU7.5 PU7.15 PU7.16
N83085661: PC116.1 PC122.1 PC401.1 PJ3.1 PU8.2 PU8.3 PU8.4
N83085739: PC402.1 PU8.13(VCC)
N83085803: PR537.1 PU8.1
N83085805: PC409.1 PR537.2
N83085807: PC409.2 PL1.1 PR517.2 PU8.5 PU8.15 PU8.16
N83085819: PC406.1 PC407.1 PC411.1 PC412.1 PJ4.2 PL1.2 PR533.2
N83085845: PR128.2 PR531.1 PU8.10
N83085921: PR129.2 PR131.2 PR533.1
N83085945: PR125.1 PU8.7
N83085968: PC397.2 PQ72.2 PR126.2 PU8.9
N83085998: PC121.2 PR129.1 PR532.1 PU8.11
N83086004: PC121.1 PR131.1
N83090046: R430.2 U23.5
N83090076: R586.2 U23.37
N83090094: R587.2 U23.39
N83090107: R583.2 R596.2 R1190.2 U23.40
N83091465: PR281.2 PR633.1
N83092641: PC228.1 PR301.1 PR303.1 PU17.1 PU17.2 PU17.6 PU17.7
N83092840: PC225.2 PR305.1 PU17.4
N83092971: PC217.1 PU17.12
N83092973: PC218.1 PU17.10
N83178683: PR18.2 PU2.18
N83179814: PR119.1 PU7.1
N83179815: PC97.1 PR119.2
N83250563: TP50.1 U49.T8
N83250570: TP46.1 U49.T7
N83308892: TP115.1 U42.B3
N83308905: TP113.1 U42.B4
N83308928: TP13.1 U42.E34
N83379619: Q93.3 Q95.2 R753.2 R759.1
N83379972: C632.1 Q94.2 Q95.3 R752.2
N83382742: TP110.1 U42.CR4
N83382743: TP114.1 U42.CP4
N83382768: TP65.1 U49.AK37
N83382769: TP67.1 U49.AH37
N83385689: TP66.1 U49.Y33
N83442053: TP2.1 U1.2
N83449779: TPS3.1 U49.V39
N83519107: TP73.1 U49.BA36
N84112149: LED7.2 R685.1
N84112155: LED7.3 R679.2
N84112164: LED7.1 R14.2
N84112222: LED7.4 LED7.5 LED7.6 Q5.3
N84113271: LED2.3 R697.1
N84114122: Q34.6 R322.2
N84117833: TP69.1 U27.16
N84117877: TP79.1 U27.22
N84357192: R551.2 U49.AY42
N84561731: UG4.4(Y) UG5.1
N84562167: R588.2 U23.38
N84718764: CN24.6 R669.2
N84917166: PC198.1 PC199.1 PR260.1 PR263.1 PU13.1 PU13.2 PU13.6 PU13.7
N84917339: PC482.1 PR613.2 PU13.4
N84917398: PC172.1 PU13.12
N84917400: PC173.1 PU13.10
N85188370: R713.2 R715.2 U38.3
N86880418: Q104.1(S) R855.1
N87340512: PR379.1 PU19.5
N87722142: R693.1 U37.15
N87723974: TP84.1 U37.14
N87723989: TP85.1 U37.13
N87724004: TP86.1 U37.12(YD)
N88138320: PC6.1 PR14.1 PU19.6
N88138401: PR14.2 PR366.1 PR369.1
N88264121: TP156.1 U50.C3
N88389596: QG1.2 QG1.3 R15.1
N88395011: U39.4 U40.1
N88516223: Q102.3 R824.2 R826.2 R828.2
N89714009: PR667.2 PR668.2 PU16.5
N89714060: PR619.2 PU16.4(Y)
N90053363: C872.1 U49.C14
N90053364: C871.1 U49.D14
N90053389: TP178.1 U49.C11
N90053390: TP179.1 U49.D11
N90053415: C871.2 TP180.1
N90053416: C872.2 TP181.1
N90112976: PQ72.3 PQ73.2 PR669.2 PR671.1
N90112978: PQ73.3 PR670.2
N90352201: PQ24.3 PR269.2
N90352464: Q118.2 R1198.1 R1199.2
N90352782: Q118.3 Q121.2 R1197.2
N90353103: Q119.3 Q122.2 R1200.2
N90353130: Q119.2 R1201.2 R1202.1
N90353305: Q120.3 Q123.2 R1203.2
N90353332: Q120.2 R1204.2 R1205.1
N90355820: Q124.3 R1192.1 R1209.1 R1210.2
N91210140: Q126.3 R1212.2
N91210142: Q126.6 R1213.2
N91210144: Q127.3 R1214.2
N850938110: Q94.1(S) R763.1
N852060628: TP157.1 U51.C3
N852184901: Q88.3 R746.2
N914122781: PC396.2 PR517.1
N914244551: PC102.2 PR124.1
N9142277211: PU2.31 TP1.1

Pads without a net: CN6 6 8 20 22 24 26 28 30 32 34 36 40 42 44 46 48 54 67 68; CN7 20 22 28 38 42 44 46 48 56 58 68; CN12 16 62 66 68 70; CN13 6 8 20 22 24 26 28 30 32 34 36 40 42 44 46 48 54 67 68 69; CN18 2 7 11 12; CN23 13 14; HOLE25 1; HOLE34 1; J1 6; NOREF#2 1; NOREF#3 1; NOREF#4 1; NOREF#6 1; NOREF#7 1; NOREF#10 1; NOREF#11 1; NOREF#12 1; NOREF#13 1; PQ41 2; PQ42 2; PQ43 2; PQ44 2; PQ52 2; PU1 7; PU7 8; PU8 8; PU15 19; PU21 6 27 30 33; PU22 6 27 30 33; PU23 6 27 30 33; PU24 6 27 30 33; PU25 6 27 30 33; PU26 6 27 30 33; U1 28 29; U6 9; U7 9; U9 A1 A2 A12 L3; U16 A1 A2 A12 L3; U18 2 3 5 6 7 9 10 11 12 13 14 15 25 26 27 28 30 31 32; U21 1 9 27 29 31 32 33 34 35 36 37 48; U23 41 42 43 44 45 46 51 52 53 54 55 58 59 60 61 62 63; U24 14 15 17 25; U27 23; U35 6; U42 A28 A40 AC37 AC38 AC40 AC41 AD36 AD37 AD39 AD40 AF11 AG11 AG12 AH2 AH7 AJ1 AJ3 AJ4 AJ6 AJ8 AJ9 AL3 AL4 AL8 AL9 AM33 AN1 AN6 AN38 AN39 AR4 AR10 AT1 AT2 AT3 AT4 AT6 AT7 AT8 AT9 AV1 AV4 AV6 AV9 AV12 AW1 AW7 AW36 AW37 AY1 AY33 B5 B28 B29 B40 BA12 BA33 BA37 BA38 BB36 BB37 BB39 BB40 BC1 BC2 BC3 BC4 BC6 BC7 BC8 BC9 BC35 BC36 BD3 BD7 BD8 BD12 BD39 BE3 BE8 BE33 BF2 BF7 BG3 BG4 BG8 BG9 BG12 BG33 BG37 BG38 BG40 BG41 BH3 BH4 BH8 BH9 BH37 BH38 BH40 BH41 BJ37 BJ38 BM33 BN11 BN12 BP11 BR11 BR12 BT1 BT2 BT3 BT4 BT6 BT7 BT8 BT9 BT33 BW3 BW4 BW8 BW9 BY2 BY7 C2 C29 C40 C41 CA1 CA3 CA4 CA6 CA8 CA9 CB37 CB38 CB40 CB41 CC1 CC3 CC4 CC6 CC8 CC9 CC37 CC38 CC40 CC41 CD1 CD3 CD4 CD6 CD8 CD9 CD37 CD38 CM24 CM25 CN24 CN25 CP21 CP22 CR2 CR40 CT4 CT21 CU22 CU24 CU25 D1 D28 D34 D41 E1 E2 E3 E28 E29 E37 F29 F37 H31 H41 J29 J31 K29 L31 M29 M31 N29 P24 P28 P31 P36 P37 P39 P40 R28 R29 R31 R37 R38 R40 R41 T29 U36 U37 U39 U40; U46 6; U49 A44 AA1 AA15 AA17 AB3 AB4 AB20 AC15 AC17 AC47 AE8 AH9 AH11 AH17 AH18 AJ6 AJ22 AJ42 AJ44 AK13 AK39 AL41 AL47 AM7 AM43 AP4 AP9 AR3 AR4 AR7 AR8 AR39 AT15 AT38 AT48 AU26 AU31 AU42 AU47 AV43 AV46 AV47 AW9 AW29 AW46 AW47 AY8 AY12 AY20 AY24 AY30 AY45 B33 B42 B44 BA1 BA2 BA3 BA45 BA47 BA48 BB6 BB20 BB24 BB42 BB47 BC1 BC2 BC16 BC20 BC28 BC30 BC34 BC49 BD4 BD5 BD7 BD8 BD10 BD14 BD15 BD16 BD17 BD18 BD19 BD20 BD23 BD24 BD29 BD30 BD31 BD32 BD34 BD35 BD45 BD46 BE4 BE7 BE8 BE10 BE14 BE17 BE20 BE21 BE23 BE24 BE25 BE27 BE29 BE30 BE33 BE35 BE39 BE46 BE47 BF6 BF17 BF29 BG6 BG45 C15 C18 C20 C21 C23 C33 C35 C40 C42 C43 C47 D15 D16 D17 D18 D19 D20 D21 D23 D34 D35 D40 D42 D43 D46 E16 E17 E20 E34 E41 E48 E49 F20 F44 F47 G2 G3 G14 G17 G33 G36 G43 G45 G47 H12 H15 H17 H20 H33 H35 H45 J3 J4 J13 J18 J21 J35 J46 J47 K43 L19 L21 L34 L41 L42 M1 M2 M35 M37 M46 M48 N3 N4 N7 N8 N39 N42 N43 P17 P19 P31 P33 P35 P37 P41 P46 R4 R5 R17 R19 R31 R33 R39 R45 T2 T3 T4 T5 T13 T42 T43 U3 U4 U41 V28 V29 V32 W4 W5 W6 W8 W47 Y2 Y3 Y4 Y35; U52 9; U56 4 5 7 8; UG6 A4 A53 AB2 AR55 AV1 AV2 AV55 B20 B23 BF1 BF2 BF3 BF4 BF5 BF6 BF7 BF8 BG5 BG8 BG9 BH1 BH10 BH11 BH14 BJ1 BJ7 BJ8 BJ16 BJ40 BJ42 BJ44 BK16 BK40 BK42 BK44 BK46 BL39 BL41 BL43 BL45 BL47 BM39 BM41 BM43 BM45 BM47 BN1 BN2 BN49 BN56 BP41 BP43 BP45 BP47 BP50 BR31 BR40 BR41 BR42 BR43 BR44 BR45 BR46 BR47 BR50 BR51 BT4 BT40 BT42 BT44 BT46 BT51 BT53 C52 D1 D50 D56 E50 E55 F50 G6 G50 N49 W2

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 6703 vias
v2: diameter 0.457, hole 0.254, TOP to BOTTOM, 4734 vias
v3: diameter 0.61, hole 0.356, TOP to BOTTOM, 2515 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1V8_AON_EN: length 215.2
  TOP w0.14: v1(236.73,115.41) 236.91,115.23 238.05,115.23 238.3,114.98 UG3.4 ; Q12.2 217.3,187.8 v1(216.36,186.86)
  TOP w0.203: v1(289.33,118.59) 289.5,118.75 PR122.1
  IN2 w0.089: v1(236.73,115.41) 236.7,115.41 235.22,116.89 232.68,116.89 224.02,125.55 222.91,125.55 222.32,124.95 211.43,124.95 210.21,123.74 209.32,123.74 208.67,123.08 ; 208.67,123.08 208.67,121.31 210.9,119.08 222.34,119.08 227.45,113.96 242.78,113.96 243.48,114.66 244.41,114.66 245.29,113.79 248.23,113.79 248.91,114.47 250.66,114.47 251.34,113.79 257.34,113.79 257.71,113.42 274.78,113.42 278.47,117.1 283.35,117.1 283.96,117.71 288.46,117.71 v1(289.33,118.59) ; 208.67,123.08 206.78,124.97 204.55,124.97 204.21,125.31 200.06,125.31 194.44,130.93 194.44,148.63 196.21,150.4 196.31,150.4 197.7,151.79 197.7,156.63 197.96,156.89 197.96,163.73 199.16,164.93 199.16,166.98 200.87,168.69 201.59,168.69 205.09,172.2 207.51,172.2 209.68,174.36 209.68,178.88 209.09,179.47 209.09,183.28 211.49,185.68 213.48,185.68 215.1,187.3 215.92,187.3 v1(216.36,186.86)
3V_LDO: length 146.7
  TOP w0.178: PU15.3 153.8,60.67 154.1,60.97 v1(154.1,61.2)
  TOP w0.203: PC210.1 154.05,61.54 154.1,61.49 154.1,61.2 v1(154.1,61.2)
  TOP w0.254: v1(155.21,63.04) 155.22,63.05 155.22,63.29 PR272.1 153.71,63.88 PR275.1
  IN2 w0.089: v1(107.78,50.23) 107.91,50.23 110.61,52.93 111.29,52.93 113.56,55.2 118.57,55.2 121.04,57.67 122.57,57.67 124.62,59.72 133.02,59.72 133.68,60.39 145.42,60.39 145.55,60.52 150.05,60.52 150.95,61.42 152.62,61.42 153.23,60.81 153.7,60.81 v1(154.1,61.2)
  BOTTOM w0.14: v1(107.78,50.23) 107.78,51.36 108.62,52.2 108.62,56.02 106.21,58.42 106.21,75.86 107.27,76.91 107.27,79.26 107.95,79.94 107.95,90.86 106.12,92.7 106.12,95.07 104.92,96.26 102.86,96.26 100.42,98.71 100.42,103.14 105.06,107.78 105.06,111.47 108.81,115.22 PR513.1
  BOTTOM w0.254: v1(155.21,63.04) 155.21,62.89 154.1,61.78 154.1,61.2 v1(154.1,61.2)
241VID0: length 1.9
  BOTTOM w0.203: PU39.6 242.6,38.99 243.4,38.19 PR658.2
241VID1: length 2.1
  BOTTOM w0.203: PR659.2 243.9,38.53 243.7,38.53 243,39.23 PU39.5
+1.2V_U3: length 23.9
  TOP w0.178: U24.24 19.41,61.61 19.56,61.46 v1(19.56,61.41) ; U24.4 19.81,67.55 C443.1 19.8,67.6 19.6,67.81 v1(19.33,67.81) ; U24.28 21.01,61.81 21.65,61.17 21.65,60.39 21.82,60.21 C497.1 21.95,60.21 22.13,60.39 22.13,61.38 v1(22.01,61.5) ; U24.34 22.37,64.9 C454.1 22.41,65.38 v1(22.59,65.56) ; U24.19 17.41,61.69 17.15,61.43 15.57,61.43 15.05,61.95 C468.1 v1(16.16,62.28) ; U24.23 19.01,61.61 18.83,61.44 v1(18.8,61.44) 18.61,61.63 U24.22
  IN3 w0.508: v1(16.16,62.28) 15.73,62.28 15.24,62.78 15.24,66 15.75,66.51 v1(16.44,66.51) 17.1,67.17 17.1,67.3 17.61,67.81 v1(19.33,67.81)
+1.2VSUS: length 478.3
  TOP w0.508: v1(209.37,110.65) 209.59,110.43 209.59,107.61 210.31,106.89 210.31,104.21 209.75,103.65 209.75,102.5 208.88,101.63 208.88,100.72 205.29,97.13 200.33,97.13 197.55,99.91 v3(196.6,99.91)
  IN1 w1.016: 26.27,77.75 26.17,77.84 22.89,77.84 20.99,75.93 17.55,75.93 15.89,74.27 15.89,71.97 14.88,70.96 14.05,70.96 13.69,70.6 ; 31.17,77.61 31.65,78.09 33.38,78.09 33.99,78.7 33.99,79.03 34.65,79.69 35.36,79.69 36.16,80.5 37.65,80.5 38.33,79.82 54.51,79.82 56.52,77.81 69.22,77.81 71.13,75.9 86.96,75.9 88.14,74.72 92.98,74.72 95.08,76.82 104.22,76.82
  IN4 w0.508: v1(191.83,42.63) 187.49,46.97 arc(187.28,47.11) 187.03,47.16 182.4,47.16 180.5,49.06 180.5,50.53 177.97,53.05 175.09,53.05 172.93,55.22 172.93,56.7 170.71,58.92 169.55,58.92 169.15,59.33 167.36,59.33 166.8,58.77 164.09,58.77 162.49,60.37 160.49,60.37 160.03,60.83 158.06,60.83 157.72,60.49 152.98,60.49 152.38,61.09 151.28,61.09 150.76,60.58 150.76,59.76 149.02,58.02 145.4,58.02 143.69,59.73 142.97,59.73 139.87,56.63 136.81,56.63 135.13,54.95 v3(135.13,54.04) ; v1(304.68,99.57) 300.02,99.57 298.41,101.17 298.41,102.19 297.43,103.17 296.37,103.17 295.49,104.05 295.49,105.39 296.22,106.13 296.22,106.84 295.69,107.37 292.14,107.37 286.75,112.76 284.83,112.76 283.55,111.49 280.08,111.49 279.81,111.21 262.76,111.21 262.57,111.02 250.66,111.02 250.15,111.54 210.26,111.54 209.38,110.65 v1(209.37,110.65) ; v1(191.97,47.47) 191.98,47.47 193.51,47.47 195.4,49.36 207.67,49.36 208.09,49.79 v1(211.42,49.79)
  IN4 w1.016: 106.3,74.56 109.99,74.56 111.27,75.84 114.65,75.84 116.84,73.65
  BOTTOM w0.2: U42.AY5 151,131.13 v2(151.38,130.81)
  BOTTOM w0.203: U42.BN5 142.53,131.54 v2(142.51,131.54) 142.51,131.53 U42.BP5 ; U42.AT5 154.27,130.84 v2(154.33,130.84) 154.66,131.16 U42.AR5 154.42,131.46 v2(154.33,131.46) ; U42.AW5 151.77,131.16 v2(152.16,131.55) ; U42.BD10 v2(149.19,134.84) U42.BC10
  BOTTOM w0.254: JDIM1.124 152.08,97.61 v1(151.37,98.32) ; JDIM2.129 153.28,88.04 v1(153.77,87.54) ; JDIM2.111 v1(148.78,88.16) ; JDIM1.178 167.58,97.29 167.38,97.48 167.38,98.36 v1(168.18,99.15) ; JDIM1.96 145.08,97.68 144.7,98.05 144.59,98.16 v1(144.55,98.16) ; v1(134.54,97.43) 134.58,97.39 JDIM1.54 ; v1(160.97,83.6) 161.53,83.05 JDIM2.154 ; JDIM1.12 124.08,97.08 124.1,97.11 124.1,97.63 v1(123.61,98.12) ; v1(163.26,87.49) 162.78,87.98 JDIM2.159 ; v2(145.49,130.83) 145.16,131.16 U42.BK5 ; JDIM2.33 129.28,88.02 v1(129.99,87.31) ; JDIM1.117 150.33,103.39 149.91,102.97 149.91,101.77 v1(149.16,101.02) ; v2(139.58,130.85) 139.9,131.16 U42.BV5 ; v1(161.74,87.44) 161.28,87.91 JDIM2.153 ; JDIM1.142 156.58,97.13 157.77,98.32 v1(157.83,98.32) ; JDIM2.178 167.53,82.95 v1(167.94,83.36) ; v2(140.34,134.84) 140.66,134.51 U42.BT10 ; JDIM2.147 159.78,87.95 160.32,87.4 160.38,87.4 v1(160.45,87.32) ; v1(152.71,102.4) 152.89,102.58 152.91,102.58 153.19,102.86 153.19,102.88 153.33,103.02 JDIM1.129 ; JDIM2.96 145.03,83.45 v1(144.06,84.41) ; U42.BD5 148.89,131.16 v2(149.2,130.85) ; JDIM2.123 151.78,88.09 v1(152.37,87.49) ; JDIM2.130 153.53,83.31 v1(154.2,83.99) ; v1(139.8,103.02) 139.83,103.05 JDIM1.75 ; v1(159.13,102.38) 159.83,103.07 JDIM1.147 ; JDIM1.112 v1(149.08,97.48) ; v1(135.41,84.06) 134.53,83.17 JDIM2.54 ; v1(155.35,102.8) 154.83,103.33 JDIM1.135 ; v1(152.66,100.37) 151.83,101.2 JDIM1.123 ; v1(183.8,87.58) 183.72,87.58 183.28,88.03 JDIM2.241 ; v1(159.13,98.21) 159.25,98.09 160.08,97.26 JDIM1.148 ; v2(139.56,134.82) 139.61,134.82 139.92,134.51 U42.BV10 ; U42.BW5 139.13,131.16 v2(138.82,130.85) ; JDIM1.118 150.58,97.08 150.54,97.12 150.54,97.18 150.15,97.56 150.15,99.69 v1(150.9,100.44) ; v1(149.01,82.63) 149.03,82.62 JDIM2.112 ; JDIM2.141 156.28,88.6 156.9,87.98 157.26,87.98 v1(157.35,88.07) ; v1(152.9,84.66) 152.64,84.66 152.03,84.05 JDIM2.124 ; v1(164.76,86.74) 163.78,87.72 JDIM2.163 ; v1(161.69,102.3) 161.53,102.47 161.5,102.47 161.22,102.75 161.22,103.31 161.33,103.41 JDIM1.153 ; v1(139.61,88.24) 139.78,88.41 JDIM2.75 ; v1(155.06,88.1) 155.03,88.1 154.78,88.35 JDIM2.135 ; JDIM2.220 v1(178.03,82.68) ; v1(159.25,83.49) 159.4,83.49 160.03,82.87 JDIM2.148 ; JDIM2.199 v1(172.78,88.22) ; U42.BM10 143.62,134.51 v2(143.29,134.84) 142.97,134.51 U42.BN10 ; v1(147.72,101.67) 147.89,101.67 148.53,102.31 148.53,103.12 148.83,103.42 JDIM1.111 ; v1(157.48,83.28) 157.32,83.11 157.31,83.11 156.53,82.33 JDIM2.142 ; U42.BH5 146.19,130.84 v2(146.22,130.84) ; v1(151,83.44) 150.54,82.99 150.54,82.61 150.53,82.59 JDIM2.118 ; JDIM2.136 155.03,84.52 v1(154.93,84.62) ; JDIM2.12 124.03,83.54 v1(123.47,84.09) ; JDIM2.160 163.03,82.89 v1(163.52,83.38) ; JDIM1.33 129.33,103.15 v1(129.21,103.03) ; U42.BE5 148.1,131.16 v2(148.43,130.84) ; v1(163.5,102.93) 163.5,103.09 163.83,103.42 JDIM1.163 ; v1(157.54,102.09) 156.33,103.31 JDIM1.141 ; JDIM1.241 183.33,103.16 183.17,103 v1(183.17,102.97) ; v1(155.08,97.5) JDIM1.136 ; JDIM2.117 150.28,88.42 v1(150.13,88.27) ; v1(178.19,97.62) 178.08,97.5 JDIM1.220 ; v1(163.51,101.58) 163.41,101.58 163.08,101.92 162.66,102.34 162.66,103.26 162.83,103.42 JDIM1.159 ; v1(163.41,98.94) 162.91,98.45 162.91,97.24 163.08,97.08 JDIM1.160 ; v1(161.7,98.23) 161.7,98.21 161.27,97.78 161.27,97.38 161.58,97.08 JDIM1.154 ; v1(152.66,99.61) 153.58,98.69 JDIM1.130 ; JDIM1.199 v1(172.83,103.06)
  BOTTOM w0.508: v1(191.83,42.63) 191.83,42.65 191.97,42.8 v1(191.97,47.47)
  vias: v1(13.59,69.58) v1(13.59,68.85) v1(104.35,75.73) v1(105.01,75.62) v1(117.96,73.71) v1(118.65,73.85) v2(146.24,134.84) v2(147.01,135.49) v2(148.43,135.49) v2(149.96,135.49) v2(151.38,135.49) v2(152.12,135.49) v2(152.12,134.84) v2(152.91,134.19) v2(153.62,136.2) v2(154.33,135.47) v2(155.15,136.27) v2(155.92,136.28) v2(157.65,135.47) v2(157.74,136.28) v2(158.52,136.28) v3(124.93,53.23) v3(125.68,53.25) v3(125.89,54.01) v3(126.44,53.25) v3(126.65,54.01) v3(127.2,53.25) v3(127.43,54.04) v3(127.96,53.22) v3(128.2,54.04) v3(128.96,54.04) v3(129.72,54.04) v3(130.48,54.04) v3(131.24,54.04) v3(132.01,54.04) v3(132.36,53.28) v3(132.77,54.04) v3(133.12,53.28) v3(133.53,54.04) v3(133.89,53.28) v3(134.34,54.04) v3(134.72,53.23) v3(188.06,107.23) v3(188.06,106.47) v3(188.06,105.7) v3(196.6,101.44) v3(196.6,100.67)
+1.2VSUS_TEMP: length 25.9
  IN2 w0.254: v3(132.72,50.25) 132.4,50.25 131.96,50.7 131.96,51.74 131.71,51.99 125.99,51.99 125.45,52.54 121.14,52.54 120.75,52.15 v1(120.75,43.64)
  BOTTOM w0.203: PU38.19 118.55,45.18 118.92,44.81 119.47,44.81 120.04,44.23 PC506.1 120.63,43.64 v1(120.75,43.64)
  vias: v3(131.14,46.8) v3(131.93,46.8) v3(132.72,46.8) v3(133.52,46.8) v3(134.38,49.32) v3(134.36,48.56) v3(134.36,47.77) v3(134.31,46.93) v3(135.09,46.96) v3(135.18,49.33) v3(135.12,48.55) v3(135.11,47.79)
+1.2VSUS_VIN: length 16.3
  IN2 w0.508: v1(112.09,47.56) 111.93,47.4 111.93,43.05 112.42,42.55 118.23,42.55 118.85,43.17 119.66,43.17 120.71,42.13 v3(121.54,42.13)
  BOTTOM w0.508: v1(112.09,47.56) 112.2,47.56 112.83,46.94 PR635.1
  vias: v1(123.37,41.62) v3(121.52,41.36) v3(125.15,43.63)
+1.05V_PWRGD_G1: length 2.1
  TOP w0.14: v1(151.39,73.11) 151.64,72.86 153.42,72.86
+1.05V_PWRGD_G2:
  vias: v1(154.46,71.16)
+1.8V: length 278
  IN2 w0.508: v1(300.06,59.49) 300.56,58.99 314.76,58.99 v1(315.29,59.53) ; v1(217.71,115.61) 215.7,115.61 213.01,112.91 213.01,110.36 213.62,109.74 v1(213.62,108.74)
  IN3 w0.508: v1(235.88,115.48) 235.31,116.05 232.82,116.05 232.05,116.82 229.51,116.82 228.29,115.6 217.72,115.6 v1(217.71,115.61) ; v1(253.97,65.47) 253.97,64.57 251.13,61.74 249.36,61.74 248.17,62.92 243.37,62.92 243.02,62.58 240.94,62.58 240.32,63.19 235.36,63.19 234.06,61.9 234.06,58.36 233.58,57.87 233.04,57.87 231.87,59.05 231.28,59.05 230.88,58.65 230.88,58.27 230.51,57.9 228.97,57.9 228.9,57.83 228.13,57.83 227.5,57.2 223.14,57.2 222.53,56.59 220.92,56.59 220.81,56.47 217.97,56.47 217.78,56.66 214.24,56.66 213.67,56.09 211.09,56.09 209.68,54.67 209.33,54.67 209.14,54.48 208.21,54.48 207.18,53.45 203.41,53.45 202.2,52.24 196.21,52.24 194.61,53.84 193.42,53.84 191.46,55.8 190.01,55.8 189.79,56.02 187.26,56.02 186.66,56.61 185.14,56.61 184.48,57.27 182.67,57.27 181.4,58.54 177.72,58.54 177.07,59.2 176.72,59.2 175.75,60.17 175.1,60.17 174.51,60.76 169.97,60.76 169.08,61.65 168.4,61.65 168.02,62.02 164.11,62.02 163.07,60.98 v1(161.74,60.98) ; v1(250.56,77.75) 248.59,79.72 235.05,79.72 233.4,81.37 233.4,84.77 232.55,85.63 224.58,85.63 223.05,87.17 220.53,87.17 220.29,87.41 217.57,87.41 217.06,87.92 217.06,88.67 215.83,89.9 215.83,95.01 214.98,95.86 214.31,95.86 213.74,96.43 213.74,98 213.81,98.06 213.81,107.8 213.62,107.98 v1(213.62,108.74) ; v1(300.06,59.49) 300.56,58.99 314.76,58.99 v1(315.29,59.53)
  IN4 w0.508: v1(235.88,115.48) 236.43,116.03 236.77,116.03 237.95,117.21 238.97,117.21 v1(239.47,116.71)
  BOTTOM w0.508: PR614.1 253.79,65.29 v1(253.97,65.47) 253.96,65.47 253.96,67.99 254.31,68.33 254.31,72.76 253.55,73.52 253.24,73.52 250.56,76.2 v1(250.56,77.75) ; v1(300.06,59.49) 300.06,60.45 L21.1 ; v1(239.47,116.71) 239.5,116.68 RG178.2 ; v1(157.48,75.8) 157.48,75.35 155.95,73.82 155.95,71.94 156.47,71.42 156.47,70.37 157.48,69.36 157.48,67.38 156.57,66.46 156.57,62.98 158.18,61.37 158.18,60.51 157.75,60.08 157.75,59.23 158.75,58.22 160.46,58.22 161.74,59.49 v1(161.74,60.98)
  vias: v1(260.23,42.74) v1(260.25,42.08) v1(299.39,59.5) v1(316.03,59.53)
+1.8V_5G: length 92.4
  TOP w0.508: v1(297.54,82.56) 296.43,82.56 291.78,77.92 289.7,77.92 289.22,77.43 287.53,77.43 286.52,78.45 284.67,78.45 v1(284.39,78.73)
  IN2 w0.508: v1(299.45,85.93) 300.19,86.66 300.19,87.59 301.76,89.16 302.65,89.16 304.14,87.67 304.55,87.67 304.98,87.24 306.88,87.24 307.72,86.41 307.72,83.98 309.09,82.61
  IN3 w0.508: v1(304.42,97.5) 304.62,97.3 308.27,97.3 309.37,96.2 309.49,96.2 311.11,94.58 312,94.58 312.91,93.68 312.91,88.97 313.31,88.57 313.31,84.7 v1(313.77,84.24) ; v1(297.54,82.56) 297.85,82.87 299.52,82.87 300.41,83.76 300.41,84.97 v1(299.45,85.93) ; v1(284.39,78.73) 283.85,78.73 282.47,77.35 282.47,76.81 281.86,76.21 278.61,76.21 277.3,74.89 277.3,73.93 276.95,73.59 276.95,62.78 278.23,61.5 v1(278.23,61.48)
  BOTTOM w0.508: R1051.2 v1(287.69,56.63) ; R1045.2 280.43,58.27 v1(279.99,58.71) 278.99,59.71 278.99,60.75 278.25,61.48 v1(278.23,61.48) ; Q109.2 313.51,78.81 v1(313.09,78.4) ; v1(304.42,97.5) 304.42,97.69 303.91,98.2 301.59,98.2 301.4,98.01 300.53,98.01 300.03,98.52 Q102.2
+1.8V_AON: length 582.4
  TOP w0.508: v2(236.59,170.07) 237.71,170.07 237.88,170.25 239.33,170.25 v2(239.37,170.21) 239.37,169.79 240.01,169.15 249.63,169.15 250.75,170.27 v2(251.18,170.27) 251.4,170.05 v2(253.84,170.05) ; v1(203.29,94.62) 203.29,90.02 203.69,89.62 203.69,87.99 206.02,85.67 206.02,84.66 206.84,83.84 207.48,83.84 208.06,83.26 v1(208.06,82.52) ; R68.1 215.28,187.36 v1(215.28,186.55) ; v2(224.92,170.07) 222.31,170.07 v2(222.27,170.11) ; v1(249.76,81.52) 250.19,81.52 251.67,83 251.67,83.98 253.29,85.61 264.14,85.61 264.46,85.29 267.86,85.29 268.22,84.93 268.94,84.93 269.42,84.44 269.42,81.78 ; v2(213.89,160.37) 214,160.48 v2(214,162.94)
  IN1 w0.508: v2(262.46,170.63) 262.46,184.82 264.47,186.83 266.01,186.83 266.64,186.2 268.92,186.2 271.12,188.4 274.42,188.4 275.82,189.8 275.82,193.74 277.29,195.21 277.29,196.43 277.83,196.97 278.68,196.97 280.25,198.54 v1(280.65,198.54) ; v1(208.06,82.52) 211.15,82.52 212.56,83.93 212.56,84.29 213.07,84.8 215.7,84.8 215.97,84.53 221.01,84.53 221.41,84.94 224.84,84.94 225.84,83.94 230.07,83.94 230.66,83.35 230.66,82.51 231.17,82 231.75,82 234.39,79.36 235.89,79.36 236.7,78.55 245.81,78.55 246.39,79.12 247.25,79.12 249.65,81.52 v1(249.76,81.52)
  IN2 w0.508: v1(113.85,123.98) 115.35,123.98 115.89,124.51 123.08,124.51 125.83,121.76 179.56,121.76 194.33,106.99 197.1,106.99 197.23,106.86 197.62,106.86 v1(197.99,106.48) 197.99,106.19 198.43,105.75 199.27,105.75 202.25,102.77 202.25,101.19 v1(203.39,100.05) 203.89,99.55 203.89,97.47 203.29,96.88 v1(203.29,94.62) ; v1(253.27,216.49) 253.93,217.14 258.66,217.14 260.86,214.95 262.16,214.95 262.73,214.38 265.33,214.38 267.18,212.52 267.18,207.87 269.86,205.19 272.97,205.19 273.49,204.67 273.49,202.53 275.13,200.88 276.04,200.88 276.84,200.08 276.94,200.08 278.48,198.54 v1(280.65,198.54)
  IN3 w0.508: v2(260.97,148.28) 260.97,147.91 261.26,147.62 261.26,147.46 261.57,147.15 261.57,145.17 v2(261.26,144.86) ; v1(113.85,123.98) 113.85,123.47 114.37,122.94 114.37,121.71 112.54,119.87 112.54,118.65 115.67,115.51 115.67,111.49 111.08,106.9 108.66,106.9 107.78,106.01 107.78,105.31 105.3,102.83 105.3,99.18 99.75,93.63 99.75,89.56 97.07,86.88 93.83,86.88 92.75,85.8 88.65,85.8 87.85,86.6 78.05,86.6 v1(77.98,86.53) ; v1(207.85,148.4) 208.56,147.69 213.54,147.69 213.92,148.08 v2(213.92,148.31) ; v1(269.6,129.35) 269.6,126.9 267.53,124.83 265.95,124.83 265.33,124.21 v1(265.33,124.2) ; v2(261,161.99) 261,159.42 v2(261.09,159.32) ; v1(197.99,106.48) 197.99,107.45 198.19,107.65 198.19,111.22 195.5,113.92 195.5,121.55 198.69,124.74 207.95,124.74 209.08,123.61 212.85,123.61 v2(215.19,125.95) ; v1(248.09,216.94) 248.06,216.94 248.04,216.92 248.02,216.92 248.01,216.9 247.53,216.9 246.22,215.59 246.22,214.43 v1(245.57,213.78)
  IN4 w0.508: v1(21.29,36.87) 21.26,36.84 v1(21.26,34.74) v1(16.74,34.74) ; v1(21.29,36.87) 23.85,36.87 27.44,40.45 27.9,40.45 32.11,44.66 33.23,44.66 36.16,47.6 36.16,47.9 41.15,52.9 58.26,52.9 60.6,50.56 66.81,50.56 67.08,50.83 71.52,50.83 71.73,51.04 72.7,51.04 75.29,53.63 v1(75.29,54.67) ; v1(21.29,36.87) 19.38,36.87 19.05,37.2 17.2,37.2 v1(16.49,37.91) ; v1(237.95,116.25) 237.95,115.66 236.88,114.59 234.28,114.59 v1(233.43,115.44) ; v1(253.27,216.49) 252.68,216.49 251.09,214.9 249.46,214.9 248.33,216.03 248.33,216.42 248.09,216.66 v1(248.09,216.94)
  BOTTOM w0.102: VRAM7.A10 274.3,147.95 v2(274.62,147.63)
  BOTTOM w0.203: v2(261.26,144.86) 261.38,144.74 VRAM7.V5 ; VRAM7.V10 261.3,147.95 v2(260.97,148.28) ; v2(274.67,162.13) 274.45,162.13 VRAM5.V5 273.83,162.15 v2(273.83,161.93)
  BOTTOM w0.245: v2(213.98,133.95) 213.98,134.1 VRAM8.A10 ; VRAM1.A5 225.33,183.2 v2(224.98,183.55) ; VRAM3.V10 250.8,170.27 v2(251.18,170.27) ; v2(214,162.94) 213.63,163.32 VRAM4.A10 ; 213.87,145.68 213.63,145.43 VRAM6.V10 ; VRAM4.V5 200.56,160.02 v2(200.39,160.02) ; VRAM4.A5 213.89,159.96 v2(213.89,160.37) ; VRAM1.V10 221.93,170.45 v2(222.27,170.11) ; VRAM1.A10 221.95,183.52 v2(221.95,183.69) ; VRAM3.V5 254.23,170.45 v2(253.84,170.05) ; VRAM2.A10 239.61,170.45 v2(239.37,170.21) ; VRAM6.V5 213.63,148.87 213.92,148.57 v2(213.92,148.31) ; VRAM2.A5 236.5,170.07 v2(236.59,170.07) ; v2(236.45,183.69) 236.44,183.68 236.44,183.51 VRAM2.V5 ; VRAM1.V5 225.3,170.45 v2(224.92,170.07) ; VRAM5.V10 274.13,158.72 v2(274.51,159.11)
  BOTTOM w0.254: v1(21.26,34.74) 21.09,34.91 Q117.5 ; Q117.2 16.92,34.91 v1(16.74,34.74) ; VRAM7.A5 274.23,144.2 v2(274.56,144.53) ; v2(261,161.99) 261.38,162.37 VRAM5.A5 ; VRAM3.A5 254.33,183.2 v2(253.98,183.55) ; VRAM5.A10 261.38,159.04 v2(261.09,159.32) ; v2(250.96,183.66) 250.63,183.32 VRAM3.A10
  BOTTOM w0.305: VRAM6.A5 200.88,148.9 v2(200.53,148.55) ; v2(239.47,183.55) 239.83,183.2 VRAM2.V10 ; v2(200.5,163.07) 200.88,163.44 VRAM4.V10 ; VRAM8.V5 200.56,131.02 v2(200.28,131.02) ; VRAM8.V10 200.88,134.42 v2(200.53,134.07) ; v2(200.35,145.55) 200.52,145.55 VRAM6.A10
  BOTTOM w0.508: v1(280.65,198.54) 280.37,198.26 Q82.2 ; 213.87,145.68 214.23,145.68 214.74,145.17 214.74,143.2 v2(214.06,142.52) ; v1(75.29,54.67) 75.49,54.88 75.49,62.45 76.84,63.79 76.84,82.13 77.88,83.17 77.88,86.42 v1(77.98,86.53)
  vias: v1(216.35,173.09) v1(216.32,172.36) v1(216.89,126.58) v1(217.71,126.58) v1(218.42,126.58) v1(240.58,117.57) v1(241.68,122.75) v1(252.28,125.24) v1(259.95,134.04) v1(260.62,134.04) v1(264.42,131.26) v1(264.57,117.26) v1(265.05,135.55) v1(265.26,131.26) v1(265.45,136.12) v1(267.33,127.34) v1(267.81,126.69) v1(267.86,127.81) v1(268.36,127.16) v1(268.42,128.24) v1(268.88,127.67) v1(271.68,125.55) v1(271.83,135.62) v1(274.63,150.64) v2(209.5,171.52) v2(210.17,171.52) v2(214.11,131.18) v2(224.9,130.47) v2(224.9,129.77) v2(226.3,132.57) v2(226.31,131.86) v2(226.3,130.47) v2(226.3,129.77) v2(226.31,133.27) v2(227.71,132.57) v2(227.7,131.87) v2(227.71,130.47) v2(227.69,129.78) v2(227.97,134.68) v2(228.27,134.2) v2(228.58,134.81) v2(229.1,133.96) v2(230.16,134.41) v2(230.51,133.97) v2(230.5,130.47) v2(230.49,129.78) v2(230.65,134.76) v2(236.65,175.95) v2(244.22,183.74) v2(246.25,183.74) v2(250.11,133.97) v2(250.1,133.28) v2(253.71,121.35) v2(253.74,120.73) v2(253.73,119.46) v2(253.87,120.12) v2(254.28,121.18) v2(254.31,120.56) v2(269.16,144.95) v2(273.46,144.73) v3(192.97,155.18) v3(192.97,154.39) v3(193.81,155.23) v3(193.83,154.39) v3(283.39,137.02) v3(283.34,136.26) v3(283.31,135.17) v3(283.87,135.68) v3(284.18,137.02) v3(284.97,137.02)
+1.8V_CLKLDO: length 1.1
  BOTTOM w0.254: v1(208.86,64.92) 208.5,65.28 U49.R29 ; v1(208.05,64.94) 207.71,65.28 U49.P29
+1.8V_DEEP_SUS: length 87.8
  TOP w0.254: U22.5 271.84,66.53 271.16,67.21 270.29,67.21 v1(270.19,67.3)
  TOP w0.305: U26.5 272.02,63.99 v1(271.44,64.57)
  TOP w0.508: R498.1 198.05,63.45 v1(197.86,63.64)
  IN1 w0.508: v1(222.18,53.96) 222.18,54.07 221.65,54.6 221.16,54.6 220.01,55.75 219.1,55.75 217.7,57.15 215.94,57.15 214.94,58.15 214.94,60.54 214.31,61.17 211.91,61.17 211.19,61.89 211.19,62.64 211.11,62.72 v1(211.11,62.73)
  IN2 w0.508: v1(268.46,69.74) 267.64,69.74 267.42,69.96 265.77,69.96 264.4,71.34 264.4,71.99 263.93,72.45 262.39,72.45 261.55,71.62 255.92,71.62 251.59,67.28 251.59,66.51
  IN3 w0.508: v1(271.44,64.57) 270.19,65.81 v1(270.19,67.3) ; v1(224.49,84.13) 224.37,84.01 v1(224.37,81.85) 224.37,81.06 227.33,78.09 227.33,73.93 227.24,73.84 227.24,70.16 v1(228.6,68.8)
  IN4 w0.508: v1(270.19,67.3) 270.19,66.98 269.65,66.44 268.93,66.44 268.25,67.12 268.25,69.53 v1(268.46,69.74) ; v1(197.86,63.64) 198.46,64.24 199.1,64.24 199.52,64.65 200.25,64.65 200.57,64.34 202.86,64.34 202.88,64.32
  BOTTOM w0.203: R914.2 224.76,82.06 224.54,81.85 v1(224.37,81.85)
  BOTTOM w0.254: U49.AF25 213.67,67.49 v1(214.07,67.1) ; v1(214.06,67.88) 213.67,68.26 U49.AF23 ; v1(213.3,67.15) 212.95,67.5 U49.AD25 ; U49.AB27 v1(211.69,66.29) ; v1(213.3,67.92) 212.95,68.27 U49.AD23 ; v1(224.49,84.13) 224.77,83.85 R897.2 ; U49.AB25 212.13,67.5 v1(212.5,67.13) ; U49.AF27 213.31,66.36 v1(213.31,66.33) ; v1(214.11,68.65) 214.11,68.66 213.72,69.05 U49.AF22 ; v1(212.52,68.66) 212.13,69.05 U49.AB22 ; v1(212.51,67.9) 212.13,68.27 U49.AB23 ; v1(270.19,67.3) 270.16,67.27 269.8,67.27 269.29,67.78 R967.2 ; v1(212.53,66.34) 212.9,66.71 U49.AD27 ; v1(211.71,67.12) 211.35,66.75 U49.AA27 ; v1(213.26,69.41) 213.26,69.43 213.65,69.82 U49.AF20 ; v1(213.3,68.66) 212.91,69.05 U49.AD22 ; U49.Y37 211.08,62.09 211.08,62.7 v1(211.11,62.73) ; v1(268.46,69.74) 268.64,69.92 R959.2 ; v1(212.5,69.41) 212.5,69.46 212.86,69.82 U49.AD20
  vias: v1(226.46,65.94) v1(249.07,62.88) v1(249.19,63.72) v1(249.54,62.43) v1(249.65,63.18) v1(250.22,62.42) v1(250.8,62.76)
+1.8V_S5: length 353.4
  TOP w0.508: R413.1 161.93,71.52 161.93,73.28 162.49,73.84 163.97,73.84 164.7,74.57 v1(164.7,76.58)
  IN3 w0.508: v1(185.98,55.94) 186.47,55.94 187,55.41 189.54,55.41 189.76,55.2 191.21,55.2 193.17,53.23 194.35,53.23 195.96,51.63 199.86,51.63 200.55,50.93 202.47,50.93 204.38,52.84 207.43,52.84 208.46,53.87 209.14,53.87 209.65,53.36 210.82,53.36 211.12,53.67 211.12,54.34 212.26,55.48 213.92,55.48 214.49,56.05 217.53,56.05 217.72,55.86 221.06,55.86 221.18,55.98 222.78,55.98 223.39,56.59 228.85,56.59 229.22,56.96 229.23,56.96 229.56,57.29 230.33,57.29 231.22,56.4 233.11,56.4 234.67,57.96 234.67,60.88 235.54,61.74 243.05,61.74 243.62,62.31 247.87,62.31 249.05,61.13 252.09,61.13 252.53,60.68 253.89,60.68 v3(253.98,60.77) ; v1(164.7,76.58) 164.71,76.59 164.71,77.16 166.61,79.06 167.98,79.06 168.87,79.95 178.21,79.95 178.79,79.36 183.94,79.36 v1(184.34,78.96) 184.34,78.8 184.84,78.3 186.24,78.3 186.62,77.91 187.99,77.91 188.79,78.71 188.79,80.04 188.84,80.09 190.23,81.48 190.23,96.64 191.24,97.65 191.24,102.45 189.86,103.83 187.93,103.83 185.71,106.05 185.71,147.91 184.48,149.14 184.48,164.86 183.87,165.47 183.87,166.22 183.23,166.87 v1(182.27,166.87)
  IN4 w0.508: 252.43,64.66 251.21,64.66 250.8,65.06 246.26,65.06 245.24,66.07 v1(245.24,67.88) ; v1(303.81,85.37) 303.81,84.56 304.77,83.6 304.77,82.23 303.94,81.4 301.88,81.4 299.82,79.34 295.89,79.34 295.72,79.52 288.57,79.52 288.01,78.96 286.39,78.96 285.48,79.87 v1(285.48,80.23)
  BOTTOM w0.508: v1(285.48,80.23) 285.48,82.34 282.27,85.55 280.25,85.55 279.61,84.9 273.14,84.9 271.89,83.66 269.87,83.66 269.31,84.21 264.82,84.21 263.67,85.37 250.05,85.37 248.23,83.54 248.23,74.95 245.24,71.97 v1(245.24,67.88) ; v1(184.34,78.96) 184.34,78.23 184.17,78.06 184.17,75.15 184.98,74.34 184.98,72.61 184.17,71.81 184.17,63.44 184.31,63.3 184.31,59.09 184.37,59.09 184.72,58.74 184.72,57.21 v1(185.98,55.94) ; v1(182.27,166.87) 182.27,166.89 182.77,167.4 184.99,167.4 186.43,165.96 R756.1 186.43,164.41 187.3,163.54 Q94.3 ; 304.49,89.51 304.49,91.99 303.47,93.01 303.47,95.53 302.8,96.2 300.21,96.2 299.47,95.47 298.45,95.47 298.07,95.09 298.07,94.41 297.56,93.9 296.31,93.9 295.8,93.39 Q104.3
  vias: v1(254.61,67.3) v1(254.62,66.6) v3(253.44,61.46)
+1.8V_VCC: length 74.8
  IN2 w0.508: v1(184.56,166.03) 184.56,167.25 177.94,173.87 v1(176.26,173.87)
  IN4 w0.508: v1(176.26,173.87) 176.17,173.78 173.57,173.78 171.34,171.55 154.9,171.55 154.23,170.88 151.85,170.88 149.59,168.63 149.59,166.25 147.76,164.42 147.76,154.72 149.73,152.75 149.73,149.63 150.3,149.06 154.36,149.06 155.01,149.71 v2(155.83,149.71) v2(155.83,150.36)
  BOTTOM w0.508: v1(184.56,166.03) 184.67,165.92 R756.2 R763.2 184.67,161.9 184.53,161.76 184.53,160.62 v1(184.79,160.36)
+1V8_AON_U:
  vias: v1(242.83,119.72)
+1V_GFX: length 2.3
  TOP w0.203: CG324.1 240.62,135.16 v2(240.6,135.17) 240.6,135.61 240.44,135.76 CG317.1 ; CG330.1 239.77,134.91 240.08,134.6 v2(240.52,134.6)
  vias: v1(205.51,107.6) v1(238.69,120.56) v1(238.74,119.24) v1(238.99,121.15) v1(239.37,120.56) v1(239.42,119.24) v2(232.52,134.61) v2(232.53,134.05) v2(233.3,133.96) v2(233.3,133.27) v2(234.07,134.07) v2(234.2,134.64) v2(234.64,134.04) v2(235.4,134.66) v2(243.79,134.7) v2(244.51,135.26) v2(244.53,134.65) v2(244.51,133.99) v2(246,134.84) v2(246.59,133.96) v2(247.05,134.34) v2(247.2,135.18) v3(203.73,108.17) v3(203.75,107.41) v3(204.15,108.8) v3(204.54,107.4) v3(204.62,108.22)
+1V_GFX_EN: length 57.3
  TOP w0.14: v1(198.63,101.82) 198.81,101.64 PR132.2
  TOP w0.203: v1(200.22,101.51) 200.2,101.51 200.07,101.64 PR132.2
  IN3 w0.089: v1(200.22,101.51) 200.22,101.89 203.37,105.04 203.57,105.04 205.67,107.14 205.67,111.56 211.33,117.21 215.86,117.21 216.98,118.33 224.94,118.33 225.35,118.74 225.35,118.74 225.86,119.25 231.31,119.25 233.49,121.43 234.32,121.43 234.67,121.08 235.99,121.08 238.53,118.53 239.58,118.53 240.2,119.16 240.36,119.16 241.04,119.84 v1(241.49,119.84)
  BOTTOM w0.14: UG9.4 242.15,120.15 242.04,120.26 241.71,120.26 241.49,120.04 v1(241.49,119.84)
+1V_GFX_EN_1: length 92.2
  TOP w0.14: v1(197.04,105.11) 197.26,104.89 197.26,101.41 198.22,100.45 PR135.1
  IN2 w0.089: v1(251.56,114.94) 251.56,115.02 251.57,115.02 251.57,116.13 250.76,116.93 244.94,116.93 242.55,114.54 235.59,114.54 235.27,114.86 235.27,115.52 234.74,116.04 232.5,116.04 232.17,115.72 231.73,115.72 230.93,116.51 230.93,118.37 223.94,125.35 222.99,125.35 222.4,124.76 212.31,124.76 v1(211.79,124.24)
  IN3 w0.089: v1(211.79,124.24) 211.67,124.24 210.77,125.14 198.53,125.14 195.1,121.71 195.1,113.75 197.79,111.06 197.79,107.81 197.51,107.53 197.51,105.58 v1(197.04,105.11)
  BOTTOM w0.14: v1(251.56,114.94) 251.67,115.05 DG5.2
+1V_GFX_PG: length 53.5
  TOP w0.14: v1(214.03,110.69) 214.03,110.72 214.27,110.96 226.23,110.96 230.81,115.53 231.94,115.53 233.59,117.18 234.72,117.18 234.98,116.93 UG2.2 234.98,116.45 234.52,115.99 233.32,115.99 232.57,115.24 RG90.2
  IN4 w0.086: v1(214.03,110.69) 214.03,110.72 213.61,111.14 211.75,111.14 210.85,110.24 200.49,110.24 199.96,109.72 199.96,108.61 200.89,107.68 201.76,107.68 202.54,106.9 202.54,104.65 203.66,103.52 203.66,102.44 v1(204.17,101.93)
  BOTTOM w0.203: v1(204.17,101.93) PR534.1 PR535.1
+1V_GFX_S:
  vias: v1(204.95,103.78) v3(205.54,102.91) v3(205.92,103.56) v3(206.33,102.91)
+1V_S5_VIN:
  vias: v1(245.65,41.05) v3(246.42,41.36) v3(246.42,40.58) v3(247.18,41.29) v3(247.18,40.5) v3(247.4,39.76) v3(247.97,41.29) v3(247.97,40.5) v3(248.19,39.76)
+2.5V_SUS:
  vias: v1(187.81,88.19) v1(187.81,87.54) v1(188.9,102.12) v1(188.9,101.44) v1(197.56,98.31) v1(197.58,97.65)
+3V: length 1188.7
  TOP w0.203: v1(308.09,61.81) 308.81,61.81 309.22,62.21 R505.2 ; v1(307.93,74.38) 307.87,74.33 R387.1
  TOP w0.254: 164.92,96.79 164.9,96.94 R137.1
  TOP w0.305: Q47.2 25.68,66.18 25.91,66.41 v1(25.91,66.51) ; v1(25.45,63.88) 25.68,64.12 Q47.5
  TOP w0.508: 266.74,114.36 269.43,111.67 277.29,111.67 280.11,114.49 283.64,114.49 285.69,112.45 286.2,112.45 v1(286.82,111.83) ; 266.74,114.36 266.83,114.46 v1(266.83,115.82) ; 266.74,114.36 266.09,114.36 263.83,112.1 263.31,112.1 262.17,110.96 252.28,110.96 251.84,111.39 ; 164.92,96.79 164.92,93.78 v1(164.95,93.75) ; v1(299.22,96.18) 299.24,96.21 304.19,96.21 305.17,95.23 306.71,95.23 307.3,94.64 307.79,94.64 308.6,93.83 308.6,91.34 308.68,91.25 ; 123.93,213.81 123.93,214 123.72,214.21 123.52,214.21 123.47,214.26 122.12,214.26 121.6,214.78 121.6,215.57 120.96,216.21 v1(120.96,216.65) ; 273.13,216.14 273.13,216.55 272.05,217.63 267.53,217.63 266.86,216.96 v1(266.68,216.96) ; 247.32,111.55 247.32,111.44 247.88,110.88 251.33,110.88 251.84,111.39 ; 260.51,216.89 260.51,216.8 261.02,216.29 261.99,216.29 262.22,216.52 262.22,216.93 ; v1(160,68.49) 160,68.64 160.65,69.3 162.25,69.3 R436.1 ; R431.1 270.29,68.43 270.11,68.24 v1(270.11,67.96) ; 217.15,86.09 217.15,86.53 216.69,86.98 216.05,86.98 215.37,87.66 215.37,95.17 214.53,96.01 v1(214.53,97.12) ; 223.76,83.18 224.78,83.18 225.48,82.48 226.14,82.48 226.73,81.89 v1(228.37,81.89) 230.56,81.89 v1(231.35,82.68) ; v1(208.92,107.84) 207.52,106.44 203.95,106.44 203.76,106.64 ; v1(304.65,72.35) 304.55,72.25 304.55,70.56 305.24,69.86 L11.1 ; v1(315.74,75.9) 316.46,75.18 R420.1 ; 289.06,80.35 290.32,80.35 291.33,81.36 Q31.2 291.33,82.04 294.55,85.27 295.75,85.27 296.7,86.23 297.33,86.23 298.22,87.12 298.22,87.57 299.09,88.44 300.17,88.44 301.04,89.31 303.44,89.31 304.31,90.18 305.75,90.18 306.5,89.43 Q23.2 307.2,89.78 308.68,91.25 ; 251.84,111.39 251.84,113.5 ; v1(169.28,162.14) 169.27,162.14 169.27,165.11 168.4,165.98 166.98,165.98 165.9,167.07 164.79,167.07 v1(163.77,168.08) 163.77,172.77 v1(162.2,174.35) ; Q124.2 195.32,53.43 194.95,53.81 194.95,54.53 195.25,54.83 195.84,54.83 ; v1(117.61,68.71) 111.95,63.05 111.95,60.51 112.19,60.27 112.19,58.41 111.75,57.97 111.75,49.88 v1(111.46,49.59) ; v1(243.56,71.26) 243.56,70.3 242.83,69.56 242.83,66.74 v1(245.53,64.04) ; 308.68,91.25 312.35,91.25 312.98,90.62 312.98,89.22 ; R527.1 v1(48.99,60.2)
  IN1 w0.508: v1(297.99,61.79) 298.01,61.76 298.71,61.76 299.24,62.29 299.24,63.82 299.82,64.4 303.71,64.4 306.31,61.81 v1(308.09,61.81) ; v1(265.72,186.22) 267.56,184.39 269.96,184.39 270.39,184.81 274.08,184.81 276.84,182.06 279.68,182.06 280.22,182.59 v1(282.81,182.59) 282.81,180.72 281.15,179.06 281.15,157.27 278.66,154.78 278.66,139.91 278.16,139.41 277.18,139.41 275.45,137.68 275.45,135.38 274.61,134.54 274.61,131.9 268.6,125.9 v1(267.35,125.9) 266.54,125.08 262.06,125.08 v1(261.91,125.23) ; v1(266.68,216.96) 266.15,217.48 262.73,217.48 262.05,216.8 261.22,216.8 ; v1(272.97,77.69) 272.44,78.21 272.44,79.46 272.01,79.9 269.57,79.9 269.22,79.55 v1(269.22,78.4) ; 261.12,216.09 261.12,215.69 261.72,215.08 264.4,215.08 266.85,212.62 266.85,203.57 265.74,202.45 265.74,200.24 266.4,199.58 v1(267.44,199.58)
  IN2 w0.508: v1(261.91,125.23) 263.41,125.23 264.59,124.05 v1(264.59,121.74) 264.18,121.32 263.99,121.32 263.48,120.81 263.48,120.02 264.4,119.11 264.4,118.39 263.93,117.92 263.93,116.91 264.39,116.45 266.2,116.45 266.21,116.44 v1(266.83,115.82) ; v1(113.64,114.06) 114.73,114.06 117.42,111.37 182.65,111.37 185.63,108.4 185.63,104.64 v1(187.19,103.07) ; v1(265.72,186.22) 265.72,187.11 265.04,187.79 265.04,188.63 266.67,190.25 266.67,199.03 267.22,199.58 v1(267.44,199.58) ; v1(258.6,62.26) 260.17,63.83 263.91,63.83 265.48,65.39 266.81,65.39 269.38,67.96 v1(270.11,67.96) 270.11,70.78 270.96,71.64 270.96,72.99 272.33,74.35 272.33,77.05 v1(272.97,77.69) ; v1(255,213.4) 255,213.36 253.23,211.6 253.23,207.02 252.31,206.1 243.19,206.1 242.77,205.68 236.91,205.68 234.95,203.72 232.43,203.72 231.88,203.18 226.03,203.18 224.97,202.12 221.78,202.12 220.84,203.07 219.42,203.07 218.84,203.65 213.93,203.65 213.35,203.07 201.27,203.07 200.03,204.31 197.62,204.31 196.73,203.42 196.73,202.91 v1(196.35,202.53)
  IN3 w0.508: v1(221.39,82.1) 221.4,82.1 222.62,80.88 v1(222.62,76.88) 222.62,76.02 222.05,75.45 221.24,75.45 221.21,75.43 221.06,75.43 221.01,75.48 220.4,75.48 v1(220.02,75.1) ; v1(229.92,62.8) 232.08,62.8 233.58,64.3 243.84,64.3 244.15,64.6 244.96,64.6 v1(245.53,64.04) 246.43,64.04 246.99,64.6 249.16,64.6 250.08,63.69 251.13,63.69 253.51,66.08 254.23,66.08 254.74,65.57 254.74,63.54 256.02,62.26 v1(258.6,62.26) ; v1(297.74,59.5) 295.66,61.58 295.66,64.5 295.05,65.97 293.27,67.76 289.19,67.76 286.92,65.49 286.92,60.64 287.18,60.39 287.18,57.5 286.32,56.64 286.32,53.89 284.97,52.54 284.97,50.41 ; v1(98.77,98.9) 98.77,99.68 100.29,101.2 101.22,101.2 105.22,105.2 105.22,107.57 108.82,111.16 111.08,111.16 113.64,113.73 v1(113.64,114.06) 113.11,114.06 110.19,116.98 110.19,125.11 114.75,129.68 114.75,135.98 114.24,136.49 114.24,137.6 117.05,140.41 117.05,144.29 118.43,145.67 118.43,172.03 v1(116.43,174.03) 115.52,174.94 111.23,174.94 109.45,176.72 109.45,195.44 109.99,195.98 109.99,202.65 111.19,203.86 111.19,208.85 114.71,212.37 114.71,214.14 115.79,215.22 117.47,215.22 117.94,215.7 120.01,215.7 v1(120.96,216.65) 121.92,217.61 144.2,217.61 144.8,217.01 146.8,217.01 148.42,215.39 148.42,212.83 148.72,212.54 148.72,209.89 149.28,209.34 152.23,209.34 152.78,208.78 v1(152.99,208.78) 153.19,208.57 153.85,208.57 153.95,208.47 158.19,208.47 162.26,212.54 166.09,212.54 167.01,211.62 167.64,211.62 171.07,208.2 171.07,207.07 172.39,205.74 172.39,203.9 173.76,202.53 175.01,202.53 v1(175.26,202.27) ; v1(93.8,69.89) 100.46,69.89 102.4,67.95 105.73,67.95 106.11,68.32 117.23,68.32 v1(117.61,68.71) ; v1(165.39,74.26) 168.03,74.26 168.5,74.73 169.48,74.73 v1(171.34,76.59) ; v1(312.17,84.29) 312.21,84.24 312.21,80.17 311.53,79.49 310.65,79.49 307.93,76.77 v1(307.93,74.38) ; v1(243.56,71.26) 243.44,71.39 233.66,71.39 231.49,73.55 231.49,77.79 v1(230.94,78.35) 231.35,78.76 v1(231.35,82.68) ; v1(25.35,79.5) 22.99,79.5 22.33,80.16 22.33,85.74 22.63,86.04 22.63,86.98 v1(23.75,88.1)
  IN4 w0.508: v1(214.53,97.12) 214.53,98.42 213.9,99.04 213.9,101.35 213.11,102.14 213.11,103.64 v1(208.92,107.84) ; v1(33.15,65.59) 33.15,65.79 32.64,66.3 29.35,66.3 28.45,67.2 28.45,75.45 28.11,75.79 26.57,75.79 25.73,76.63 25.73,78.18 25.35,78.55 v1(25.35,79.5) ; v1(162.2,174.35) 162.03,174.18 153.71,174.18 152.97,173.44 117.01,173.44 v1(116.43,174.03) ; v1(287.33,82.62) 286.76,82.05 282.18,82.05 281.4,82.83 276.69,82.83 275.01,81.15 275.01,78.44 274.25,77.69 v1(272.97,77.69) ; v1(164.95,93.75) 164.99,93.75 165.26,94.02 180.92,94.02 v1(186.78,88.17) ; v1(29.59,96.23) 29.83,96.23 30.48,95.58 30.48,91.91 29.59,91.02 27.44,91.02 24.51,88.1 v1(23.75,88.1) ; v1(175.26,202.27) 176.28,203.29 188.6,203.29 189.36,202.53 v1(196.35,202.53) ; v1(286.82,111.83) 293.48,105.17 293.48,103.41 293.99,102.9 294.93,102.9 296.91,100.92 296.91,97.81 298.53,96.18 v1(299.22,96.18)
  BOTTOM w0.203: R1000.2 229.31,62.24 229.34,62.27 R997.2 ; R997.2 229.72,62.6 v1(229.92,62.8) ; R997.2 229.34,63.03 229.38,63.07 R994.2 ; v1(228.43,62.9) 228.29,63.04 R996.2 227.97,63.04 R999.2 ; v2(228.39,61.38) 228.38,61.38 228.31,61.3 R1005.2 ; v1(221.39,82.1) 221.41,82.1 221.41,82.21 221.52,82.32 221.52,82.51 R910.2 ; v1(228.37,81.89) 228.32,81.89 227.73,81.31 R917.2
  BOTTOM w0.254: v1(231.35,82.68) 231.31,82.73 R912.2 230.75,82.25 230.78,82.22 Q108.2 ; v1(230.94,78.35) R923.2 230.94,79.24 230.78,79.4 Q108.5
  BOTTOM w0.508: R1169.1 268.55,42.42 v1(268.68,42.28) ; v1(264.59,121.74) 264.24,122.09 264.24,122.42 263.66,123 U44.5 ; v1(315.74,75.9) 315.38,75.54 310.66,75.54 309.52,74.4 307.95,74.4 v1(307.93,74.38) 307.68,74.14 307.68,72.97 308.99,71.66 308.99,70.45 v1(308.59,70.04) 306.36,70.04 304.65,71.75 v1(304.65,72.35) ; v1(165.89,63.57) 165.89,68.72 164.34,70.27 164.34,72.03 165.39,73.08 v1(165.39,74.26) ; R741.1 266.25,184.97 265.72,185.5 v1(265.72,186.22) ; U43.5 262.02,125.12 v1(261.91,125.23) ; v1(287.33,82.62) 287.79,82.17 287.79,79.59 288.29,79.08 v1(288.29,75.78) ; v1(37.72,82.92) 37.72,83.15 37.21,83.66 33.66,83.66 32.77,84.54 31.12,84.54 27.61,88.06 23.8,88.06 v1(23.75,88.1) ; 226.95,114.7 226.81,114.56 213.14,114.56 210.34,111.76 210.34,110.7 210.22,110.58 210.22,109.13 v1(208.92,107.84) ; v1(308.09,61.81) 308.77,61.81 L20.1 ; U45.5 267.35,125.16 v1(267.35,125.9)
  vias: v1(17.25,40.37) v1(17.25,39.69) v1(17.25,39) v1(17.25,38.32) v1(17.99,40.37) v1(18.01,39.69) v1(18.04,38.98) v1(18.06,38.29) v1(21.02,7.46) v1(22.38,11.96) v1(23.01,12.19) v1(23.38,49.74) v1(23.77,47.86) v1(27.05,10.21) v1(31.64,62.85) v1(31.62,62.18) v1(32.31,62.86) v1(32.36,62.17) v1(33.01,62.86) v1(33.12,62.18) v1(63.77,68.43) v1(95.1,75.48) v1(95.59,74.01) v1(95.63,73.22) v1(96.33,74.01) v1(96.39,73.22) v1(96.68,74.66) v1(97.04,74.01) v1(97.08,73.23) v1(98.78,98.21) v1(98.79,97.54) v1(99.47,98.92) v1(99.46,98.2) v1(99.48,97.54) v1(135.84,66.49) v1(136.5,66.49) v1(137.21,66.49) v1(137.87,66.49) v1(186.31,78.96) v1(186.74,87.51) v1(186.98,78.96) v1(187.18,102.4) v1(187.79,61.18) v1(196.7,55.7) v1(197.07,56.27) v1(197.39,55.7) v1(198.27,50.17) v1(200.35,49.97) v1(201.51,48.23) v1(204.85,48.51) v1(205.97,48.5) v1(216.64,41.82) v1(216.98,42.4) v1(217.32,41.82) v1(217.63,42.4) v1(259.78,217.56) v1(260.45,217.58) v1(275.22,203.68) v1(285.39,202.84) v1(285.68,201.38) v1(286.42,204.21) v1(286.44,203.52) v3(140.9,78.37) v3(141.68,78.37) v3(142.47,78.37) v3(143.23,78.37) v3(144,78.37) v3(144.76,78.37)
