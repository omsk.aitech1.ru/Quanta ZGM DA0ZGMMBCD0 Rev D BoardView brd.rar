# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DIM0_ODT0: length 63.6
  IN1 w0.127: v2(153.53,127.06) 153.91,127.06 154.17,126.8 154.17,126.14 153.97,125.95 153.53,125.95 153.41,125.82 153.41,125.56 153.53,125.44 154,125.44 154.12,125.31 154.12,125.06 154,124.93 153.53,124.93 153.41,124.8 153.41,124.55 153.53,124.42 153.99,124.42 154.12,124.29 154.12,124 154.01,123.89 153.51,123.89 153.41,123.79 153.41,123.5 153.53,123.37 153.99,123.37 154.17,123.19 154.17,122.85 154.5,122.53 154.5,122.29 154.37,122.17 154.12,122.17 154,122.04 154,121.79 154.12,121.66 154.37,121.66 154.5,121.53 154.5,121.28 154.37,121.15 154.12,121.15 154,121.02 154,120.77 154.12,120.64 154.37,120.64 154.5,120.52 154.5,120.26 154.37,120.14 154.12,120.14 154,120.01 154,119.75 154.12,119.63 154.37,119.63 154.5,119.5 154.5,119.25 154.37,119.12 154.12,119.12 154,118.99 154,118.74 154.12,118.61 154.37,118.61 154.5,118.48 154.5,118.23 154.37,118.1 154.12,118.1 154,117.98 154,117.72 154.12,117.6 154.37,117.6 154.5,117.47 154.5,117.21 154.37,117.09 154.12,117.09 154,116.96 154,116.71 154.12,116.58 154.37,116.58 154.5,116.45 154.5,116.2 154.37,116.07 154.12,116.07 154,115.94 154,115.69 154.12,115.56 154.37,115.56 154.5,115.44 154.5,115.18 154.37,115.06 154.12,115.06 154,114.93 154,114.67 154.12,114.55 154.37,114.55 154.5,114.42 154.5,114.17 154.37,114.04 154.12,114.04 154,113.91 154,113.66 154.12,113.53 154.37,113.53 154.5,113.4 154.5,113.15 154.37,113.02 154.12,113.02 154,112.9 154,111.82 157.97,107.85 157.97,107.16 158.1,107.03 158.72,107.03 158.88,106.87 158.88,106.65 158.75,106.52 158.1,106.52 157.97,106.39 157.97,106.14 158.1,106.02 158.98,106.02 159.11,105.88 159.11,105.63 158.99,105.51 158.1,105.51 157.97,105.38 157.97,105.13 158.13,104.97 158.89,104.97 159.02,104.84 159.02,104.59 158.89,104.46 158.1,104.46 157.97,104.33 157.97,103.71 158.1,103.58 158.34,103.58 158.71,103.22 158.71,94.88 161.33,92.25 161.76,91.82 161.76,88.17 v1(161.78,88.15)
  BOTTOM w0.102: v2(153.53,127.06) 154.22,127.06 155.02,127.86 155.02,129.56 U42.AR3
  BOTTOM w0.216: JDIM2.155 v1(161.78,88.15)
M_A_DIM0_ODT1: length 61.1
  IN1 w0.127: v2(155.88,126.58) 155.46,126.16 155.46,125.15 155.77,124.84 155.77,124.66 155.46,124.36 155.46,124.09 155.6,123.95 155.78,123.95 156.13,124.3 156.31,124.3 156.67,123.94 156.67,123.51 156.54,123.38 155.91,123.38 155.78,123.25 155.78,122.99 155.91,122.87 156.54,122.87 156.67,122.74 156.67,122.49 156.54,122.36 155.92,122.36 155.79,122.24 155.79,121.98 155.92,121.86 156.54,121.86 156.67,121.73 156.67,121.5 156.33,121.16 156.33,121.01 156.62,120.72 156.8,120.72 157.14,121.05 157.32,121.05 157.54,120.83 157.54,120.65 157.29,120.41 157.29,120.23 157.54,119.98 157.54,119.73 157.41,119.6 156.8,119.6 156.67,119.47 156.67,119.22 156.8,119.09 157.41,119.09 157.54,118.96 157.54,118.71 157.41,118.58 156.8,118.58 156.67,118.46 156.67,118.2 156.8,118.08 157.41,118.08 157.54,117.95 157.54,117.69 157.41,117.57 156.8,117.57 156.67,117.44 156.67,117.19 156.8,117.06 157.41,117.06 157.54,116.93 157.54,116.68 157.41,116.55 156.8,116.55 156.67,116.42 156.67,116.17 156.8,116.04 157.41,116.04 157.54,115.92 157.54,115.66 157.41,115.54 156.8,115.54 156.67,115.41 156.67,115.15 156.8,115.03 157.41,115.03 157.54,114.9 157.54,114.65 157.41,114.52 156.8,114.52 156.67,114.39 156.67,110.98 160.41,107.24 160.41,95.01 163.18,92.23 163.18,91.63 163.06,91.51 163.06,90.92 163.18,90.8 163.18,90.24 163.06,90.12 163.06,89.64 163.18,89.52 163.18,89.09 163.06,88.96 163.06,88.42 163.18,88.29 v1(163.28,88.2)
  BOTTOM w0.102: v2(155.88,126.58) 156.81,127.5 156.81,129.31 U42.AM3
  BOTTOM w0.216: JDIM2.161 v1(163.28,88.2)
M_A_DQ0: length 70.4
  IN1 w0.127: v1(121.78,88.27) 121.78,88.98 121.11,89.65 120.72,89.65 120.32,89.25 120.14,89.25 119.96,89.43 119.96,89.61 120.38,90.02 120.38,90.2 120.21,90.38 120.01,90.38 119.6,89.97 119.42,89.97 119.24,90.15 119.24,90.33 119.67,90.75 119.67,90.93 119.5,91.1 119.3,91.1 118.88,90.68 118.71,90.68 118.53,90.86 118.53,91.04 118.99,91.51 118.99,91.69 118.83,91.86 118.62,91.86 118.17,91.4 117.99,91.4 117.81,91.58 117.81,91.76 118.21,92.16 118.21,92.34 117.63,92.92 117.63,112.58 116.22,113.98 116.22,120.54 118.01,122.33 118.01,135.34 122.44,139.77 125.28,139.77 125.57,140.06 126.26,140.06 126.65,139.66 127.99,139.66 128.4,139.26 v2(128.47,139.26)
  BOTTOM w0.102: v2(128.47,139.26) 128.79,139.59 U42.CR18
  BOTTOM w0.216: v1(121.78,88.27) JDIM2.3
M_A_DQ1: length 72
  IN1 w0.127: v1(121.59,83.35) 121.59,87.18 117.25,91.52 117.25,112.42 115.84,113.82 115.84,120.7 117.63,122.49 117.63,135.5 118.04,135.9 122.28,140.15 125.12,140.15 125.41,140.44 126.59,140.44 126.98,140.05 128.24,140.05 129.03,139.26 v2(129.12,139.26)
  BOTTOM w0.102: U42.CP18 129.44,139.59 v2(129.12,139.26)
  BOTTOM w0.216: v1(121.59,83.35) 122.03,82.91 JDIM2.4
M_A_DQ2: length 69.6
  IN1 w0.127: v1(123.47,83.32) 122.19,84.6 122.19,85.99 122.32,86.12 122.55,86.12 122.67,86.25 122.67,86.48 122.53,86.63 122.32,86.63 122.19,86.75 122.19,89.11 118.01,93.29 118.01,112.73 116.64,114.1 116.64,120.42 118.39,122.17 118.39,135.18 122.59,139.39 125.44,139.39 125.73,139.68 126.1,139.68 v2(126.52,139.26)
  BOTTOM w0.102: v2(126.52,139.26) 127.03,138.75 U42.CU17
  BOTTOM w0.216: JDIM2.8 123.03,82.88 v1(123.47,83.32)
M_A_DQ3: length 69.8
  IN1 w0.127: v2(127.17,139.26) 126.78,138.87 125.76,138.87 125.62,139 122.75,139 118.77,135.03 118.77,122.01 117.05,120.29 117.05,114.23 118.39,112.89 118.39,98.75 118.52,98.62 119.05,98.62 119.18,98.49 119.18,98.24 119.05,98.11 118.52,98.11 118.39,97.98 118.39,97.73 118.52,97.61 118.99,97.61 119.11,97.48 119.11,97.23 118.99,97.1 118.52,97.1 118.39,96.97 118.39,96.72 118.52,96.59 119.05,96.59 119.18,96.46 119.18,96.21 119.05,96.08 118.52,96.08 118.39,95.96 118.39,95.7 118.53,95.56 119.05,95.56 119.07,95.54 119.18,95.43 119.18,95.18 119.05,95.05 118.52,95.05 118.39,94.92 118.39,94.69 118.52,94.56 119.04,94.56 119.18,94.42 119.18,94.18 119.05,94.05 118.52,94.05 118.39,93.92 118.39,93.52 122.86,89.06 122.86,87.96 v1(123.19,87.62)
  BOTTOM w0.102: v2(127.17,139.26) 127.49,139.59 U42.CU18
  BOTTOM w0.216: v1(123.19,87.62) 122.78,88.04 JDIM2.7
M_A_DQ4: length 71.2
  IN1 w0.127: v1(126.26,88.27) 126.26,89.15 121.96,93.44 121.96,98.54 122.68,99.26 122.68,103.72 122.81,103.85 123.32,103.85 123.45,103.97 123.45,104.23 123.32,104.35 122.81,104.35 122.68,104.48 122.68,104.73 122.81,104.86 123.32,104.86 123.45,104.99 123.45,105.24 123.32,105.37 122.81,105.37 122.68,105.5 122.68,105.75 122.81,105.88 123.32,105.88 123.45,106 123.45,106.26 123.32,106.39 122.81,106.39 122.68,106.51 122.68,106.77 122.81,106.89 123.32,106.89 123.45,107.02 123.45,107.27 123.32,107.4 122.7,107.4 122.58,107.53 122.58,107.78 122.7,107.91 123.32,107.91 123.45,108.04 123.45,108.29 123.32,108.42 122.55,108.42 122.42,108.54 122.42,108.8 122.55,108.93 123.32,108.93 123.45,109.05 123.45,109.29 123.32,109.42 122.45,109.42 122.32,109.55 122.32,109.8 122.45,109.93 123.31,109.93 123.45,110.07 123.45,110.32 123.32,110.45 122.81,110.45 122.68,110.58 122.68,111.78 119.38,115.08 119.38,119.33 121.09,121.04 121.09,133.89 123.52,136.32 126.81,136.32 126.99,136.5 128.14,136.5 v2(129.12,137.48)
  BOTTOM w0.102: v2(129.12,137.48) 129.44,137.8 U42.CP16
  BOTTOM w0.216: JDIM2.21 126.28,88.28 v1(126.26,88.27)
M_A_DQ5: length 70.7
  IN1 w0.127: v1(126.24,86.91) 125.82,87.32 125.82,89.04 121.58,93.28 121.58,98.7 122.3,99.42 122.3,103.58 121.74,104.15 121.74,108.13 121.61,108.26 120.81,108.26 120.68,108.39 120.68,108.64 120.8,108.77 121.61,108.77 121.74,108.89 121.74,109.15 121.61,109.27 120.87,109.27 120.75,109.4 120.75,109.66 120.87,109.78 121.61,109.78 121.74,109.91 121.74,110.16 121.61,110.29 120.89,110.29 120.76,110.42 120.76,110.67 120.89,110.8 121.61,110.8 121.74,110.93 121.74,111.18 121.61,111.31 121.05,111.31 120.93,111.43 120.93,111.69 121.05,111.81 121.61,111.81 121.74,111.94 121.74,112.18 119,114.93 119,119.49 120.71,121.2 120.71,134.15 123.28,136.72 126.41,136.72 126.59,136.9 127.89,136.9 v2(128.47,137.48)
  BOTTOM w0.102: v2(128.47,137.48) 128.79,137.8 U42.CR16
  BOTTOM w0.216: v1(126.24,86.91) 125.28,87.87 JDIM2.17
M_A_DQ6: length 69.9
  IN1 w0.127: v2(127.17,137.48) 126.63,137.48 126.25,137.1 123.07,137.1 120.33,134.36 120.33,121.36 118.62,119.65 118.62,114.77 119.87,113.51 119.87,106.97 120.62,106.22 120.62,102.26 121.92,100.95 121.92,99.58 120.67,98.32 120.67,97.33 121.2,96.8 121.2,93.13 125.44,88.89 125.44,86.04 125.57,85.92 126.13,85.92 126.26,85.79 126.26,85.54 126.13,85.41 125.57,85.41 125.44,85.28 125.44,85.03 125.57,84.9 126.13,84.9 126.26,84.77 126.26,84.52 126.13,84.39 125.57,84.39 125.44,84.26 125.44,83.82 125.57,83.69 125.87,83.69 126,83.57 126,83.32 125.86,83.18 125.57,83.18 125.44,83.06 125.44,83.06 v1(125.01,82.63)
  BOTTOM w0.102: v2(127.17,137.48) 127.49,137.8 U42.CU16
  BOTTOM w0.216: v1(125.01,82.63) 125.03,82.62 JDIM2.16
M_A_DQ7: length 71.1
  IN1 w0.127: v2(126.45,137.84) 126.09,137.48 122.79,137.48 119.95,134.64 119.95,121.52 118.23,119.81 118.23,114.61 119.49,113.35 119.49,106.81 120.24,106.07 120.24,102.1 121.54,100.8 121.54,99.74 120.28,98.48 120.28,96.71 120.41,96.59 120.69,96.59 120.82,96.45 120.82,96.2 120.69,96.08 120.41,96.08 120.28,95.95 120.28,95.7 120.41,95.57 120.68,95.57 120.82,95.43 120.82,95.19 120.69,95.06 120.41,95.06 120.28,94.93 120.28,94.55 120.41,94.43 120.65,94.43 120.78,94.3 120.78,94.05 120.66,93.92 120.41,93.92 120.28,93.79 120.28,93.39 125.06,88.62 125.06,85.03 v1(124.84,84.8)
  BOTTOM w0.102: v2(126.45,137.84) 126.45,137.3 126.99,136.77 127.82,136.77 U42.CT14
  BOTTOM w0.216: v1(124.84,84.8) 126.03,83.62 JDIM2.20
M_A_DQ8: length 64.5
  IN1 w0.127: v1(127.94,86.14) 127.58,86.5 127.58,86.5 127.45,86.63 127.45,89.64 124.45,92.65 124.45,95.39 124.57,95.51 124.91,95.51 125.03,95.64 125.03,95.89 124.91,96.02 124.57,96.02 124.45,96.15 124.45,96.53 125.01,97.1 125.01,98.36 124.65,98.72 124.65,112.84 127.43,115.63 127.43,118.61 122.28,123.75 122.28,133.08 123.9,134.69 125.61,134.69 126.1,135.18 127.73,135.18 v2(128.48,135.93)
  BOTTOM w0.102: U42.CR13 128.79,136.25 v2(128.48,135.93)
  BOTTOM w0.216: JDIM2.29 128.28,88.65 128.44,88.48 128.44,86.64 v1(127.94,86.14)
M_A_DQ9: length 65.4
  IN1 w0.127: v1(127.98,87.46) 128.39,87.88 128.39,89.24 125.99,91.64 125.99,92.4 125.86,92.54 125.25,92.54 125.12,92.67 125.12,92.92 125.25,93.05 125.87,93.05 125.99,93.17 125.99,93.42 125.87,93.55 125.21,93.55 125.07,93.68 125.07,93.93 125.2,94.05 125.87,94.05 125.99,94.18 125.99,94.43 125.87,94.56 125.22,94.56 125.09,94.7 125.09,94.94 125.22,95.07 125.87,95.07 125.99,95.2 125.99,99.57 125.05,100.52 125.05,112.69 127.81,115.45 127.81,118.77 122.67,123.91 122.67,132.83 124.12,134.29 125.74,134.29 126.26,134.8 127.99,134.8 v2(129.12,135.93)
  BOTTOM w0.102: U42.CP13 129.44,136.25 v2(129.12,135.93)
  BOTTOM w0.216: v1(127.98,87.46) 127.8,87.46 127.28,87.99 JDIM2.25
M_A_DQ10: length 64
  IN1 w0.127: v1(127.54,83.28) 126.69,84.12 126.69,89.32 123.16,92.86 123.16,98.38 123.4,98.62 123.4,99.15 123.88,99.64 123.88,111.19 119.81,115.26 119.81,119.15 121.52,120.87 121.52,133.61 123.74,135.83 v2(125.19,135.83)
  BOTTOM w0.102: U42.CU12 127.44,135.5 125.51,135.5 v2(125.19,135.83)
  BOTTOM w0.216: v1(127.54,83.28) 127.52,83.28 127.03,82.79 JDIM2.24
M_A_DQ11: length 64
  IN1 w0.127: v2(125.78,135.88) 125.78,135.87 125.24,135.33 123.98,135.33 121.9,133.25 121.9,120.71 120.2,119 120.2,115.41 124.26,111.35 124.26,99.05 124.06,98.85 124.06,96.6 123.94,96.47 123.81,96.47 123.68,96.34 123.68,96.09 123.81,95.96 123.94,95.96 124.06,95.84 124.06,95.58 123.94,95.46 123.81,95.46 123.68,95.33 123.68,95.07 123.81,94.95 123.94,94.95 124.06,94.82 124.06,92.49 127.07,89.48 127.07,85.08 127.32,84.83 v1(127.57,84.83)
  BOTTOM w0.102: U42.CU13 126.23,136.33 v2(125.78,135.88)
  BOTTOM w0.216: v1(127.57,84.83) 128.03,84.37 JDIM2.28
M_A_DQ12: length 64.9
  IN1 w0.127: v2(129.85,135.06) 129.79,135 129.79,134.25 128.8,133.25 127.69,133.25 127.03,132.58 126.36,132.58 126.01,132.24 126.01,123.74 130.06,119.7 130.06,114.13 128.63,112.7 128.63,111.73 128.51,111.6 127.64,111.6 127.51,111.48 127.51,111.22 127.65,111.09 128.65,111.09 128.77,110.96 128.77,110.71 128.65,110.58 127.63,110.58 127.5,110.45 127.5,110.21 127.63,110.08 128.62,110.08 128.75,109.95 128.75,109.7 128.62,109.57 127.62,109.57 127.49,109.45 127.49,109.19 127.62,109.06 128.57,109.06 128.71,108.93 128.71,108.68 128.58,108.56 127.65,108.56 127.53,108.43 127.53,108.18 127.65,108.05 128.51,108.05 128.63,107.92 128.63,100.95 129.19,100.39 129.19,91.62 131.19,89.62 131.19,88.14 131.75,87.58 v1(131.75,87.54)
  BOTTOM w0.102: U42.CP11 129.6,134.8 v2(129.85,135.06)
  BOTTOM w0.216: JDIM2.41 131.28,88.02 v1(131.75,87.54)
M_A_DQ13: length 64.3
  IN1 w0.127: v2(129.12,134.41) 128.37,133.66 127.57,133.66 126.87,132.96 126.2,132.96 125.53,132.29 125.53,123.69 129.68,119.54 129.68,114.29 127.01,111.61 127.01,107.67 127.13,107.54 127.74,107.54 127.9,107.38 127.9,107.16 127.78,107.03 127.13,107.03 127.01,106.91 127.01,106.65 127.13,106.52 127.8,106.52 127.94,106.38 127.94,106.14 127.82,106.02 127.13,106.02 127.01,105.89 127.01,105.64 127.13,105.51 127.79,105.51 127.94,105.36 127.94,105.13 127.81,105 127.13,105 127.01,104.87 127.01,104.47 128.25,103.23 128.25,100.79 128.81,100.23 128.81,91.47 130.81,89.46 130.81,87.12 131.7,86.24 v1(131.7,86.22)
  BOTTOM w0.102: v2(129.12,134.41) 128.79,134.73 U42.CR11
  BOTTOM w0.216: v1(131.7,86.22) 131.7,86.24 130.6,87.34 130.6,87.58 130.6,88.15 130.28,88.48 JDIM2.37
M_A_DQ14: length 63.1
  IN1 w0.127: v1(131.53,82.74) 131.15,82.74 130.48,83.41 130.48,85.43 129.5,86.41 129.5,88.55 129.63,88.67 129.92,88.67 130.05,88.8 130.05,89.05 129.92,89.18 129.63,89.18 129.5,89.31 129.5,89.7 127.53,91.67 127.53,92.78 127.4,92.91 127.23,92.91 127.11,93.04 127.11,93.29 127.23,93.42 127.4,93.42 127.53,93.54 127.53,93.8 127.4,93.92 127.23,93.92 127.11,94.05 127.11,94.31 127.23,94.43 127.4,94.43 127.53,94.56 127.53,94.81 127.4,94.94 127.23,94.94 127.11,95.07 127.11,95.32 127.23,95.45 127.4,95.45 127.53,95.58 127.53,95.83 127.4,95.96 127.23,95.96 127.11,96.08 127.11,96.34 127.23,96.46 127.4,96.46 127.53,96.59 127.53,99.71 126.87,100.36 126.87,103.11 126.25,103.73 126.25,112.11 128.92,114.78 128.92,119.22 124.77,123.38 124.77,132.6 125.89,133.72 126.5,133.72 127.17,134.4 v2(127.17,134.41)
  BOTTOM w0.102: U42.CU11 127.49,134.73 v2(127.17,134.41)
  BOTTOM w0.216: JDIM2.42 v1(131.53,82.74)
M_A_DQ15: length 64.2
  IN1 w0.127: v2(127.82,134.41) 127.43,134.02 127.33,134.02 126.65,133.34 126.04,133.34 125.15,132.45 125.15,123.53 129.3,119.38 129.3,114.53 126.63,111.86 126.63,103.89 127.25,103.26 127.25,100.77 127.91,100.11 127.91,99.73 128.03,99.6 128.3,99.6 128.43,99.48 128.43,99.22 128.3,99.1 128.03,99.1 127.91,98.97 127.91,96.31 128.03,96.19 128.3,96.19 128.43,96.06 128.43,95.8 128.3,95.68 128.03,95.68 127.91,95.55 127.91,95.3 128.03,95.17 128.3,95.17 128.43,95.04 128.43,94.79 128.3,94.66 128.03,94.66 127.91,94.53 127.91,94.28 128.03,94.15 128.3,94.15 128.43,94.03 128.43,93.77 128.3,93.65 128.03,93.65 127.91,93.52 127.91,93.26 128.03,93.14 128.3,93.14 128.43,93.01 128.43,92.76 128.3,92.63 128.03,92.63 127.91,92.5 127.91,91.83 130.43,89.3 130.43,86.02 130.86,85.58 130.86,84.41 131.02,84.25 v1(131.42,84.25)
  BOTTOM w0.102: v2(127.82,134.41) 128.14,134.08 U42.CT9
  BOTTOM w0.216: v1(131.42,84.25) 130.53,83.36 JDIM2.38
M_A_DQ16: length 56.8
  IN1 w0.127: v1(133.25,86.78) 133.69,87.22 133.69,91.16 131.83,93.03 131.83,99.64 130.77,100.69 130.77,103.89 131.37,104.49 131.37,104.87 131.24,105 130.9,105 130.77,105.13 130.77,105.38 130.9,105.51 131.24,105.51 131.37,105.64 131.37,105.89 131.24,106.02 130.9,106.02 130.77,106.14 130.77,106.4 130.9,106.52 131.24,106.52 131.37,106.65 131.37,106.91 131.24,107.03 130.9,107.03 130.77,107.16 130.77,107.41 130.9,107.54 131.24,107.54 131.37,107.67 131.37,107.92 131.24,108.05 130.9,108.05 130.77,108.18 130.77,112.45 131.64,113.32 131.64,120.35 129.09,122.9 129.09,130.56 129.53,131 129.53,132.15 129.25,132.44 128.89,132.44 v2(128.47,132.85)
  BOTTOM w0.102: U42.CR8 128.79,133.18 v2(128.47,132.85)
  BOTTOM w0.216: v1(133.25,86.78) 132.28,87.75 JDIM2.45
M_A_DQ17: length 56.3
  IN1 w0.127: v1(133.46,84.22) 132.58,85.11 132.58,89.39 130.5,91.47 130.5,99.82 130.01,100.31 130.01,112.76 130.87,113.63 130.87,120.03 128.33,122.58 128.33,130.22 v2(126.44,132.1)
  BOTTOM w0.102: v2(126.44,132.1) 127.49,133.15 U42.CU8
  BOTTOM w0.216: JDIM2.46 132.53,83.29 v1(133.46,84.22)
M_A_DQ18: length 56.3
  IN1 w0.127: v2(128.5,132.05) 128.71,131.84 128.71,131.57 128.47,131.32 128.47,130.8 128.71,130.56 128.71,122.74 131.25,120.19 131.25,113.47 130.39,112.61 130.39,100.51 130.88,100.02 130.88,96.23 131,96.1 131.32,96.1 131.45,95.98 131.45,95.72 131.32,95.6 131,95.6 130.88,95.47 130.88,95.21 131,95.09 131.32,95.09 131.45,94.96 131.45,94.71 131.32,94.58 131,94.58 130.88,94.45 130.88,94.2 131,94.07 131.32,94.07 131.45,93.94 131.45,93.69 131.32,93.56 131,93.56 130.88,93.44 130.88,93.18 131,93.06 131.32,93.06 131.45,92.93 131.45,92.67 131.32,92.55 131,92.55 130.88,92.42 130.88,91.69 131.18,91.39 131.36,91.39 132.05,92.08 132.24,92.08 132.41,91.9 132.41,91.72 131.69,90.99 131.69,90.81 131.87,90.64 132.05,90.64 132.73,91.32 132.94,91.32 133.11,91.16 133.11,90.98 132.41,90.28 132.41,90.1 133.28,89.23 v1(133.28,88.22)
  BOTTOM w0.102: U42.CR7 128.79,132.34 v2(128.5,132.05)
  BOTTOM w0.216: JDIM2.49 v1(133.28,88.22)
M_A_DQ19: length 55.7
  IN1 w0.127: v1(133.53,82.76) 132.19,84.09 132.19,89.23 129.62,91.8 129.62,100.59 129.63,100.6 129.63,113.08 130.49,113.95 130.49,119.88 127.95,122.42 127.95,129.99 127.05,130.88 v2(126.43,130.88)
  BOTTOM w0.102: U42.CU7 127.3,132.45 126.91,132.07 126.91,131.37 v2(126.43,130.88)
  BOTTOM w0.216: JDIM2.50 v1(133.53,82.76)
M_A_DQ20: length 58
  IN1 w0.127: v2(131.36,129.54) 131.59,129.54 131.8,129.33 131.8,129.04 131.92,128.91 132.27,128.91 132.4,128.79 132.4,124.85 133.88,123.36 133.88,104.85 133.61,104.58 133.61,103.94 134.52,103.03 134.52,100.28 134.96,99.83 134.96,94.63 134.74,94.4 134.74,94.07 134.89,93.91 135.35,93.91 135.81,94.37 135.99,94.37 136.26,94.1 136.26,93.92 135.89,93.55 135.89,93.37 136.07,93.19 136.25,93.19 136.62,93.56 136.8,93.56 136.98,93.38 136.98,93.2 136.63,92.85 136.63,92.66 136.8,92.48 136.98,92.48 137.34,92.85 137.52,92.85 137.7,92.67 137.7,92.49 137.39,92.17 137.39,91.99 137.88,91.5 137.88,89.04 137.31,88.46 137.31,86.31 137.45,86.16 137.45,85.8 137.31,85.66 137.31,85.29 137.45,85.15 137.45,84.79 137.31,84.64 137.31,84.24 137.58,83.97 137.58,83.34 137.46,83.22 137.09,83.22 136.93,83.38 v1(136.93,83.48)
  BOTTOM w0.079: v2(131.36,129.54) 131.04,129.86 U42.CM3
  BOTTOM w0.216: v1(136.93,83.48) 136.53,83.07 JDIM2.62
M_A_DQ21: length 57
  IN1 w0.127: v2(131.36,130.19) 131.21,130.04 130.19,130.04 130.06,129.91 130.06,129.45 130.19,129.32 130.73,129.32 130.84,129.22 130.84,128.84 130.71,128.71 130.19,128.71 130.06,128.58 130.06,128.33 130.19,128.2 130.75,128.2 130.88,128.07 130.88,127.82 130.75,127.7 130.19,127.7 130.06,127.57 130.06,127.31 130.19,127.19 130.71,127.19 130.9,127 130.9,124.73 132.74,122.88 132.74,112.8 132.47,112.53 132.47,100.55 133.36,99.67 133.36,97.41 132.94,96.99 132.94,93.48 135.82,90.59 135.82,85.81 134.95,84.94 134.95,83.22 v1(135.53,82.64)
  BOTTOM w0.102: U42.CM4 131.04,130.51 v2(131.36,130.19)
  BOTTOM w0.216: JDIM2.58 v1(135.53,82.64)
M_A_DQ22: length 56.5
  IN1 w0.127: v2(131.36,128.24) 131.36,128.4 131.49,128.53 131.88,128.53 132.02,128.4 132.02,127.91 131.71,127.61 131.71,127.15 131.84,127.02 131.89,127.02 132.02,126.9 132.02,126.64 131.89,126.52 131.79,126.52 131.66,126.38 131.66,126.13 131.79,126.01 131.89,126.01 132.02,125.88 132.02,125.63 131.89,125.5 131.79,125.5 131.66,125.37 131.66,125.04 133.5,123.2 133.5,112.48 133.23,112.21 133.23,111.83 133.36,111.7 133.38,111.7 133.5,111.58 133.5,111.32 133.38,111.2 133.36,111.2 133.23,111.07 133.23,110.82 133.36,110.69 133.38,110.69 133.5,110.56 133.5,110.31 133.38,110.18 133.36,110.18 133.23,110.05 133.23,109.8 133.36,109.67 133.38,109.67 133.5,109.55 133.5,109.29 133.38,109.16 133.36,109.16 133.23,109.04 133.23,108.78 133.36,108.66 133.38,108.66 133.5,108.53 133.5,108.28 133.38,108.15 133.36,108.15 133.23,108.02 133.23,107.77 133.36,107.64 133.38,107.64 133.5,107.51 133.5,107.26 133.38,107.13 133.36,107.13 133.23,107.01 133.23,106.75 133.36,106.62 133.38,106.62 133.5,106.5 133.5,106.24 133.38,106.12 133.36,106.12 133.23,105.99 133.23,105.74 133.36,105.61 133.38,105.61 133.5,105.48 133.5,105.23 133.38,105.1 133.36,105.1 133.23,104.97 133.23,103.78 133.84,103.17 133.84,102.79 133.97,102.66 134.01,102.66 134.14,102.54 134.14,102.28 134.01,102.16 133.97,102.16 133.83,102.02 133.83,101.47 133.96,101.34 134.01,101.34 134.14,101.21 134.14,100.96 134.01,100.83 133.96,100.83 133.83,100.7 133.83,100.27 134.12,99.98 134.12,97.06 134.58,96.6 134.58,94.79 134.22,94.42 133.86,94.42 133.7,94.26 133.7,93.92 133.83,93.79 134.26,93.79 134.38,93.67 134.38,93.25 134.51,93.12 134.69,93.12 135.1,93.53 135.31,93.53 135.47,93.37 135.47,93.19 134.98,92.7 134.98,92.51 135.16,92.34 135.34,92.34 135.81,92.81 136.03,92.81 136.19,92.65 136.19,92.47 135.71,91.99 135.71,91.79 135.88,91.62 136.06,91.62 136.55,92.11 136.73,92.11 136.91,91.93 136.91,91.75 136.45,91.29 136.45,91.11 136.68,90.88 136.86,90.88 137.11,91.13 137.32,91.13 137.5,90.94 137.5,90.68 137.32,90.5 137.07,90.5 136.93,90.35 136.93,89.91 137.05,89.78 137.37,89.78 137.5,89.66 137.5,89.4 137.37,89.28 137.05,89.28 136.93,89.15 136.93,88.42 v1(136.78,88.27)
  BOTTOM w0.079: v2(131.36,128.24) 131.04,128.56 U42.CM1
  BOTTOM w0.216: JDIM2.63 v1(136.78,88.27)
M_A_DQ23: length 57.3
  IN1 w0.127: v2(131.29,126.96) 131.28,126.95 131.28,124.88 133.12,123.04 133.12,112.64 132.85,112.37 132.85,100.71 133.74,99.82 133.74,97.25 133.32,96.83 133.32,96.45 133.45,96.33 134.06,96.33 134.2,96.18 134.2,95.94 134.07,95.82 133.45,95.82 133.32,95.69 133.32,95.44 133.45,95.31 134.05,95.31 134.19,95.18 134.19,94.93 134.06,94.8 133.45,94.8 133.32,94.67 133.32,93.64 136.36,90.6 136.42,90.6 136.55,90.47 136.55,90.22 136.42,90.09 136.33,90.09 136.2,89.96 136.2,89.71 136.33,89.58 136.42,89.58 136.55,89.45 136.55,89.2 136.42,89.07 136.33,89.07 136.2,88.94 136.2,84.74 136.34,84.61 136.8,84.61 136.93,84.74 136.93,86.62 v1(136.76,86.78)
  BOTTOM w0.102: v2(131.29,126.96) 132.1,127.77 132.1,128.86 U42.CK2
  BOTTOM w0.216: v1(136.76,86.78) 135.78,87.77 JDIM2.59
M_A_DQ24: length 52.9
  IN1 w0.127: v1(138.43,84.1) 138.43,84.64 138.61,84.82 138.61,85.25 138.43,85.43 138.43,86.27 139.08,86.91 139.08,88.31 139.68,88.91 139.68,92.38 136.63,95.43 136.63,100.91 136.16,101.38 136.16,103.06 136.63,103.53 136.63,104.32 136.16,104.78 135.08,105.86 135.08,123.85 133.95,124.98 133.95,127.59 133.38,128.15 133.38,129.06 v2(132.9,129.54)
  BOTTOM w0.102: U42.CJ3 132.57,129.86 v2(132.9,129.54)
  BOTTOM w0.216: v1(138.43,84.1) 137.53,83.19 JDIM2.66
M_A_DQ25: length 53.4
  IN1 w0.127: v1(139.63,86.92) 139.88,86.92 140.08,87.12 140.08,92.51 137.01,95.59 137.01,104.47 135.46,106.02 135.46,124.01 135.21,124.26 135.21,124.51 135.46,124.75 135.46,124.94 135.26,125.14 135.08,125.14 134.79,124.86 134.61,124.86 134.33,125.14 134.33,128.65 133.58,129.4 133.58,129.58 134.33,130.33 134.33,130.58 134.14,130.77 133.96,130.77 133.23,130.04 133.05,130.04 v2(132.9,130.19)
  BOTTOM w0.102: v2(132.9,130.19) 132.57,130.51 U42.CJ4
  BOTTOM w0.216: JDIM2.71 138.78,87.77 v1(139.63,86.92)
M_A_DQ26: length 52.3
  IN1 w0.127: v1(132.92,126.41) 132.83,126.32 132.83,125.02 134.32,123.54 134.32,104.17 135.4,103.09 135.4,95.58 138.31,92.66 138.31,88.86 137.78,88.32 137.78,86.6 138.02,86.36 138.02,83.15 137.37,82.51 137.37,82.26 137.59,82.04 137.87,82.04 v1(138.53,82.69)
  BOTTOM w0.102: v1(132.92,126.41) 132.96,126.45 133.41,126.91 133.41,128.56 U42.CH1
  BOTTOM w0.216: JDIM2.70 v1(138.53,82.69)
M_A_DQ27: length 52.4
  IN1 w0.127: v1(138.24,87.46) 138.69,87.92 138.69,89.08 138.82,89.21 139.17,89.21 139.3,89.33 139.3,89.59 139.17,89.71 138.82,89.71 138.69,89.84 138.69,90.1 138.82,90.22 139.17,90.22 139.3,90.35 139.3,90.6 139.17,90.73 138.82,90.73 138.69,90.86 138.69,91.46 138.82,91.58 139.17,91.58 139.3,91.71 139.3,91.96 139.17,92.09 138.82,92.09 138.69,92.22 138.69,92.82 135.78,95.74 135.78,96.12 135.9,96.25 136.12,96.25 136.24,96.37 136.24,96.63 136.12,96.76 135.9,96.76 135.78,96.88 135.78,99.63 135.9,99.76 136.12,99.76 136.24,99.88 136.24,100.14 136.12,100.26 135.9,100.26 135.78,100.39 135.78,103.25 135.51,103.52 135.51,103.7 136.01,104.21 136.01,104.39 135.84,104.57 135.66,104.57 135.15,104.06 134.97,104.06 134.7,104.33 134.7,104.68 135.03,105.02 135.03,105.26 134.7,105.6 134.7,123.7 134.16,124.23 133.35,125.04 133.35,125.68 133.57,125.9 133.57,126.19 133.35,126.4 133.35,126.7 133.57,126.91 133.57,127.26 v1(132.82,128.01)
  BOTTOM w0.102: v1(132.82,128.01) 132.51,128.31 U42.CJ1
  BOTTOM w0.216: v1(138.24,87.46) 137.78,87.93 JDIM2.67
M_A_DQ28: length 53.8
  IN1 w0.127: v1(141.22,86.12) 141.43,86.12 142.45,87.14 142.45,88.86 142.58,88.99 142.88,88.99 143,89.12 143,89.37 142.88,89.5 142.58,89.5 142.45,89.63 142.45,89.88 142.58,90.01 142.88,90.01 143,90.13 143,90.39 142.88,90.52 142.58,90.52 142.45,90.64 142.45,90.9 142.58,91.02 142.88,91.02 143,91.15 143,91.4 142.88,91.53 142.58,91.53 142.45,91.66 142.45,92.25 139,95.7 139,105.59 136.94,107.64 136.94,126.1 135.53,127.52 135.53,127.96 135.29,128.2 135.29,128.93 134.7,129.52 v2(134.7,129.52)
  BOTTOM w0.102: v2(134.7,129.52) 134.36,129.86 U42.CF3
  BOTTOM w0.216: JDIM2.83 141.78,86.67 v1(141.22,86.12)
M_A_DQ29: length 54.9
  IN1 w0.127: v2(134.7,130.19) 134.72,130.19 135.73,129.18 135.73,128.3 135.92,128.11 135.92,127.71 135.98,127.65 137.33,126.31 137.33,108.04 139.38,105.98 139.38,95.85 143.38,91.85 143.38,86.75 142.57,85.94 142.39,85.94 142.22,86.11 142.04,86.11 141.86,85.93 141.86,85.75 142.09,85.52 142.09,85.34 141.56,84.81 v1(141.41,84.81)
  BOTTOM w0.102: v2(134.7,130.19) 134.37,130.51 U42.CF4
  BOTTOM w0.216: v1(141.41,84.81) 140.87,84.27 140.87,82.95 141.03,82.8 JDIM2.80
M_A_DQ30: length 54
  IN1 w0.127: v1(141.25,87.53) 142.07,88.35 142.07,88.8 141.94,88.93 141.31,88.93 141.19,89.05 141.19,89.31 141.31,89.43 141.94,89.43 142.07,89.56 142.07,89.81 141.94,89.94 141.31,89.94 141.19,90.07 141.19,90.32 141.31,90.45 141.94,90.45 142.07,90.58 142.07,90.83 141.94,90.96 141.31,90.96 141.19,91.08 141.19,91.34 141.31,91.47 141.94,91.47 142.07,91.59 142.07,92.09 138.62,95.54 138.62,100.08 138.49,100.21 138.25,100.21 138.12,100.33 138.12,100.59 138.25,100.72 138.49,100.72 138.62,100.84 138.62,104.42 138.09,104.95 138.09,105.13 138.34,105.38 138.34,105.56 138.16,105.74 137.98,105.74 137.73,105.49 137.55,105.49 137.37,105.67 137.37,105.85 137.69,106.17 137.69,106.35 137.52,106.53 137.34,106.53 137.01,106.21 136.83,106.21 136.56,106.48 136.56,125.95 135.15,127.36 135.15,127.81 134.78,128.18 v2(134.78,128.19)
  BOTTOM w0.102: U42.CF1 134.4,128.56 v2(134.78,128.19)
  BOTTOM w0.216: v1(141.25,87.53) 140.78,88.01 JDIM2.79
M_A_DQ31: length 54.8
  IN1 w0.127: v2(136.31,128.26) 136.31,127.86 137.71,126.47 137.71,108.2 140.22,105.68 140.22,101.32 140.02,101.12 139.76,100.86 139.76,96.01 143.76,92.01 143.76,85.84 143.57,85.64 143.57,85.46 143.78,85.24 143.78,85.06 143.6,84.89 143.42,84.89 143.21,85.1 143.03,85.1 142.85,84.92 142.85,84.74 143.05,84.54 143.05,84.36 142.87,84.18 142.69,84.18 142.49,84.38 142.31,84.38 141.66,83.73 v1(141.66,83.53)
  BOTTOM w0.102: v2(136.31,128.26) 136.31,128.26 135.72,128.26 135.46,128.52 135.46,128.84 U42.CE2
  BOTTOM w0.216: JDIM2.84 142.03,83.1 141.66,83.47 v1(141.66,83.53)
M_A_DQ32: length 54
  IN1 w0.127: v2(159.97,129.55) 159.97,129.54 158.93,128.49 158.29,128.49 157.34,127.55 157.34,125.39 158.17,124.56 158.17,122.32 159.04,121.45 159.04,110.73 162.17,107.6 162.17,95.36 164.76,92.77 164.76,88.8 165.42,88.15 165.42,83.77 v1(166.53,82.66)
  BOTTOM w0.102: U42.AG3 159.66,129.86 v2(159.97,129.55)
  BOTTOM w0.216: JDIM2.174 v1(166.53,82.66)
M_A_DQ33: length 54.6
  IN1 w0.127: v2(159.97,130.19) 160.36,129.79 160.36,128.75 160.06,128.44 158.69,127.07 158.69,125.66 159.31,125.03 159.31,123.36 160.18,122.49 160.18,111.21 163.94,107.45 163.94,95.93 166.22,93.65 166.22,89.25 166.92,88.55 167.45,88.55 167.58,88.42 167.58,88.17 167.45,88.04 166.91,88.04 166.78,87.92 166.78,87.39 166.91,87.26 167.06,87.26 167.43,86.89 167.43,86.71 167.09,86.37 166.91,86.37 166.56,86.72 v1(166.25,86.72)
  BOTTOM w0.102: U42.AG4 159.65,130.51 v2(159.97,130.19)
  BOTTOM w0.216: JDIM2.169 165.28,87.69 v1(166.25,86.72)
M_A_DQ34: length 52.7
  IN1 w0.127: v1(166.28,88.18) 166.28,88.66 165.61,89.32 165.61,89.5 165.84,89.72 165.84,89.9 165.52,90.21 165.52,90.55 165.65,90.68 165.71,90.68 165.84,90.8 165.84,91.06 165.71,91.18 165.65,91.18 165.52,91.31 165.52,91.56 165.65,91.69 165.71,91.69 165.84,91.82 165.84,92.07 165.71,92.2 165.65,92.2 165.52,92.33 165.52,92.58 165.65,92.71 165.71,92.71 165.84,92.83 165.84,93.09 165.71,93.22 165.65,93.22 165.52,93.34 165.52,93.81 164.49,94.84 164.14,94.84 164.02,94.95 164.01,94.96 164.01,95.24 163.84,95.41 163.66,95.41 163.54,95.29 163.36,95.29 163.18,95.47 163.18,95.65 163.55,96.03 163.55,96.81 163.41,96.95 163.09,96.95 162.93,97.11 162.93,99.88 163.17,100.11 163.17,100.57 162.93,100.8 162.93,103.51 163.06,103.64 163.43,103.64 163.55,103.77 163.55,104.02 163.43,104.15 163.06,104.15 162.93,104.28 162.93,104.53 163.06,104.66 163.43,104.66 163.55,104.78 163.55,105.04 163.43,105.16 163.06,105.16 162.93,105.29 162.93,105.55 163.06,105.67 163.43,105.67 163.55,105.8 163.55,106.05 163.43,106.18 163.06,106.18 162.93,106.31 162.93,106.56 163.06,106.69 163.43,106.69 163.55,106.82 163.55,107.07 163.43,107.2 163.06,107.2 162.93,107.32 162.93,107.91 159.8,111.05 159.8,121.77 158.93,122.64 158.93,124.88 158.1,125.71 158.1,126.56 v2(158.29,126.75)
  BOTTOM w0.102: U42.AF1 160.3,128.38 159.92,128.38 v2(158.29,126.75)
  BOTTOM w0.216: JDIM2.173 v1(166.28,88.18)
M_A_DQ35: length 53
  IN1 w0.127: v1(166.4,84.07) 165.8,84.67 165.8,85.34 165.92,85.46 166.13,85.46 166.26,85.59 166.26,85.85 166.13,85.97 165.92,85.97 165.8,86.1 165.8,88.3 165.14,88.96 165.14,92.93 162.55,95.52 162.55,107.76 159.42,110.89 159.42,121.61 158.55,122.48 158.55,124.72 157.72,125.55 157.72,127.35 v2(158.38,128.01)
  BOTTOM w0.102: U42.AG1 159.1,128.08 158.45,128.08 v2(158.38,128.01)
  BOTTOM w0.216: JDIM2.170 165.53,83.2 v1(166.4,84.07)
M_A_DQ36: length 54.4
  IN1 w0.127: v1(169.53,82.64) 170.54,83.65 170.54,86.36 170.91,86.73 170.91,91.14 169.42,92.63 169.42,93.63 167.29,95.75 167.29,103.18 166.74,103.73 166.74,107.83 162.43,112.14 162.43,123.42 161.56,124.29 161.56,126.54 162.38,127.36 162.38,129.58 v2(161.77,130.19)
  BOTTOM w0.102: U42.AD4 161.45,130.51 v2(161.77,130.19)
  BOTTOM w0.216: JDIM2.186 v1(169.53,82.64)
M_A_DQ37: length 53.2
  IN1 w0.127: v1(169.34,87.59) 169.69,87.94 169.69,88.98 169.43,89.24 169.25,89.24 169.01,89 168.83,89 168.65,89.18 168.65,89.36 168.77,89.48 168.77,89.66 167.73,90.7 167.73,92.04 167.86,92.17 168.15,92.17 168.28,92.3 168.28,92.55 168.15,92.68 167.86,92.68 167.73,92.8 167.73,93.7 165.04,96.39 165.04,99.47 165.17,99.6 165.47,99.6 165.6,99.72 165.6,99.97 165.47,100.1 165.17,100.1 165.04,100.23 165.04,100.49 165.17,100.61 165.47,100.61 165.6,100.74 165.6,100.99 165.47,101.12 165.17,101.12 165.04,101.25 165.04,103.14 165.6,103.69 165.6,107.36 161.29,111.67 161.29,122.95 160.42,123.82 160.42,127.45 160.9,127.93 160.9,129.27 161.25,129.62 161.67,129.62 v2(161.76,129.53)
  BOTTOM w0.102: U42.AD3 161.43,129.86 v2(161.76,129.53)
  BOTTOM w0.216: v1(169.34,87.59) 169.78,88.02 JDIM2.187
M_A_DQ38: length 52.3
  IN1 w0.127: v1(169.4,86.3) 170.15,87.04 170.15,89.06 169.47,89.74 169.47,89.92 169.88,90.33 170,90.45 170,90.63 169.81,90.82 169.57,90.82 169.07,90.32 168.89,90.32 168.66,90.55 168.66,93.31 165.98,95.99 165.98,107.51 161.67,111.83 161.67,123.11 160.8,123.97 160.8,127.29 v2(161.76,128.25)
  BOTTOM w0.102: U42.AD1 161.45,128.56 v2(161.76,128.25)
  BOTTOM w0.216: v1(169.4,86.3) 169.25,86.45 169.14,86.45 168.78,86.82 JDIM2.183
M_A_DQ39: length 53.3
  IN1 w0.127: v1(169.49,84.02) 170.06,84.58 170.06,86.41 170.53,86.89 170.53,90.98 169.04,92.47 169.04,93.47 166.36,96.15 166.36,107.67 162.05,111.98 162.05,123.26 161.18,124.13 161.18,127 161.72,127.55 v1(161.72,127.6)
  BOTTOM w0.102: U42.AC2 162.54,128.83 162.54,128.41 v1(161.72,127.6)
  BOTTOM w0.216: v1(169.49,84.02) 168.53,83.05 JDIM2.182
M_A_DQ40: length 55.3
  IN1 w0.127: v1(171,84.54) 171.23,84.54 171.66,84.97 171.66,85.36 172.13,85.83 172.38,85.83 173.19,86.64 173.19,88.71 172.58,89.32 172.58,92.16 169.09,95.65 169.09,105.63 168.96,105.75 168.9,105.75 168.77,105.88 168.77,106.13 168.9,106.26 168.96,106.26 169.09,106.39 169.09,107.17 163.62,112.64 163.62,123.92 162.75,124.79 162.75,125.98 163.7,126.93 163.7,129.14 v2(163.31,129.54)
  BOTTOM w0.102: U42.AB3 162.98,129.86 v2(163.31,129.54)
  BOTTOM w0.216: v1(171,84.54) 170.53,84.07 JDIM2.190
M_A_DQ41: length 56.5
  IN1 w0.127: v2(163.32,130.18) 163.32,130.17 164.09,129.41 164.09,126.78 163.38,126.07 163.38,124.7 164,124.08 164,112.79 169.47,107.33 169.47,95.81 173.58,91.7 173.58,91.24 173.45,91.11 173.31,91.11 173.18,90.98 173.18,90.73 173.31,90.6 173.45,90.6 173.58,90.48 173.58,85.51 173.04,84.97 172.86,84.97 172.57,85.26 172.4,85.26 172.22,85.08 172.22,84.9 172.5,84.61 172.5,84.43 172.04,83.97 v1(172.04,83.38)
  BOTTOM w0.102: v2(163.32,130.18) 162.99,130.51 U42.AB4
  BOTTOM w0.216: v1(172.04,83.38) 171.53,82.86 JDIM2.194
M_A_DQ42: length 54
  IN1 w0.127: v2(163.31,128.19) 163.23,128.19 162.81,127.77 162.81,127.18 161.99,126.36 161.99,124.47 162.86,123.6 162.86,112.32 167.17,108.01 167.17,107.11 167.3,106.99 167.87,106.99 168,106.86 168,106.61 167.87,106.48 167.3,106.48 167.17,106.35 167.17,106.1 167.21,106.06 167.3,105.97 167.88,105.97 168.01,105.84 168.01,105.59 167.88,105.46 167.3,105.46 167.17,105.34 167.17,103.91 167.73,103.36 167.73,95.93 170.22,93.44 170.22,93.18 169.94,92.9 169.94,92.72 170.11,92.55 170.3,92.55 170.57,92.82 170.75,92.82 170.93,92.64 170.93,92.46 170.65,92.18 170.65,92 170.82,91.84 171.03,91.84 171.29,92.1 171.47,92.1 171.77,91.81 171.77,91.23 171.64,91.11 171.47,91.11 171.34,90.98 171.34,90.73 171.47,90.6 171.64,90.6 171.77,90.47 171.77,90.22 171.64,90.09 171.47,90.09 171.34,89.96 171.34,89.71 171.47,89.58 171.64,89.58 171.77,89.46 171.77,88.06 v1(171.34,87.62)
  BOTTOM w0.102: U42.Y1 163.68,128.56 v2(163.31,128.19)
  BOTTOM w0.216: JDIM2.195 171.78,88.48 171.79,88.46 171.79,88.08 171.34,87.62 v1(171.34,87.62)
M_A_DQ43: length 54.6
  IN1 w0.127: v1(171.29,86.33) 171.73,86.33 172.2,86.79 172.2,92 168.31,95.89 168.31,96.11 168.41,96.21 168.58,96.21 168.71,96.34 168.71,96.59 168.58,96.72 168.24,96.72 168.11,96.85 168.11,97.1 168.23,97.23 168.58,97.23 168.71,97.35 168.71,99.49 168.42,99.77 168.42,100.05 168.71,100.33 168.71,103.56 168.58,103.69 167.93,103.69 167.76,103.86 167.76,104.07 167.89,104.2 168.58,104.2 168.71,104.32 168.71,104.58 168.58,104.7 168.16,104.7 168.04,104.83 168.04,105.08 168.17,105.21 168.26,105.21 168.39,105.34 168.39,107.33 163.24,112.48 163.24,123.76 162.37,124.63 162.37,126.2 163.21,127.03 163.21,127.5 v2(163.28,127.58)
  BOTTOM w0.102: v2(163.28,127.58) 162.92,127.94 U42.AB1
  BOTTOM w0.216: v1(171.29,86.33) 171.29,86.37 170.78,86.88 JDIM2.191
M_A_DQ44: length 55.1
  IN1 w0.127: v1(175.03,82.73) 176.06,83.76 176.06,84.58 176.23,84.76 176.23,85.75 176.06,85.93 176.06,92.4 172.96,95.5 172.96,96.78 173.68,97.51 173.68,106.3 166.25,113.73 166.25,129.05 v2(165.11,130.19)
  BOTTOM w0.102: v2(165.11,130.19) 164.79,130.51 U42.W4
  BOTTOM w0.216: JDIM2.208 v1(175.03,82.73)
M_A_DQ45: length 54.8
  IN1 w0.127: v2(165.09,129.54) 165.87,128.76 165.87,113.57 173.3,106.14 173.3,100.4 172.58,99.67 172.58,95.34 175.68,92.24 175.68,85.98 175.55,85.85 175.44,85.85 175.31,85.72 175.31,85.47 175.44,85.34 175.55,85.34 175.68,85.21 175.68,84.81 v1(175,84.13)
  BOTTOM w0.102: U42.W3 164.76,129.86 v2(165.09,129.54)
  BOTTOM w0.216: JDIM2.204 174.03,83.16 v1(175,84.13)
M_A_DQ46: length 53.4
  IN1 w0.127: v1(174.78,86.86) 174.88,86.76 175.17,86.76 175.29,86.88 175.29,92.08 172.19,95.19 172.19,99.83 172.57,100.2 172.57,100.38 172.19,100.75 172.19,103.28 172.32,103.4 172.58,103.4 172.82,103.64 172.82,103.83 172.71,103.94 172.35,103.94 172.19,104.1 172.19,104.38 172.32,104.51 172.79,104.51 172.92,104.63 172.92,104.85 172.76,105.01 172.32,105.01 172.19,105.14 172.19,105.4 172.32,105.52 172.79,105.52 172.92,105.65 172.92,105.9 172.79,106.03 172.32,106.03 172.19,106.16 172.19,106.71 165.49,113.41 165.49,128.11 165.36,128.24 v2(165.11,128.24)
  BOTTOM w0.102: U42.W1 164.78,128.56 v2(165.11,128.24)
  BOTTOM w0.216: JDIM2.203 173.78,87.86 v1(174.78,86.86)
M_A_DQ47: length 54.2
  IN1 w0.127: v2(164.76,127.65) 164.76,127.52 165.11,127.17 165.11,113.25 171.01,107.35 171.01,106.87 171.14,106.74 171.62,106.74 171.8,106.56 171.8,106.2 171.67,106.07 171.14,106.07 171.01,105.94 171.01,105.69 171.14,105.56 171.69,105.56 171.81,105.43 171.81,105.18 171.69,105.05 171.14,105.05 171.01,104.93 171.01,104.67 171.14,104.54 171.69,104.54 171.81,104.42 171.81,104.15 171.69,104.03 171.29,104.03 171.16,103.9 171.16,103.62 171.29,103.49 171.69,103.49 171.81,103.36 171.81,101.29 171.69,101.16 171.14,101.16 171.01,101.04 171.01,100.78 171.14,100.65 171.69,100.65 171.81,100.53 171.81,97.05 171.69,96.92 171.29,96.92 171.17,96.79 171.17,96.54 171.3,96.41 171.69,96.41 171.81,96.29 171.81,95.96 171.69,95.83 171.45,95.83 171.32,95.7 171.32,95.52 174.68,92.16 174.68,91.82 174.83,91.68 174.83,91.18 174.68,91.04 174.68,90.51 174.83,90.36 174.83,89.93 174.68,89.79 174.68,89.34 174.78,89.25 v1(174.78,88.23)
  BOTTOM w0.102: U42.V2 165.8,128.91 165.8,128.28 165.17,127.65 v2(164.76,127.65)
  BOTTOM w0.216: v1(174.78,88.23) JDIM2.207
M_A_DQ48: length 55.5
  IN1 w0.127: v2(166.64,129.54) 167.55,128.63 167.55,124.7 168.06,124.2 168.06,116.58 167.44,115.97 167.44,114.22 175.37,106.29 175.38,106.29 175.38,94.77 177.91,92.24 177.91,85.89 177.78,85.77 177.48,85.77 177.35,85.64 177.35,85.39 177.48,85.26 177.78,85.26 177.91,85.13 177.91,84.75 v1(176.5,83.33)
  BOTTOM w0.102: U42.U3 166.32,129.86 v2(166.64,129.54)
  BOTTOM w0.216: JDIM2.212 176.03,82.86 v1(176.5,83.33)
M_A_DQ49: length 56.7
  IN1 w0.127: v1(177.93,84.11) 178.29,84.48 178.29,84.71 178.42,84.84 178.54,84.84 178.67,84.96 178.67,85.22 178.54,85.35 178.42,85.35 178.29,85.47 178.29,92.39 176.19,94.49 175.76,94.92 175.76,106.44 175.64,106.56 167.88,114.33 167.88,114.55 168.01,114.68 168.3,114.68 168.44,114.82 168.44,115.09 168.29,115.24 167.95,115.24 167.83,115.36 167.83,115.62 167.95,115.74 168.31,115.74 168.44,115.87 168.44,124.36 167.93,124.86 167.93,128.9 v2(166.64,130.19)
  BOTTOM w0.102: U42.U4 166.32,130.51 v2(166.64,130.19)
  BOTTOM w0.216: v1(177.93,84.11) 177.03,83.21 JDIM2.216
M_A_DQ50: length 54.6
  IN1 w0.127: v1(176.76,86.89) 176.88,86.77 177.37,86.77 177.53,86.93 177.53,92.08 175,94.61 175,100.1 174.49,100.6 174.49,106.63 167.06,114.06 167.06,116.48 167.19,116.61 167.55,116.61 167.68,116.74 167.68,116.99 167.55,117.12 167.19,117.12 167.06,117.24 167.06,117.5 167.19,117.63 167.55,117.63 167.68,117.75 167.68,118.01 167.55,118.13 167.19,118.13 167.06,118.26 167.06,118.51 167.19,118.64 167.55,118.64 167.68,118.77 167.68,119.02 167.55,119.15 167.19,119.15 167.06,119.28 167.06,119.53 167.19,119.66 167.55,119.66 167.68,119.78 167.68,120.04 167.55,120.17 167.19,120.17 167.06,120.29 167.06,120.67 167.62,121.23 167.62,124.09 167.17,124.54 167.17,127.71 v2(166.64,128.24)
  BOTTOM w0.102: v2(166.64,128.24) 166.84,128.24 U42.R1
  BOTTOM w0.216: JDIM2.211 175.78,87.88 v1(176.76,86.89)
M_A_DQ51: length 54.8
  IN1 w0.127: v2(166.71,127.57) 166.68,127.54 166.68,123.93 166.81,123.81 167.12,123.81 167.24,123.68 167.24,123.43 167.12,123.3 166.81,123.3 166.68,123.17 166.68,122.92 166.81,122.79 167.12,122.79 167.24,122.66 167.24,122.41 167.12,122.28 166.81,122.28 166.68,122.16 166.68,121.9 166.81,121.77 167.12,121.77 167.24,121.65 167.24,121.39 167.12,121.27 166.81,121.27 166.68,121.14 166.68,113.91 174.11,106.48 174.11,97.17 174.24,97.04 174.42,97.04 174.57,96.9 174.57,96.72 174.5,96.65 173.52,96.65 173.39,96.52 173.39,96.27 173.52,96.14 174.49,96.14 174.62,96.01 174.62,95.69 174.49,95.56 174.04,95.56 173.87,95.38 173.87,95.2 174.08,94.98 174.37,94.98 174.62,94.74 174.62,94.45 176.49,92.58 176.49,92.12 176.62,91.99 177,91.99 177.15,91.84 177.15,91.61 177.02,91.48 176.62,91.48 176.49,91.35 176.49,91.1 176.62,90.97 177.01,90.97 177.15,90.83 177.15,90.59 177.02,90.47 176.62,90.47 176.49,90.34 176.49,90.08 176.62,89.96 177.02,89.96 177.15,89.83 177.15,89.58 177.02,89.45 176.62,89.45 176.49,89.32 176.49,88.52 v1(176.78,88.23)
  BOTTOM w0.102: v2(166.71,127.57) 166.26,128.02 166.26,128.2 U42.U1
  BOTTOM w0.216: v1(176.78,88.23) 176.79,88.25 176.79,89.53 JDIM2.215
M_A_DQ52: length 56.3
  IN1 w0.127: v1(180.17,84.1) 180.72,84.65 180.72,85.43 181.35,86.07 181.35,92.58 179.41,94.52 179.41,99.91 180.08,100.58 180.08,105.31 170.69,114.7 170.69,126.41 169.95,127.14 169.87,127.14 169.59,127.42 169.59,129.05 v2(168.45,130.19)
  BOTTOM w0.102: U42.P4 168.12,130.51 v2(168.45,130.19)
  BOTTOM w0.216: JDIM2.224 179.03,82.96 v1(180.17,84.1)
M_A_DQ53: length 55.2
  IN1 w0.127: v2(168.45,129.54) 169.21,128.78 169.21,128.02 169.32,127.9 169.32,127.23 170.31,126.25 170.31,114.54 179.7,105.15 179.7,103.66 179.23,103.18 179.23,100.36 179.03,100.16 179.03,94.36 180.97,92.42 180.97,86.22 179.68,84.93 179.68,83.09 v1(180.08,82.69)
  BOTTOM w0.102: v2(168.45,129.54) 168.12,129.86 U42.P3
  BOTTOM w0.216: JDIM2.228 180.03,82.63 v1(180.08,82.69)
M_A_DQ54: length 53.5
  IN1 w0.127: v1(180.03,86.93) 180.03,86.36 180.16,86.23 180.44,86.23 180.59,86.38 180.59,92.13 180.45,92.27 180.17,92.27 180.05,92.4 180.05,92.81 178.65,94.2 178.65,100.32 178.84,100.51 178.84,103.34 179.17,103.67 179.17,103.78 179.07,103.88 178.97,103.88 178.84,104.01 178.84,104.26 178.97,104.38 179.19,104.38 179.32,104.51 179.32,104.77 179.19,104.89 178.97,104.89 178.84,105.02 178.84,105.46 178.53,105.77 178.27,105.77 178.15,105.9 178.15,106.16 169.92,114.38 169.92,126.09 169.04,126.97 169.04,127.75 168.9,127.89 168.9,128.25 168.77,128.38 168.59,128.38 v2(168.45,128.24)
  BOTTOM w0.102: U42.P1 168.12,128.56 v2(168.45,128.24)
  BOTTOM w0.216: v1(180.03,86.93) 179.18,87.78 179.18,88.54 179.28,88.63 JDIM2.225
M_A_DQ55: length 54.4
  IN1 w0.127: v2(168.45,127.59) 168.61,127.42 168.79,127.25 168.79,126.69 169.54,125.93 169.54,114.23 177.74,106.03 177.74,105.44 177.87,105.31 178.31,105.31 178.46,105.16 178.46,104.93 178.34,104.81 177.81,104.81 177.68,104.68 177.68,104.43 177.81,104.3 178.33,104.3 178.46,104.16 178.46,103.92 178.34,103.79 177.87,103.79 177.74,103.66 177.74,100.25 177.87,100.12 178.14,100.12 178.27,100 178.27,99.74 178.14,99.62 177.87,99.62 177.74,99.49 177.74,97.14 177.87,97.01 178.14,97.01 178.27,96.89 178.27,96.63 178.14,96.51 177.82,96.51 177.69,96.38 177.69,96.13 177.76,96.06 177.82,96 178.14,96 178.27,95.87 178.27,95.62 178.14,95.49 177.87,95.49 177.74,95.36 177.74,94.99 177.87,94.86 178.16,94.86 178.25,94.77 178.25,94.48 178.1,94.33 178.1,94.15 179.53,92.72 179.53,91.95 179.66,91.82 179.99,91.82 180.14,91.68 180.14,91.27 179.98,91.1 179.67,91.1 179.54,90.97 179.54,90.72 179.67,90.59 180.01,90.59 180.14,90.47 180.14,90.21 180.01,90.08 179.74,90.08 179.61,89.95 179.61,89.7 179.74,89.58 179.98,89.58 180.1,89.45 v1(180.1,88.26)
  BOTTOM w0.102: U42.N2 169.16,128.88 169.16,128.31 v2(168.45,127.59)
  BOTTOM w0.216: v1(180.1,88.26) 180.28,88.43 JDIM2.229
M_A_DQ56: length 57.6
  IN1 w0.127: v2(169.98,129.54) 171.95,127.57 171.95,125.44 172.45,124.94 172.45,121.35 171.91,120.81 171.91,115.17 181.38,105.7 181.38,105.28 181.51,105.15 181.88,105.15 182.01,105.03 182.01,104.77 181.88,104.65 181.51,104.65 181.38,104.52 181.38,101.35 181.8,100.93 181.8,94.96 181.68,94.83 181.4,94.83 181.27,94.7 181.27,94.45 181.4,94.32 181.68,94.32 181.8,94.2 181.8,93.9 182.97,92.74 182.97,86.53 181.53,85.09 181.53,84.28 181.71,84.1 v1(182,84.1)
  BOTTOM w0.102: U42.L3 169.66,129.86 v2(169.98,129.54)
  BOTTOM w0.216: JDIM2.232 181.03,83.13 v1(182,84.1)
M_A_DQ57: length 58.9
  IN1 w0.127: v1(183.77,86.22) 183.35,86.65 183.35,89.56 183.47,89.68 183.66,89.68 183.79,89.81 183.79,90.07 183.66,90.19 183.47,90.19 183.35,90.32 183.35,90.57 183.47,90.7 183.66,90.7 183.79,90.83 183.79,91.08 183.66,91.21 183.47,91.21 183.35,91.34 183.35,91.59 183.47,91.72 183.66,91.72 183.69,91.74 183.79,91.84 183.79,92.1 183.66,92.22 183.47,92.22 183.35,92.35 183.35,92.89 182.24,94 182.24,103.01 182.37,103.13 182.74,103.13 182.87,103.26 182.87,103.5 182.72,103.65 181.89,103.65 181.76,103.77 181.76,104.02 181.89,104.15 182.56,104.15 182.69,104.28 182.69,104.93 172.29,115.33 172.29,120.65 172.83,121.2 172.83,125.1 172.34,125.6 172.34,127.78 169.98,130.13 v2(169.98,130.19)
  BOTTOM w0.102: U42.L4 169.66,130.51 v2(169.98,130.19)
  BOTTOM w0.216: v1(183.77,86.22) 183.5,86.22 182.28,87.45 JDIM2.237
M_A_DQ58: length 56.1
  IN1 w0.127: v2(169.98,128.24) 170.74,128.24 171.57,127.41 171.57,125.28 172.07,124.78 172.07,121.51 171.52,120.96 171.52,115.02 180.89,105.64 180.89,96.99 181.02,96.86 181.3,96.86 181.42,96.73 181.42,96.48 181.3,96.35 181.02,96.35 180.89,96.23 180.89,95.97 181.02,95.85 181.3,95.85 181.42,95.72 181.42,95.46 181.3,95.34 181.02,95.34 180.89,95.21 180.89,94.27 182.58,92.58 182.58,86.69 181.15,85.25 181.15,83.61 v1(182.03,82.74)
  BOTTOM w0.102: U42.K1 170.17,128.24 v2(169.98,128.24)
  BOTTOM w0.216: v1(182.03,82.74) JDIM2.236
M_A_DQ59: length 56.8
  IN1 w0.127: v1(181.78,87.62) 181.86,87.55 182.08,87.55 182.16,87.63 182.2,87.67 182.2,88.84 182.11,88.93 181.91,88.93 181.79,89.06 181.79,89.41 181.91,89.54 182.08,89.54 182.2,89.66 182.2,89.92 182.08,90.05 181.91,90.05 181.79,90.17 181.79,90.43 181.91,90.55 182.08,90.55 182.2,90.68 182.2,90.93 182.08,91.06 181.91,91.06 181.79,91.19 181.79,91.44 181.91,91.57 182.08,91.57 182.2,91.7 182.2,91.95 182.08,92.08 181.91,92.08 181.79,92.2 181.79,92.79 180.51,94.06 180.51,94.56 180.38,94.69 179.97,94.69 179.84,94.82 179.84,95.07 179.97,95.2 180.38,95.2 180.51,95.33 180.51,95.58 180.38,95.71 179.97,95.71 179.84,95.83 179.84,96.09 179.97,96.21 180.38,96.21 180.51,96.34 180.51,96.7 180.22,96.99 180.22,97.11 180.51,97.4 180.51,99.71 180.38,99.83 180.38,100.27 180.51,100.4 180.51,105.49 171.12,114.88 171.12,121.88 171.25,122.01 171.56,122.01 171.69,122.14 171.69,122.39 171.56,122.52 171.25,122.52 171.12,122.65 171.12,122.9 171.25,123.03 171.56,123.03 171.69,123.15 171.69,123.41 171.56,123.54 171.25,123.54 171.12,123.66 171.12,123.92 171.25,124.04 171.56,124.04 171.69,124.17 171.69,124.42 171.56,124.55 171.25,124.55 171.12,124.68 171.12,126.58 170.86,126.84 170.86,127.02 171.05,127.21 171.05,127.39 170.88,127.56 170.68,127.56 170.39,127.28 170.21,127.28 169.98,127.51 v2(169.98,127.59)
  BOTTOM w0.102: U42.L1 169.41,128.38 169.41,128.22 169.41,127.72 169.54,127.59 v2(169.98,127.59)
  BOTTOM w0.216: JDIM2.233 181.28,88.11 181.77,87.62 v1(181.78,87.62)
M_A_DQ60: length 57
  IN1 w0.127: v2(171.78,130.19) 172.19,130.6 172.75,130.6 173.11,130.23 173.11,129.42 175.08,127.46 175.08,125.36 181.33,119.12 181.33,109.6 186.1,104.82 186.1,100.08 185.88,99.86 185.88,97.11 186.3,96.69 186.3,86.66 185.9,86.26 185.9,83.06 v1(185.53,82.69)
  BOTTOM w0.102: U42.H4 171.46,130.51 171.58,130.39 v2(171.78,130.19)
  BOTTOM w0.216: JDIM2.250 v1(185.53,82.69)
M_A_DQ61: length 57
  IN1 w0.127: v2(171.78,129.54) 172.76,128.56 172.9,128.56 174.32,127.14 174.32,124.45 174.73,124.04 175.32,124.04 177.2,122.17 177.2,121.57 177.65,121.12 178.24,121.12 180.57,118.8 180.57,115.44 180.2,115.08 180.2,114.7 180.04,114.54 180.04,114.19 180.2,114.03 180.2,113.68 180.04,113.52 180.04,113.17 180.2,113.02 180.2,112.67 180.04,112.51 180.04,112.16 180.2,112 180.2,111.65 180.04,111.49 180.04,111.14 180.2,110.98 180.2,110.63 180.04,110.48 180.04,110.13 180.2,109.97 180.2,109.65 184.69,105.15 184.69,99.83 184.43,99.57 184.43,96.79 184.89,96.33 185.37,96.33 185.49,96.2 185.49,95.95 185.37,95.82 184.89,95.82 184.76,95.69 184.76,95.44 184.89,95.31 185.37,95.31 185.49,95.18 185.49,94.93 185.37,94.8 184.77,94.8 184.62,94.65 184.62,94.42 184.74,94.29 185.37,94.29 185.54,94.12 185.54,87.33 v1(185.04,86.83)
  BOTTOM w0.102: v2(171.78,129.54) 171.46,129.86 U42.H3
  BOTTOM w0.216: v1(185.04,86.83) 184.28,87.6 JDIM2.245
M_A_DQ62: length 55.3
  IN1 w0.127: v2(172.73,128.17) 173.94,126.96 173.94,123.46 174.21,123.19 174.39,123.19 174.71,123.52 174.89,123.52 175.07,123.34 175.07,123.16 174.75,122.83 174.75,122.65 174.93,122.47 175.11,122.47 175.43,122.8 175.61,122.8 175.79,122.62 175.79,122.44 175.46,122.12 175.46,121.94 175.73,121.67 175.91,121.67 176.24,121.99 176.42,121.99 176.6,121.81 176.6,121.63 176.27,121.31 176.27,121.13 176.66,120.74 178.09,120.74 180.18,118.64 180.18,115.6 180.17,115.59 179.66,115.08 179.66,109.65 184.31,104.99 184.31,99.99 184.05,99.73 184.05,97.23 183.92,97.11 183.68,97.11 183.55,96.98 183.55,96.72 183.68,96.6 184,96.6 184.12,96.47 184.12,96.22 184,96.09 183.69,96.09 183.55,95.95 183.55,95.71 183.68,95.58 184,95.58 184.12,95.45 184.12,95.2 184,95.07 183.69,95.07 183.55,94.94 183.55,94.69 183.68,94.57 184,94.57 184.12,94.44 184.12,94.13 185.12,93.13 v1(185.12,88.19)
  BOTTOM w0.102: U42.H1 171.7,128.26 172.64,128.26 v2(172.73,128.17)
  BOTTOM w0.216: JDIM2.249 185.28,88.35 v1(185.12,88.19)
M_A_DQ63: length 56.7
  IN1 w0.127: v1(185.47,84.04) 185.47,86.36 185.92,86.82 185.92,96.53 185.5,96.95 185.5,100.01 185.72,100.24 185.72,104.66 180.93,109.45 180.93,110.06 180.81,110.19 180.71,110.19 180.58,110.31 180.58,110.57 180.71,110.7 180.81,110.7 180.93,110.82 180.93,111.08 180.81,111.2 180.71,111.2 180.58,111.33 180.58,111.58 180.71,111.71 180.81,111.71 180.93,111.84 180.93,112.09 180.81,112.22 180.71,112.22 180.58,112.35 180.58,112.6 180.71,112.73 180.81,112.73 180.93,112.85 180.93,113.11 180.81,113.24 180.71,113.24 180.58,113.36 180.58,113.62 180.71,113.74 180.81,113.74 180.93,113.87 180.93,114.12 180.81,114.25 180.71,114.25 180.58,114.38 180.58,114.63 180.71,114.76 180.81,114.76 180.95,114.9 180.95,118.96 174.7,125.2 174.7,127.3 172.97,129.03 v2(172.85,129.03)
  BOTTOM w0.102: v2(172.85,129.03) 172.35,129.03 U42.G2
  BOTTOM w0.216: v1(185.47,84.04) 184.53,83.1 JDIM2.246
