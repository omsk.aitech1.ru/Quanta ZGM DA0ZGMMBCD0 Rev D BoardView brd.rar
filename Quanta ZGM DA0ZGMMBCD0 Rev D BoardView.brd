# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND_FET: length 12.3
  TOP w0.14: PU2.9 231.94,210.58 232.2,210.32 232.2,209.28 232.73,208.75 PR67.1 232.73,208.24 232.97,208 232.97,207.33 232.5,206.85 v1(231.92,206.85) 231.5,206.85 PR83.1 ; v1(227.33,206.53) 227.59,206.8 PR75.1
  IN1 w0.086: v1(227.33,206.53) 227.33,206.66 227.84,207.18 231.01,207.18 231.33,206.85 v1(231.92,206.85)
GNDMS_SENSE: length 4.6
  BOTTOM w0.102: RG139.1 221.11,125.11 223.01,127.01 223.01,127.88 UG6.BR49
VCC3V3_FLASH: length 12.7
  TOP w0.254: R446.2 v1(33.15,67.07) ; v1(30.23,67.17) R443.2 ; R473.2 v1(35.74,65.65) ; R236.1 51.69,83.12 v1(51.69,83.12) ; v1(40.12,82.9) 40.23,83.01 R242.2 ; v1(30.71,65.67) 30.71,65.96 30.51,66.16 R468.2 ; v1(36.19,82.9) 36.19,83.21 35.96,83.43 R244.2 ; R220.2 R219.2 36.83,84.54 v1(36.99,84.39) ; R217.2 34.8,84.63 v1(35.04,84.39) ; R233.1 R234.1 v1(50.04,83.02) ; v1(32.34,67.12) 32.26,67.2 R445.2
  BOTTOM w0.254: v1(36.99,84.39) 36.73,84.39 36.07,85.05 R866.2 R867.2 R874.2
  vias: v1(44.94,81.7) v1(45.87,82.2) v1(45.85,81.52) v1(52.17,98.39) v1(52.17,97.63) v1(52.81,98.01)
VCC3V3_FLASH_PD: length 2.1
  TOP w0.381: v1(64.23,83.67) 64.14,83.76 R230.2 ; R231.2 65.79,83.94 v1(65.52,83.67) ; R175.2 v1(65.41,93.18)
  vias: v1(63.17,76.87) v1(64.25,76.63) v1(65.77,85.15) v1(68.68,76.62)
VCC_AUX_SENSE: length 1.6
  TOP w0.102: v2(165.81,149.69) 165.81,149.57 165.97,149.42 166.09,149.42 166.4,149.72 PR116.2
  BOTTOM w0.203: U42.U34 165.89,149.69 v2(165.81,149.69)
VCC_AUX_SENSE_SRC: length 2.7
  BOTTOM w0.14: PR644.1 241.74,45.53 241.81,45.45 241.81,45.23 241.96,45.08 PR645.1 242.19,44.73 242.2,44.73 PU39.16
VCC_PCH_AUX_SENSE: length 41.7
  TOP w0.14: v1(239.94,53.95) 239.94,53.93 239.73,53.73 239.73,52.27 239.63,52.17 239.63,51.33 243.92,47.04 243.92,46 243.45,45.53 242.93,45.53 v1(242.83,45.43)
  IN2 w0.089: v1(215.85,59.6) 216.19,59.6 216.94,58.84 216.94,57.67 218.14,56.47 223.16,56.47 223.8,57.11 228.1,57.11 229.33,55.88 230.12,55.88 230.29,56.05 232.46,56.05 232.61,55.9 232.75,55.9 233.17,55.47 238.09,55.47 238.98,54.58 239.47,54.58 239.68,54.37 239.68,54.21 v1(239.94,53.95)
  BOTTOM w0.102: U49.AH39 215.13,60.32 v1(215.85,59.6)
  BOTTOM w0.14: v1(242.83,45.43) 242.73,45.53 PR645.2 242.2,45.54 242.2,45.65 242.26,45.72 PR638.1
VCCAUX_VID0: length 253.7
  TOP w0.14: PR52.1 164.56,210.71 164.39,210.87 v1(164.39,211.21) 164.39,211.49 164,211.89 164,212.92 164.18,213.09 164.44,213.09 164.76,213.42 164.76,213.87 164.4,214.23 163.55,214.23 163.33,214.45 PR21.2 163.33,214.9 163.19,215.04 162.93,215.04 162.79,214.9 PR22.1 ; v1(245.14,37.73) 244.15,37.73 242.91,38.97 242.91,44.37 244.18,45.64 244.54,45.64 245.29,46.38 245.29,49.38 243.74,50.93 240.92,50.93 v1(240.24,51.61)
  IN2 w0.089: v1(170.82,167.54) 170.5,167.23 170.5,166.32 169.97,165.79 169.97,162 176.99,154.97 176.99,152.5 182.31,147.18 182.31,125.02 196.79,110.54 198.09,110.54 200.4,108.23 200.4,106.27 203.25,103.42 203.25,101.6 203.66,101.19 206.44,101.19 206.86,100.77 206.86,97.95 v1(208.11,96.7)
  IN3 w0.089: v1(164.39,211.21) 164.8,211.62 165.48,211.62 166.5,210.61 167.48,210.61 170.21,207.88 170.21,206.44 171.49,205.16 171.49,203.57 172.55,202.51 172.55,201.25 173.66,200.14 173.66,194.48 175.83,192.3 175.83,191.67 175.48,191.31 175.48,187.61 176.7,186.39 176.7,181.35 176.92,181.12 176.92,177.52 177.66,176.78 177.66,175.44 176.99,174.77 176.99,173.54 172.51,169.05 171.75,169.05 171.52,168.82 171.42,168.82 170.82,168.22 v1(170.82,167.54) ; v1(217.09,75.02) 218.19,76.12 218.19,80.7 220.18,82.69 220.59,82.69 221.17,83.27 221.33,83.44 221.33,83.95 221.06,84.23 216.8,84.23 216.18,84.85 216.18,85.69 216,85.87 215.36,85.87 215.03,86.19 213.92,87.3 213.92,93.06 210.93,96.04 208.76,96.04 v1(208.11,96.7)
  IN4 w0.086: v1(234.42,73.46) 233.52,74.36 233.32,74.36 231.11,76.57 228.34,76.57 227.1,77.81 224.31,77.81 222.18,75.69 220.81,75.69 220.66,75.83 219.55,75.83 218.63,74.92 217.19,74.92 v1(217.09,75.02)
  BOTTOM w0.102: U49.AN11 217.43,74.68 v1(217.09,75.02)
  BOTTOM w0.14: PR658.1 PR665.2 PR666.1 244.57,37.16 v1(245.14,37.73) ; v1(234.42,73.46) 234.52,73.35 234.52,72.2 234.37,72.04 234.37,67.3 234.26,67.19 234.26,64.1 233.85,63.68 233.85,61.21 234.62,60.44 234.62,57.38 236.71,55.3 237.96,55.3 238.43,54.82 238.43,53.42 v1(240.24,51.61)
VCCAUX_VID1: length 260.5
  TOP w0.14: PR27.1 162.79,213.99 162.93,214.13 163.19,214.13 163.33,213.99 PR28.2 163.33,213.69 163.7,213.32 163.7,211.24 v1(163.68,211.21) 163.88,211.01 PR51.1 ; v1(245.8,37.71) 245.8,37.85 245.46,38.2 244.08,38.2 243.19,39.08 243.19,44.27 244.29,45.37 244.65,45.37 245.61,46.33 245.61,49.77 243.55,51.83 v1(242.31,51.83) 241.25,51.83 v1(241.02,51.6)
  IN2 w0.089: v1(208.76,96.69) 208.13,97.32 207.79,97.32 207.07,98.04 207.07,100.86 206.53,101.4 203.76,101.4 203.47,101.7 203.47,103.51 200.61,106.36 200.61,108.32 198.18,110.75 196.88,110.75 182.53,125.11 182.53,147.27 177.21,152.59 177.21,155.06 170.18,162.09 170.18,165.7 170.84,166.36 170.84,166.68 v1(171.4,167.23)
  IN3 w0.089: v1(163.68,211.21) 164.32,211.85 165.59,211.85 166.6,210.83 167.56,210.83 170.42,207.97 170.42,206.53 171.7,205.25 171.7,203.66 172.76,202.6 172.76,201.34 173.87,200.23 173.87,194.57 176.05,192.39 176.05,191.58 175.69,191.22 175.69,187.7 176.91,186.48 176.91,181.44 177.14,181.21 177.14,177.61 177.88,176.87 177.88,175.35 177.21,174.68 177.21,173.45 171.77,168.01 171.77,167.6 v1(171.4,167.23) ; v1(208.76,96.69) 208.71,96.64 208.71,96.4 208.85,96.26 211.02,96.26 214.14,93.15 214.14,87.39 215.43,86.09 216.08,86.09 216.4,85.78 216.4,84.94 216.89,84.44 221.15,84.44 221.55,84.04 221.55,83.35 220.91,82.7 220.91,81.6 v1(221.52,80.99)
  IN4 w0.086: v1(221.52,80.99) 221.52,80.13 219.55,78.16 217.71,78.16 216.96,77.42 216.96,76.47 216.49,76 216.49,74.97 216.89,74.56 217.68,74.56 217.82,74.7 218.72,74.7 219.64,75.62 220.57,75.62 220.72,75.48 222.27,75.48 223.01,76.21 224.4,77.6 227.01,77.6 228.25,76.36 231.02,76.36 233.23,74.15 233.43,74.15 233.99,73.59 233.99,73.32 234.32,72.99 234.62,72.99 v1(235,72.61)
  BOTTOM w0.102: v1(221.52,80.99) 221.21,80.68 220.2,80.68 219.88,80.36 219.88,79.92 219.96,79.84 219.96,79.32 219.42,78.79 219.42,78.12 U49.AT4
  BOTTOM w0.14: PR659.1 244.48,37.74 244.99,38.24 245.43,38.24 245.8,37.87 v1(245.8,37.71) 246.04,37.47 PR664.2 PR663.1 ; v1(241.02,51.6) 240.43,52.2 240.03,52.2 238.81,53.42 238.81,54.94 238.16,55.59 237.25,55.59 234.89,57.95 234.89,60.55 234.12,61.32 234.12,63.57 234.53,63.98 234.53,67.08 234.64,67.19 234.64,71.5 234.88,71.75 234.88,72.49 v1(235,72.61)
VCCGPPA_1P8V_3V3: length 25.3
  TOP w0.203: v1(218.53,65.79) 218.55,65.8 C451.2
  TOP w0.254: v1(201.32,62.47) 201,62.15 199,62.15 R511.2 R498.2
  IN3 w0.254: v1(218.53,65.79) 218.05,65.3 216.88,65.3 215.8,64.22 214.81,64.22 214.14,63.55 214.14,62.82 213.89,62.56 212.92,62.56 212.78,62.43 212.33,62.43 212.2,62.56 211.67,62.56 211.19,62.08 209.38,62.08 208.77,62.7 206.89,62.7 206.63,62.44 205.24,62.44 204.63,63.06 201.9,63.06 v1(201.32,62.47)
  BOTTOM w0.254: v1(218.53,65.79) 218.13,65.38 U49.AP29
VCCIN_AUX_HWPG: length 209.6
  TOP w0.14: D39.1 156.59,68.29 v1(156.44,68.14) ; PR85.1 161.7,206.64 161.42,206.92 160.51,206.92 v1(160.17,206.59)
  IN1 w0.086: v1(186.16,169.08) 183.82,171.41 169.49,171.41 167.15,173.75 167.15,175.03 v1(166.12,176.06)
  IN3 w0.089: v1(154.27,74.84) 154.67,75.24 160.24,75.24 161.1,74.38 164.69,74.38 167.74,77.43 172.49,77.43 172.97,76.95 172.97,76.02 172.51,75.57 172.51,74.92 172.09,74.5 172.09,74.34 172.4,74.03 172.95,74.03 173.1,74.18 173.1,75.32 173.55,75.78 173.55,76.94 174.22,77.61 182.14,77.61 183.22,76.52 184.52,76.52 185.64,75.41 187.67,75.41 191.7,79.44 191.7,89.16 192.26,89.72 192.26,96.41 192.72,96.87 192.72,103.06 189.91,105.88 189.91,108.74 188.41,110.24 188.41,151.7 187.53,152.57 187.53,162.1 185.84,163.8 185.84,168.65 186.16,168.97 v1(186.16,169.08) ; v1(166.12,176.06) 166.33,176.27 166.33,179.58 164.51,181.4 164.51,185.09 164.61,185.19 164.61,195.72 160.61,199.72 160.61,201.16 160.25,201.52 160.25,205.07 159.74,205.58 159.74,206.15 v1(160.17,206.59)
  BOTTOM w0.14: v1(156.44,68.14) 154.27,70.31 v1(154.27,74.84)
VCCIN_AUX_PCH_HWPG: length 123.8
  TOP w0.14: D40.1 155.66,66.87 155.16,66.36 154.41,66.36 153.42,67.35 152.87,67.35 149.96,64.44 149.77,64.44 148.68,63.35 v1(148.68,62.47)
  IN2 w0.089: v1(239.52,36.6) 239.21,36.3 235.26,36.3 234.4,37.15 227.68,37.15 224.23,40.61 221.26,40.61 219.8,39.15 209.37,39.15 209.09,39.43 205.82,39.43 205.77,39.48 202.2,39.48 201.73,39.95 196.15,39.95 195.9,39.71 190.06,39.71 189.76,40 188.17,40 186.84,41.34 186.84,42.94 185.6,44.17 183.9,44.17 179.86,48.21 179.86,49.88 178.06,51.68 170.66,51.68 170.31,52.03 170.31,53.56 170.04,53.83 169.62,53.83 169.43,53.64 163.44,53.64 v1(161.96,55.12)
  BOTTOM w0.14: v1(161.96,55.12) 161.11,55.97 156.49,55.97 155.82,55.29 151.36,55.29 147.71,58.95 147.71,62.39 147.85,62.53 148.62,62.53 v1(148.68,62.47)
  BOTTOM w0.203: v1(239.52,36.6) 239.52,37.19 PR660.1
VCCRTC_4:
  vias: v1(212.73,47.08)
VCCSENSE: length 94.7
  TOP w0.14: v1(115.59,166.57) 115.37,166.79 113.41,166.79 110.17,170.03 110.17,193.62 112.56,196.01 112.56,199.74 113.76,200.94 113.76,205.13 114.41,205.78 121.54,205.78 121.79,205.52 123.22,205.52 123.48,205.78 125.01,205.78 126.77,207.54 126.77,213.89 126.91,214.03 126.91,214.18 126.67,214.42 126.67,214.57 126.85,214.74 PR19.1
  IN2 w0.089: v1(115.59,166.57) 115.59,166.73 115.68,166.82 116,166.82 116.96,165.86 116.96,163.27 123.79,156.44 135.08,156.44 v1(135.33,156.19)
  BOTTOM w0.102: 134.87,154.34 134.87,153.59 U42.CE40
  BOTTOM w0.203: v1(135.33,156.19) 135.34,156.19 135.69,155.84 135.69,155.39 134.87,154.57 134.87,154.34
VCCST_DIS1: length 15.6
  BOTTOM w0.14: Q88.5 206,184.35 206.14,184.49 206.51,184.49 206.65,184.35 Q88.6 207.53,183.9 207.95,183.48 207.95,182.9 v1(207.59,182.54) 207.59,180.49 207.9,180.18 208.16,180.18 208.54,179.79 209.93,179.79 210.19,179.54 210.19,176.24 208.76,174.81 R750.2 R749.1
VCCST_EN_1: length 13.8
  TOP w0.14: v1(208.79,179.16) 206.63,181.32 205.41,181.32 204.22,182.51 204.22,182.97 204.12,183.07 C38.1 204.12,183.87 204.08,183.92 U3.4
  BOTTOM w0.14: Q91.2 208.84,179.11 v1(208.79,179.16) 208.66,179.16 208.03,179.79 207.78,179.79 207.01,180.56 207.01,181.19 206.63,181.57 206.25,181.57 206,181.83 Q88.2
VCCST_OVERRIDE: length 254
  TOP w0.14: v1(209.78,180.3) 210.32,180.3 210.7,180.68 210.7,181.45 210.82,181.57 R78.1 ; v1(192.06,165.33) 192.06,166.22 193.76,167.92 193.76,178.21 v1(196.47,180.92)
  IN1 w0.086: v1(209.78,180.3) 207.52,182.56 207.24,182.56 206.15,183.66 199.7,183.66 198.48,182.44 198.48,181.6 197.8,180.92 v1(196.47,180.92) ; v1(120.23,142.71) 120.23,154.9 116.87,158.26 116.87,167.88 v1(115.6,169.14)
  IN2 w0.089: v1(196.27,105.95) 196.27,105.21 198.16,103.31 198.56,103.31 199.68,102.2 200.69,102.2 201.13,101.76 201.13,99.83 201.46,99.5 201.46,95.18 203.42,93.22 203.42,89.64 203.48,89.57 203.48,88.43 206.46,85.45 v1(206.76,85.45)
  IN3 w0.089: v1(196.27,105.95) 197.32,107.01 197.32,107.61 197.6,107.89 197.6,110.98 193.68,114.9 193.68,134.16 191.83,136.01 191.83,153.08 190.96,153.95 190.96,164.23 v1(192.06,165.33)
  IN4 w0.086: v1(115.6,169.14) 115.6,170.17 118.48,173.05 153.14,173.05 153.81,173.72 170.44,173.72 172.67,175.95 174.11,175.95 174.55,176.38 174.85,176.38 175.24,176.77 176.17,176.77 176.66,177.26 177.93,177.26 178.66,176.52 182.92,176.52 183.77,175.67 191.5,175.67 196.47,180.65 v1(196.47,180.92)
  BOTTOM w0.102: 208.8,82.84 209.17,82.47 209.17,82.34 210.75,80.76 211.46,80.76 211.76,80.46 211.76,79.58 212.6,78.75 212.6,78.74 212.9,78.43 U49.AD4
  BOTTOM w0.14: v1(206.76,85.45) 206.76,84.89 208.8,82.84 ; R806.2 120.95,141.36 120.95,142.17 120.4,142.71 v1(120.23,142.71)
VCCST_OVERRIDE_EN: length 15.3
  TOP w0.14: 204.73,188.3 U3.2 ; 204.73,188.3 203.84,189.19 202.7,189.19 201.17,187.67 U2.2 ; 204.73,188.3 204.85,188.43 204.85,189.24 205.18,189.57 205.92,189.57 v1(206.91,188.58) 207.15,188.35 Q14.3 207.16,184.92 206.7,184.46 R75.1
VCCSTG_EN_2: length 5.7
  TOP w0.254: v1(202.72,181.93) 202.31,181.93 v1(201.92,182.32) v1(201.25,183)
  BOTTOM w0.254: Q87.2 201.53,185.89 201.78,185.64 201.78,184.98 201.6,184.79 201.6,183.6 201.25,183.25 v1(201.25,183)
VCCSTPWRGOOD_TCSS: length 19.3
  TOP w0.14: v2(130.44,143.65) 127.35,143.65 126.42,142.73 120.88,142.73 120.43,143.18 119.96,143.18 119.81,143.03 v1(119.5,143.03)
  BOTTOM w0.125: U42.CP23 129.91,143.65 130.37,143.65
  BOTTOM w0.14: R807.1 123.69,140.34 123.45,140.09 122.46,140.09 122.17,140.38 R806.1 122.17,141.43 v1(121.91,141.69) 120.42,143.18 119.81,143.18 119.66,143.03 v1(119.5,143.03) ; 130.37,143.65 v2(130.44,143.65)
VDD1V8: length 1.1
  TOP w0.203: U21.13 299.02,63.35 298.92,63.46 298.62,63.46 v1(298.48,63.32)
  vias: v1(299.13,63.81)
VDDMS_SENSE: length 6.8
  BOTTOM w0.102: UG6.BP49 223.15,128.5 223.29,128.36 223.95,128.36 224.21,128.11 224.21,126.18 222.34,124.31 222.34,123.93 222.23,123.82 RG140.1
VSS_AUX_SENSE: length 2.8
  TOP w0.102: PR117.2 166.85,149.59 166.56,149.59 166.16,149.19 v2(166.16,148.21)
  BOTTOM w0.203: v2(166.16,148.21) 166.19,148.25 U42.U33
VSS_AUX_SENSE_SRC: length 2.1
  BOTTOM w0.14: PR646.1 243.26,45.08 242.6,44.41 PU39.17
VSS_GPU_SENSE: length 159.4
  TOP w0.127: v1(269.71,77.09) 269.42,76.8 269.21,76.8 PR207.2
  IN1 w0.127: v1(200.49,109.13) 200.69,109.34 200.69,110.2 206.45,115.97 206.45,120.47 v1(206.16,120.76)
  IN4 w0.127: v1(269.71,77.09) 269.71,77.04 269.98,76.77 270.19,76.77 270.46,76.5 270.46,75.78 268.26,73.57 267.64,73.57 266.58,72.51 262.64,72.51 262.17,72.04 257.19,72.04 256.36,72.86 254.86,72.86 254.18,73.54 254.18,75 253.75,75.43 253.22,75.43 252.45,76.2 252.45,77.74 250.47,79.72 236.54,79.72 233.51,82.76 233.51,84.5 232.42,85.59 226.36,85.59 226.08,85.87 223.78,85.87 222.69,84.77 217.75,84.77 216.59,83.61 216.59,82.26 215.7,81.37 215.7,80.38 214.45,79.13 211.03,79.13 209.82,80.34 209.82,81.35 205.72,85.45 205.72,86.32 203.51,88.53 203.51,93.25 206.36,96.1 210.22,96.1 210.42,95.9 211.41,95.9 212.15,96.64 212.15,97.7 209.7,100.15 207.93,100.15 205.97,102.1 205.19,102.1 204.7,102.59 204.7,103.61 203.03,105.29 203.03,107.28 202.04,108.27 201.13,108.27 200.85,108.55 200.85,108.8 200.52,109.13 v1(200.49,109.13)
  BOTTOM w0.102: UG6.BR48 223.52,127.69 223.52,127.09 221.49,125.06 221.49,124.13 221.18,123.82 RG139.2
  BOTTOM w0.127: v1(206.16,120.76) 206.45,121.05 206.45,121.81 208.31,123.66 220.96,123.66 RG139.2
VSS_PCH_AUX_SENSE: length 41.8
  TOP w0.14: v1(242.88,46.17) 242.88,46.03 243.1,45.8 243.34,45.8 243.65,46.11 243.65,46.93 239.36,51.22 239.36,52.28 239.46,52.38 239.46,53.73 239.27,53.92 v1(239.27,53.95)
  IN2 w0.089: v1(216.19,59.03) 216.49,59.03 216.75,58.76 216.75,57.59 218.07,56.28 223.24,56.28 223.88,56.92 228.02,56.92 229.25,55.69 230.19,55.69 230.36,55.86 232.38,55.86 232.53,55.71 232.67,55.71 233.09,55.28 238.01,55.28 238.9,54.39 239.39,54.39 239.49,54.29 239.49,54.17 v1(239.27,53.95)
  BOTTOM w0.102: v1(216.19,59.03) 215.61,59.03 215.45,59.2 215.45,59.71 215.28,59.88 215.14,59.88 215.07,59.81 215.07,59.62 U49.AH41
  BOTTOM w0.14: v1(242.88,46.17) 242.9,46.19 243.36,46.19 PR636.1 243.7,46.09 243.82,45.97 243.82,45.63 243.73,45.53 PR646.2
VSSSENSE: length 94.7
  TOP w0.14: v1(115.6,167.21) 115.44,167.06 113.52,167.06 110.44,170.14 110.44,193.51 112.82,195.9 112.82,199.62 114.02,200.83 114.02,205.02 114.52,205.51 121.43,205.51 121.68,205.26 123.33,205.26 123.59,205.51 125.12,205.51 127.04,207.42 127.04,213.78 127.17,213.92 127.17,215.25 126.85,215.57 PR12.1
  IN2 w0.089: v1(136.12,156) 135.49,156.63 123.87,156.63 117.15,163.35 117.15,165.94 116.61,166.48 116.08,167.01 115.8,167.01 v1(115.6,167.21)
  BOTTOM w0.203: U42.CE41 135.18,154.44 135.99,155.26 135.99,155.87 v1(136.12,156)
1P35V_BOOT: length 2.5
  BOTTOM w0.178: PU38.18 118.62,45.58 118.75,45.45 119.26,45.45 119.5,45.69 PR637.2
1P35V_CS: length 2.9
  BOTTOM w0.14: PR625.2 v1(117.57,48.82)
  BOTTOM w0.203: PU38.13 116.23,47.67 116.61,48.05 PR625.2
1P35V_FB: length 3.6
  BOTTOM w0.178: PU38.6 114.24,44.78
  BOTTOM w0.203: 114.24,44.78 113.97,44.51 113.97,44.38 113.34,43.75 PR650.1 113.34,42.4 113.14,42.2 PR654.2
1P35V_LGATE: length 9.9
  IN1 w0.635: v3(125.5,49.17) 124.41,48.07 v3(118.01,48.07)
  BOTTOM w0.14: v1(118.88,49.11) 118.62,48.86 118.62,48.73 118.09,48.2
  BOTTOM w0.635: PQ67.8 125.5,48.46 v3(125.5,49.17)
1P35V_PGOOD: length 2.5
  BOTTOM w0.178: PU38.10 114.22,46.38
  BOTTOM w0.203: 114.22,46.38 114.05,46.56 v1(114.05,47.33) 113.57,47.82 PR630.1
1P35V_PHASE: length 16.6
  TOP w0.635: PR339.1 129.43,43.26 v1(127.54,45.15)
  IN1 w0.635: v1(127.54,45.15) 123.47,45.15 121.44,47.18 v1(118.77,47.18)
  BOTTOM w0.203: PC500.1 119.23,48.2 118.77,47.74 v1(118.77,47.18)
1P35V_S3: length 6.2
  BOTTOM w0.203: PU38.7 113.79,45.18 113.63,45.02 PR647.1 113.28,44.35 112.87,43.94 112.47,43.94 112.27,43.74 112.27,43.34 112.05,43.12 PR649.1 111.81,42.81 111.92,42.71 PC510.1 111.53,42.36 111.31,42.58 PR651.2
1P35V_S5: length 8.2
  BOTTOM w0.203: PR649.2 111.03,43.57 110.64,43.95 v1(110.64,44.86) 110.97,45.18 PC505.1 112.09,45.41 112.09,45.98 ; 112.09,45.98 112.53,45.54 113.85,45.54 113.9,45.58 PU38.8 ; 112.09,45.98 PR639.2 PR632.2
1P35V_TON: length 1.8
  BOTTOM w0.203: PR635.2 113.55,46.16 113.72,45.98 PU38.9
1P35V_UGATE: length 11.1
  TOP w0.14: v3(126.77,42.86) v1(126.77,43.65)
  IN1 w0.635: v3(118.97,45.98) 120.76,45.98 123.88,42.86 v3(126.77,42.86)
  BOTTOM w0.635: PQ67.1 125.56,42.86 v3(126.77,42.86)
1P35V_VDD: length 4.6
  BOTTOM w0.203: PU38.12 115.83,47.76 115.94,47.86 115.94,48.4 115.73,48.61 PC499.1 115.42,48.61 115.17,48.86 v1(115.17,50.15) 115.06,50.26 PR624.2
1P35V_VDDQ: length 26.2
  IN1 w0.254: v1(114.62,43.18) 113.72,43.18 113.19,43.71 113.19,47.84 112.91,48.12 112.91,49.64 115.78,52.52 v1(126.24,52.52)
  BOTTOM w0.178: PU38.5 115.43,43.64
  BOTTOM w0.203: v1(114.62,43.18) 113.95,43.18 PR650.2 114.16,43.69 114.85,43.69 115.04,43.5 115.29,43.5 115.43,43.64
  BOTTOM w0.254: PR621.2 v1(126.24,52.52)
1P35V_VID: length 2.7
  BOTTOM w0.178: PU38.11 115.43,47.54
  BOTTOM w0.203: 115.43,47.54 115.43,48.1 114.93,48.61 PR627.2 PR626.1
2ND_MBCLK: length 434.7
  TOP w0.14: R366.2 281.5,74.33 v1(281.51,74.33) ; Q37.3 v1(295.66,75.1) 296.12,75.1 296.68,75.65 297.06,75.65 v1(297.11,75.71) ; v1(280.71,68.02) 280.82,67.91 280.82,66.64 283.58,63.88 Q49.3 283.58,63.07 283.06,62.54 R506.1 ; Q20.6 67.47,92.02 67.33,91.88 67.33,91.69 68.25,90.76 R178.1 68.47,91.12 68.76,91.41 v1(69.26,91.41) ; Q40.6 319.64,74.6 319.5,74.74 v1(319.5,75.86) ; R335.1 174.89,76.84 174.89,75.85 174.4,75.35 174.4,74.67 v1(174.62,74.45) 174.71,74.36 U23.115 174.71,71.85 174.15,71.3 174.15,69.69 173.45,68.98 173.45,67.78 174.02,67.21 174.02,65.96 175.33,64.65 175.33,62.13 174.49,61.3 v1(174.49,59.85)
  IN1 w0.086: v1(69.26,91.41) 69.26,92.56 69.89,93.18 70.7,93.18 71.07,92.81 71.07,90.1 73.31,87.86 73.31,86.84 78.42,81.73 97.35,81.73 99.57,83.95 105.47,83.95 105.96,83.46 105.96,77.24 107.07,76.13 108.31,76.13 108.43,76.01 114.43,76.01 118.33,72.12 121.78,72.12 123.02,73.36 144.52,73.36 145.5,74.35 150.22,74.35 151.28,73.28 159.83,73.28 160.19,72.92 173.1,72.92 v1(174.62,74.45)
  IN2 w0.089: v1(174.49,59.85) 174.51,59.85 174.52,59.84 176.61,59.84 179.61,56.85 180.48,56.85 182.87,54.46 183.39,54.46 185.96,51.89 185.96,49.62 186.34,49.24 186.98,49.24 192.25,43.97 192.65,43.97 192.98,43.64 194.59,43.64 194.73,43.51 196.85,43.51 197.3,43.05 204.04,43.05 204.44,42.65 209.02,42.65 209.23,42.44 211.07,42.44 212.51,43.87 222.62,43.87 225.88,47.13 228.97,47.13 229.13,46.97 238.2,46.97 238.35,47.13 239.48,47.13 239.93,46.68 241.42,46.68 242.67,47.92 247.55,47.92 248.3,48.68 258.89,48.68 259.09,48.88 268.18,48.88 270.27,50.96 274.48,50.96 277.64,54.12 277.64,54.19 278.46,55.01 278.46,56.08 279.76,57.37 280.63,57.37 282.04,58.78 282.04,62.55 281.47,63.12 281.47,66.99 280.7,67.77 280.7,68.02 v1(280.71,68.02) 280.97,68.29 281.29,68.29 283.88,70.88 283.88,73.81 287.81,77.74 289.1,77.74 289.64,78.28 290.48,78.28 291.58,79.38 294.78,79.38 295.51,78.65 v1(295.51,78.45)
  IN3 w0.089: v1(174.62,74.45) 174.53,74.53 174.53,75.15 175.09,75.71 180.86,75.71 181.47,75.1 183.93,75.1 185.05,73.98 188.69,73.98 190.7,71.97 190.95,71.97 v1(190.95,71.97) ; v1(319.5,75.86) 319.5,72.91 319.13,72.53 318.93,72.53 318.2,71.81 317.9,71.81 317.61,71.51 316.79,71.51 316.23,72.07 316.23,74.56 315.82,74.98 313.63,74.98 313,75.61 310.51,75.61 309.89,74.99 309.89,73.36 307.26,70.73 302.64,70.73 301.29,72.09 301.29,76.1 299.93,77.46 297.54,77.46 296.55,78.45 v1(295.51,78.45) 295.51,77.84 296.68,76.67 296.68,76.14 v1(297.11,75.71)
  IN4 w0.086: v1(211.08,97.15) 210.97,97.26 209.68,97.26 208.71,98.23 205.88,98.23 202.37,94.72 202.37,93.82 202.36,93.82 202.36,90.36 201.73,89.73 201.73,88.62 204.6,85.74 204.6,83.23 204.26,82.89 204.26,82.17 203.75,81.66 203.75,79.74 201.53,77.52 198.8,77.52 193.3,72.03 191.04,72.03 190.99,71.97 190.95,71.97 v1(190.95,71.97)
  BOTTOM w0.14: v1(281.51,74.33) 280.6,74.33 279.5,73.23 279.5,72.7 279.08,72.28 279.08,71.61 279.78,70.91 279.78,68.95 v1(280.71,68.02) ; v1(211.08,97.15) 211.51,96.71 212.06,96.71 212.66,96.11 213.29,96.11 213.57,96.4 R833.2 213.57,96.81 212.67,97.71 Q103.3
2ND_MBCLK_DDR: length 11
  BOTTOM w0.14: R833.1 211.8,97.71 Q103.4 210.55,97.71 R827.1 210.49,97.42 210.24,97.17 209.7,97.17 208.58,98.29 208.58,99.37 209.79,100.58 v1(210.04,100.58) 210.62,101.16 211.36,101.16 211.5,101.01 U46.8
2ND_MBDATA: length 424.2
  TOP w0.14: v1(69.67,94.06) 69.27,94.45 R159.1 68.77,93.5 68.95,93.32 Q20.3 ; v1(286.88,76.22) 287.38,76.72 289.77,76.72 291.34,75.15 292.23,75.15 292.36,75.27 292.36,75.78 292.56,75.99 293.07,75.99 Q37.6 ; v1(318.88,73.04) 318.88,73.4 Q40.3 ; v1(173.86,59.74) 173.69,59.9 173.69,61.24 174.81,62.35 174.81,64.44 173.5,65.74 173.5,66.99 172.93,67.56 172.93,69.2 173.63,69.9 173.63,71.51 174.31,72.18 U23.116 174.31,74.1 v1(173.96,74.45) 174.14,74.62 174.14,75.43 174.65,75.95 174.65,76.8 R334.1 ; R381.2 281.14,73.95 281.41,73.68 v1(281.51,73.68) ; v1(284.13,60.51) 284.61,60.99 284.61,61.05 284.88,61.32 Q49.6 284.88,62.21 285.08,62.41 285.28,62.41 285.6,62.09 R507.1
  IN1 w0.086: v1(173.96,74.45) 172.9,73.39 160.38,73.39 160.02,73.75 151.47,73.75 150.41,74.81 145.31,74.81 144.32,73.83 122.83,73.83 121.59,72.58 118.52,72.58 114.63,76.48 108.62,76.48 108.5,76.6 107.27,76.6 106.43,77.43 106.43,83.66 105.67,84.42 99.37,84.42 97.16,82.2 78.61,82.2 73.78,87.04 73.78,88.05 71.54,90.29 71.54,93.01 70.9,93.65 70.07,93.65 69.67,94.05 v1(69.67,94.06)
  IN2 w0.089: v1(173.86,59.74) 174.22,59.37 176.42,59.37 179.41,56.38 180.29,56.38 182.67,53.99 183.2,53.99 185.49,51.69 185.49,49.42 186.15,48.77 186.78,48.77 192.06,43.5 192.46,43.5 192.78,43.17 194.4,43.17 195.01,42.56 195.35,42.56 195.61,42.31 202.32,42.31 203.14,41.49 206.61,41.49 206.65,41.44 210.74,41.44 212.7,43.4 222.82,43.4 226.07,46.66 228.78,46.66 228.94,46.5 238.39,46.5 238.55,46.66 239.29,46.66 239.74,46.21 241.62,46.21 242.86,47.46 247.74,47.46 248.5,48.21 256.96,48.21 257.5,47.68 267.65,47.68 270.46,50.49 274.68,50.49 278.11,53.93 278.11,53.99 278.93,54.82 278.93,55.88 279.95,56.9 280.83,56.9 282.51,58.58 282.51,59.67 283.25,60.41 284.04,60.41 v1(284.13,60.51) 284.13,60.51 283.11,61.54 283.11,62.36 281.94,63.53 281.94,68.27 284.35,70.68 284.35,73.08 285.5,74.23 285.5,74.76 286.88,76.14 v1(286.88,76.22) 286.98,76.22 288.03,77.27 289.3,77.27 289.84,77.81 290.83,77.81 291.47,78.45 292.87,78.45 293.32,78.91 294.39,78.91 v1(294.85,78.45)
  IN3 w0.089: v1(318.88,73.04) 318.77,73.04 318.01,72.28 317.71,72.28 317.41,71.98 316.98,71.98 316.7,72.26 316.7,74.76 316.01,75.45 313.83,75.45 313.2,76.08 310.32,76.08 309.42,75.18 309.42,73.56 307.06,71.2 302.84,71.2 301.76,72.28 301.76,76.29 300.87,77.18 300.87,77.81 299.72,78.96 295.35,78.96 v1(294.85,78.45) ; v1(173.96,74.45) 174.06,74.55 174.06,75.34 174.9,76.18 181.06,76.18 181.66,75.57 184.13,75.57 185.24,74.45 188.89,74.45 190.47,72.87 v1(191.85,72.87)
  IN4 w0.086: v1(191.85,72.87) 193.27,72.87 198.4,77.99 201.32,77.99 203.28,79.95 203.28,82.29 203.57,82.58 203.57,86.11 201.56,88.13 201.53,88.13 201.25,88.41 201.25,89.93 201.9,90.58 201.9,94.91 205.69,98.7 208.9,98.7 v1(209.91,97.69) ; v1(286.88,76.22) 285.71,76.22 283.17,73.68 v1(281.51,73.68)
  BOTTOM w0.14: v1(209.91,97.69) 209.1,98.5 209.1,99.15 209.32,99.38 R823.2 209.64,99.38 210.3,98.71 Q103.6
2ND_MBDATA_DDR: length 6.1
  BOTTOM w0.14: R823.1 210.48,99.28 211.61,99.28 212.18,98.71 Q103.1 212.69,98.66 R825.1 213.52,99.05 213.29,99.28 212.47,99.28 212.15,99.6 U46.7
3ND_MBCLK: length 647.5
  TOP w0.14: Q47.4 25.18,64.77 v1(25.63,65.22) ; U23.94 185.65,70.5 185.78,70.63 v1(185.93,70.63) 185.93,70.49 186.07,70.35 R426.1 ; v1(142.01,204.12) 141.96,204.17 141.96,205.28 141.72,205.52 141.72,206.04 Q10.4 ; v1(272.46,57.93) 272.46,56.16 272.88,55.75 273.33,55.75 273.47,55.89 Q51.4 273.47,56.79 273.62,56.94 276.01,56.94 276.34,57.27 R566.1 ; R34.1 258.27,210.85 258.17,210.95 v1(258.17,212.21)
  IN1 w0.086: v1(294.83,95.48) 296.03,96.68 296.03,101.43 295.76,101.69 295.76,105.71 294.79,106.68 294.34,106.68 290.09,110.93 290.09,111.64 289.77,111.95 289.77,113.68 289.32,114.12 289.32,115.67 285.82,119.18 283.4,119.18 282.4,120.18 282.4,137.31 282.54,137.45 282.54,153.17 286.36,156.99 286.36,183.68 281.06,188.98 281.06,193.87 281.79,194.61 281.79,199.12 281.23,199.69 277.56,199.69 276.22,201.03 273.93,201.03 272.9,202.06 269.26,202.06 267.92,200.72 267.92,198.69 267.67,198.44 265.47,198.44 264.87,199.03 264.87,200.5 265.06,200.68 265.06,202.76 265.75,203.44 265.75,205.62 264.45,206.91 264.45,208.12 261.69,210.88 261.69,212.05 261,212.74 258.7,212.74 v1(258.17,212.21)
  IN2 w0.089: v1(272.46,57.93) 271.42,56.89 266.14,56.89 263.77,54.53 253.89,54.53 253.48,54.93 250.78,54.93 249.97,54.13 244.82,54.13 244.17,53.48 238.6,53.48 237.96,54.11 237.05,54.11 236.34,54.81 232.9,54.81 232.47,55.24 232.34,55.24 232.19,55.39 230.74,55.39 230.57,55.22 229.05,55.22 227.82,56.45 224.07,56.45 223.43,55.81 219.58,55.81 219.4,55.63 217,55.63 215.76,56.87 213.92,56.87 213.17,57.63 211.12,57.63 210.43,58.32 209.92,58.32 209.41,58.83 209.41,60.13 208.82,60.72 207.52,60.72 206.98,61.26 206.98,61.4 206.65,61.74 205.19,61.74 203.99,62.94 203.54,62.94 202.51,63.97 201.76,64.72 201.09,64.72 200.05,65.76 197.35,65.76 196.22,66.89 193.28,66.89 192.1,68.07 189.76,68.07 187.82,70.01 186.55,70.01 v1(185.93,70.63)
  IN3 w0.089: v1(25.63,65.22) 25.83,65.02 25.83,64.36 26.47,63.72 28.04,63.72 29.3,62.46 29.3,61.33 29.72,60.91 29.72,59.56 33.8,55.48 37.85,55.48 38.37,54.97 45.7,54.97 46.77,56.03 52.89,56.03 53.5,56.64 56.81,56.64 58.99,58.82 58.99,59.69 60.2,60.9 62,60.9 66.12,65.02 94.71,65.02 95.09,64.65 108.9,64.65 110.21,65.95 122.8,65.95 124.18,67.33 129.57,67.33 130.93,68.69 132.51,68.69 133.75,69.93 139.35,69.93 140.37,70.95 149.42,70.95 149.94,71.46 150.65,71.46 150.85,71.67 152.35,71.67 152.38,71.63 153.96,71.63 155.68,69.92 156.94,69.92 158.54,71.52 161.29,71.52 161.84,70.97 164.61,70.97 165,71.36 167.08,71.36 167.15,71.44 174.02,71.44 174.83,70.63 177.4,70.63 178.13,71.36 179.41,71.36 181.04,69.74 183.2,69.74 184.09,70.63 v1(185.93,70.63) ; v1(272.46,57.93) 272.9,57.93 273.78,58.8 274.24,58.8 274.58,59.14 274.58,74.57 274.91,74.9 274.91,80.77 276.39,82.25 280.53,82.25 281.28,83 281.28,83.17 284.05,85.94 287.66,85.94 289.69,87.98 290.56,87.98 292.48,89.9 292.48,90.34 292.81,90.67 292.81,94.34 292.55,94.6 292.55,95.49 293.66,96.6 295.02,96.6 295.29,96.32 295.29,95.93 294.84,95.48 v1(294.83,95.48)
  IN4 w0.086: v1(258.17,212.21) 258.17,211.94 257.13,210.9 251.49,210.9 250.78,210.19 247.08,210.19 245.89,208.99 244.54,208.99 243.35,207.8 241.87,207.8 240.11,206.04 236.77,206.04 235.56,204.84 235.56,204.27 234.44,203.14 234.44,199.61 233.16,198.33 233.16,191.21 232.5,190.56 230.51,190.56 229.97,191.09 220.58,191.09 220.1,190.62 216.41,190.62 214.61,192.42 209.15,192.42 208.94,192.62 207.09,192.62 206.89,192.42 195.41,192.42 193.57,194.25 180.08,194.25 177.09,197.24 176.51,197.24 173.69,200.06 170.46,200.06 169,198.6 166.38,198.6 165.95,199.02 164.82,199.02 164.48,198.68 158.72,198.68 157.93,199.47 152.98,199.47 152.16,198.66 147.37,198.66 146.42,199.61 143.62,199.61 142.25,200.98 142.25,203.87 v1(142.01,204.12)
  BOTTOM w0.14: R698.1 257.9,213.54 Q75.3 258.17,212.61 v1(258.17,212.21)
3ND_MBCLK_C: length 17.3
  TOP w0.14: v1(148.02,209.1) 147.78,208.85 147.78,208.22 147.4,207.83 U1.4 ; R45.1 142.6,203.72 142.25,203.37 141.84,203.37 v1(141.43,203.78) 141.43,204.98 Q10.3
  IN2 w0.089: v1(141.43,203.78) 141.38,203.83 141.38,205.13 144.66,208.41 144.66,210.04 145.23,210.61 146.51,210.61 v1(148.02,209.1)
3ND_MBCLK_GPU: length 8.6
  BOTTOM w0.14: R704.2 257.86,211.49 Q75.4 258.05,211.67 258.57,211.67 258.78,211.89 v1(258.78,212.95) 258.78,213.38 258.62,213.54 R698.2 258.62,214.85 258.12,215.34 258.12,216.12 257.27,216.97 U35.8
3ND_MBDATA: length 644.8
  TOP w0.14: R567.1 279.78,57.72 279.31,58.19 279.31,59.09 279.02,59.38 278.46,59.38 277.38,58.3 276.83,58.3 276.36,58.77 v1(275.37,58.77) 275.2,58.77 274.77,58.35 Q51.1 ; Q47.1 26.18,65.48 v1(26.44,65.22) ; Q10.1 140.24,204.9 140.08,204.75 140.08,201.87 142.34,199.61 v1(142.96,199.61) ; R412.1 184.58,71.11 184.37,70.9 U23.95 182.71,70.9 182.31,70.5 182.31,70.35 v1(182.17,70.21) ; v1(256.31,210.43) 256.31,210.42 R33.1
  IN1 w0.086: v1(256.31,210.43) 257.5,211.62 258.46,211.62 259.11,212.28 260.81,212.28 261.23,211.86 261.23,210.69 263.98,207.93 263.98,206.72 265.28,205.43 265.28,203.64 264.59,202.95 264.59,200.88 264.41,200.69 264.41,198.84 265.27,197.97 268.07,197.97 268.42,198.33 268.42,200.56 269.45,201.59 272.71,201.59 273.74,200.56 276.03,200.56 277.37,199.22 281.04,199.22 281.33,198.93 281.33,194.8 280.59,194.06 280.59,188.78 285.89,183.48 285.89,172.52 285.41,172.04 285.41,166.41 285.89,165.93 285.89,157.18 282.07,153.36 282.07,137.64 281.93,137.5 281.93,119.98 283.21,118.71 285.63,118.71 288.86,115.48 288.86,113.93 289.3,113.48 289.3,111.76 289.62,111.44 289.62,110.74 294.29,106.07 294.29,105.97 294.61,105.64 294.74,105.64 295.3,105.08 295.3,101.5 295.56,101.24 295.56,96.87 v1(294.82,96.13)
  IN2 w0.089: v1(182.17,70.21) 182.68,69.7 184.85,69.7 184.92,69.77 185.5,69.77 185.85,69.42 186.36,69.42 187.99,67.79 189,67.79 189.19,67.6 191.9,67.6 193.09,66.42 196.02,66.42 197.75,64.69 200.45,64.69 200.89,64.25 201.56,64.25 202.17,63.64 202.17,63.54 203.74,61.97 204.13,61.97 204.9,61.2 204.9,60.62 205.26,60.25 207.57,60.25 208.29,59.52 208.29,59.38 208.56,59.11 208.7,59.11 208.94,58.88 208.94,58.42 209.51,57.85 210.23,57.85 211.36,56.73 212.26,56.73 212.58,56.4 215.13,56.4 215.86,55.68 215.86,55.29 216.49,54.65 219.85,54.65 220.16,54.97 220.98,54.97 221.08,54.87 223.15,54.87 224.26,55.98 227.63,55.98 228.86,54.75 231.83,54.75 232.31,54.27 232.64,54.27 232.72,54.34 236.15,54.34 237.49,53.01 244.37,53.01 245.02,53.66 250.17,53.66 250.98,54.46 253.28,54.46 253.69,54.06 263.97,54.06 266.33,56.42 271.62,56.42 273.97,58.77 v1(275.37,58.77)
  IN3 w0.089: v1(182.17,70.21) 182.17,70.49 181.95,70.71 180.73,70.71 179.53,71.91 166.96,71.91 166.88,71.83 164.8,71.83 164.41,71.44 162.42,71.44 161.88,71.99 158.35,71.99 156.96,70.6 155.66,70.6 154.16,72.1 152.58,72.1 152.5,72.19 150.7,72.19 150.45,71.93 149.59,71.93 149.07,71.42 140.17,71.42 139.16,70.4 133.77,70.4 133.76,70.42 132.74,70.42 131.49,69.16 130.74,69.16 129.71,68.13 124.31,68.13 122.6,66.42 109.38,66.42 108.86,65.9 91.49,65.9 91.08,65.49 65.76,65.49 61.64,61.37 60,61.37 58.52,59.89 58.52,59.01 56.61,57.11 53.31,57.11 52.7,56.5 46.57,56.5 45.51,55.44 38.56,55.44 38.05,55.95 34,55.95 30.19,59.76 30.19,61.11 29.77,61.53 29.77,62.66 28.24,64.19 26.66,64.19 26.3,64.56 26.3,65.07 v1(26.44,65.22) ; v1(294.82,96.13) 293.86,96.13 293.02,95.29 293.02,94.8 293.28,94.54 293.28,90.48 292.95,90.14 292.95,89.7 290.76,87.51 290.22,87.51 289.46,86.75 289.46,86.14 287.99,84.67 283.47,84.67 281.94,83.15 281.94,82.77 280.95,81.78 276.59,81.78 275.38,80.57 275.38,74.7 275.05,74.37 275.05,59.43 275.37,59.11 v1(275.37,58.77)
  IN4 w0.086: v1(256.31,210.43) 256.27,210.39 251.64,210.39 250.94,209.69 247.25,209.69 246.08,208.52 244.73,208.52 243.54,207.33 242.06,207.33 240.31,205.58 236.96,205.58 236.03,204.64 236.03,204.07 234.91,202.95 234.91,199.42 233.62,198.14 233.62,191.02 232.7,190.09 230.31,190.09 229.78,190.63 220.77,190.63 220.3,190.15 216.21,190.15 214.41,191.95 208.95,191.95 208.75,192.15 207.28,192.15 207.08,191.95 195.21,191.95 193.38,193.79 179.89,193.79 176.91,196.76 176.33,196.76 173.5,199.59 170.65,199.59 169.19,198.13 166.18,198.13 165.8,198.51 165,198.51 164.7,198.21 158.53,198.21 157.74,199 153.17,199 152.36,198.19 147.18,198.19 146.23,199.14 143.43,199.14 v1(142.96,199.61)
  BOTTOM w0.14: v1(256.31,210.43) 256.31,210.71 255.91,211.11 R700.1 256.33,211.32 256.54,211.53 Q75.6
3ND_MBDATA_C: length 12.2
  TOP w0.14: Q10.6 140.24,206.81 140.64,207.21 v1(141.33,207.21) 141.45,207.21 141.99,206.67 R43.1 142.53,207.24 143.32,208.03 144.24,208.03 144.82,208.61 144.82,209.21 145.14,209.54 145.5,209.54 145.72,209.31 147.35,209.31 147.5,209.16 147.5,208.34 147.36,208.2 147.14,208.2 147,208.05 U1.5
3ND_MBDATA_GPU: length 10.9
  TOP w0.14: v1(255.53,210.78) 255.18,211.13 v1(255.18,211.58) 255.18,211.79 256.8,213.41 256.8,214.1 256.96,214.27 257.36,214.27 257.5,214.41 257.5,215.71 v1(257.42,215.79)
  BOTTOM w0.14: Q75.1 256.9,212.88 256.69,213.1 R699.2 256.04,212.44 255.91,212.32 R700.2 255.37,211.77 v1(255.18,211.58) ; U35.7 256.9,216.32 v1(257.42,215.79)
5G_CARD_PWR_CTL: length 240.7
  TOP w0.14: R429.2 165.48,70.27 165.66,70.45 165.93,70.45 v1(166.44,70.96)
  TOP w0.203: v1(295.47,106.61) PR126.1
  IN2 w0.089: v1(310.46,94.34) 310.39,94.27 309.57,94.27 308.4,95.44 305.16,95.44 304.73,95.87 304.73,96.86 304.85,96.98 304.85,97.96 303.58,99.23 302.21,99.23 300.92,100.51 300.92,101.79 299.62,103.09 296.97,103.09 295.84,104.22 295.84,106.23 v1(295.47,106.61) ; v1(248.24,51.8) 247.99,51.54 243.97,51.54 243.61,51.18 239.15,51.18 238.82,51.51 235.12,51.51 233.83,52.81 231.45,52.81 231.16,52.51 230.26,52.51 229.48,53.29 227.65,53.29 227.4,53.04 216.44,53.04 215.73,53.75 214.89,53.75 213.49,55.15 212.43,55.15 211.7,55.87 207.99,55.87 206.82,57.05 206.82,57.99 206.94,58.12 206.94,58.74 206.34,59.34 205.21,59.34 201.51,63.04 201.51,63.24 201.25,63.49 200.83,63.49 200.67,63.33 199,63.33 198.64,62.98 195.46,62.98 194.2,64.24 193.11,64.24 192.06,65.29 190.51,65.29 190.24,65.56 188.8,65.56 188.1,66.27 187.36,66.27 185.73,67.9 184.67,67.9 184.39,68.18 181.7,68.18 181.25,68.62 178.91,68.62 178.1,69.43 175.83,69.43 174.69,70.57 173.12,70.57 172.58,70.04 170.15,70.04 170.03,70.16 166.81,70.16 166.44,70.52 v1(166.44,70.96)
  IN4 w0.086: v1(310.46,94.34) 315.74,94.34 317.29,92.78 317.29,92.39 316.29,91.39 313.81,91.39 312.4,89.98 310.95,89.98 310.14,89.17 310.14,88.12 310.05,88.03 307.35,88.03 305.67,86.35 305.67,83.35 305.91,83.11 305.91,81.41 303.48,78.98 301.31,78.98 301.16,78.83 299.09,78.83 297.98,77.72 295.22,77.72 294.91,78.03 293.79,78.03 293.4,78.42 288.31,78.42 287.91,78.03 285.92,78.03 284.15,79.8 282.7,79.8 282.18,80.32 281.49,80.32 280.81,81 280.16,81 279.67,80.51 279.67,80.51 279.58,80.42 279.58,80.4 278.94,79.76 278.94,79.55 276.12,76.74 276.12,75.36 274.71,73.95 274.71,71.96 272.13,69.38 269.5,69.38 268.75,70.14 264.47,70.14 263.15,68.82 253.85,68.82 251.38,66.35 247.43,66.35 v1(246.74,67.05)
  BOTTOM w0.14: v1(246.74,67.05) 245.99,66.3 245.99,61.54 247.36,60.17 248.88,60.17 250.76,58.29 250.76,55.39 249.93,54.56 249.93,52.08 249.24,51.39 248.64,51.39 v1(248.24,51.8) ; v1(310.46,94.34) 310.88,94.76 311.79,94.76 312.02,94.53 R836.1
5G_CARD_PWR_EC: length 204.5
  TOP w0.14: U23.4 169.15,70.1 169.78,70.73 v1(169.78,70.86) 169.78,70.97 169.48,71.28 169.11,71.28 168.78,71.61 167.69,71.61 167.45,71.85 R399.2
  IN3 w0.089: v1(309.26,93.79) 309.08,93.96 309.08,94.07 307.56,95.59 304.6,95.59 301.68,92.68 301.68,90.78 298.46,87.56 298.46,86.84 297.4,85.78 297.4,84.57 295.92,83.09 292.93,83.09 284.87,75.03 284.62,75.03 283.72,74.13 283.72,71.73 282.07,70.08 281.11,70.08 280.24,69.21 280.24,67.16 281.02,66.39 281.02,63.83 281.39,63.45 281.39,59.66 280.85,59.12 280.15,59.12 280.01,59.26 279.58,59.26 279.54,59.21 279.54,58.5 276.18,55.14 275.25,55.14 274.93,55.46 273.28,55.46 273.09,55.27 271.31,55.27 270.36,56.22 267.55,56.22 266.37,55.04 265.07,55.04 264.38,54.34 262.77,54.34 260.87,52.44 256.88,52.44 256.57,52.75 252.7,52.75 252.16,52.21 250.47,52.21 249.46,53.22 247.75,53.22 247.06,52.54 243.53,52.54 241.35,50.36 237.99,50.36 237.13,49.5 230.96,49.5 230.29,48.83 224.86,48.83 222.92,46.88 221.7,46.88 221.52,46.7 221.52,46 220.62,45.11 219.03,45.11 218.89,44.97 210.14,44.97 208.68,43.5 200.37,43.5 200.12,43.26 198.56,43.26 197.49,44.32 191.52,44.32 187.36,48.47 184.34,48.47 183.75,49.07 183.08,49.07 182.79,49.37 v1(182.6,49.37)
  BOTTOM w0.14: v1(169.78,70.86) 169.78,70.74 169.09,70.04 168.81,70.04 167.77,69 167.77,60.7 174.98,53.49 177.79,53.49 181.26,50.02 181.26,49.37 181.59,49.03 182.08,49.03 182.42,49.37 v1(182.6,49.37) ; v1(309.26,93.79) 309.26,93.79 310.58,93.79 311.03,94.24 R835.1
5G_LED_OD: length 2.3
  BOTTOM w0.14: TP126.1 309.98,90.64 309.61,91 CN7.10
5G_WWAN_DISABLE: length 213.5
  TOP w0.14: U23.93 182.81,70.1 182.33,69.62 181.97,69.62 181.36,70.23 v1(181.25,70.23)
  IN2 w0.089: v1(174.98,71.11) 175.48,70.62 177.27,70.62 177.35,70.7 180.16,70.7 180.63,70.23 v1(181.25,70.23)
  IN3 w0.089: v1(181.77,50.61) 181.82,50.55 182.89,50.55 183.32,50.13 183.32,50.04 184.5,48.86 187.52,48.86 190.98,45.4 194.12,45.4 194.78,44.73 197.62,44.73 198.71,43.64 199.96,43.64 200.21,43.89 208.5,43.89 210.23,45.61 211.57,45.61 211.84,45.35 218.73,45.35 218.87,45.49 220.46,45.49 221.13,46.16 221.13,46.88 221.52,47.26 222.76,47.26 224.97,49.47 229.9,49.47 230.31,49.88 232.91,49.88 233.07,50.04 237.05,50.04 237.92,50.92 241.37,50.92 243.39,52.94 246.93,52.94 247.59,53.6 249.62,53.6 250.62,52.6 252.01,52.6 252.54,53.13 256.73,53.13 257.04,52.82 260.71,52.82 263.17,55.28 264.52,55.28 265.87,56.63 270.72,56.63 271.5,55.86 273.76,55.86 274.63,56.73 276.17,56.73 276.75,57.31 277.72,57.31 279.16,58.75 279.16,61.82 279.25,61.91 279.25,69.62 281.43,71.8 281.91,71.8 282.45,72.35 282.45,74.51 284.23,76.29 284.59,76.29 288.42,80.12 288.42,81.57 291.29,84.44 292.27,84.44 294.03,86.21 294.03,87.23 294.56,87.75 296.65,87.75 297.3,88.41 297.3,89.75 300.23,92.68 300.23,95.08 301.73,96.58 305.76,96.58 306.08,96.26 307.17,96.26 308.56,94.86 308.97,94.86 309.57,94.27 309.89,94.27 310.22,93.94 311.8,93.94 312.14,93.59 312.14,91.95 312.09,91.9 v1(312.09,91.9)
  BOTTOM w0.14: v1(312.09,91.9) 312.08,91.91 R843.2 310.87,91.53 310.58,91.24 309.93,91.24 309.66,91.51 CN7.8 ; v1(174.98,71.11) 172.94,69.07 172.94,63.35 173.44,62.85 173.44,62.58 172.73,61.87 172.73,58.53 174.16,57.1 175.98,57.1 177.33,55.75 177.33,55.71 178.54,54.49 180.65,54.49 181.97,53.18 181.97,50.81 v1(181.77,50.61)
241_3V3: length 5.1
  BOTTOM w0.14: PR642.2 245.49,45.29 245.75,45.56 246.38,45.56 v1(246.76,45.94)
  BOTTOM w0.203: PR642.2 PC504.1 243,43.94 PU39.18
241_BST: length 3.1
  TOP w0.254: PR321.1 239.5,44.66 v1(239.5,43.65)
  BOTTOM w0.254: v1(239.5,43.65) 239.65,43.65 240.73,42.57 PU39.13
241_BST2: length 4
  TOP w0.254: PR349.1 238.98,38.1 v1(239.32,38.44)
  BOTTOM w0.203: PU39.10 241,40.18 239.88,39.06 239.88,39 v1(239.32,38.44)
241_LX1: length 10.7
  TOP w0.254: PR346.2 236.22,38.67 236.95,39.39 238.19,39.39 238.52,39.06 PC271.1 238.58,38.7 239.01,39.13 v1(239.01,40.34) v3(240.24,41.57) 238.43,41.57 237.99,42.01 PC245.1
241CLM: length 4.1
  BOTTOM w0.14: v1(238.52,45.29) PR640.2
  BOTTOM w0.203: PR640.2 239.53,44.41 240.47,43.47 PU39.14
241EN: length 4.9
  TOP w0.14: v1(241.51,38.87) v1(241.51,39.92)
  TOP w0.203: v1(241.51,38.87) 241.51,38.53 241.75,38.28 PR347.2
  BOTTOM w0.203: v1(241.51,38.87) 241.8,39.15 PU39.8 ; v1(241.51,38.87) 241.64,38.74 PC520.2 ; v1(241.51,38.87) 241.48,38.87 PR661.2
241FS: length 2
  BOTTOM w0.203: PU39.7 242.2,38.89 242.61,38.47 PR662.2
241MODE: length 2.9
  BOTTOM w0.203: PU39.15 241.8,43.9 241.6,44.1 240.72,44.1 240.54,44.29 v1(240.54,44.41) PR641.2
241PG: length 3.2
  TOP w0.203: v1(240.57,38.98) 240.57,38.67 240.43,38.54 PR348.2
  BOTTOM w0.203: PU39.9 241.26,39.67 v1(240.57,38.98) 240.57,38.69 PR660.2
269_BST: length 3.6
  TOP w0.203: PU4.15 165.74,205.69 165.94,205.49 166.08,205.49 166.68,204.9
  TOP w0.508: PR99.1 166.24,203.79 166.68,204.23 166.68,204.9
269_COMP: length 3.5
  TOP w0.203: PR57.1 168.17,210.02 168.02,209.88 PC13.2 168.01,209.39 167.05,208.43 166.75,208.43 166.48,208.16 PU4.20
269_CSN: length 24
  TOP w0.203: v1(169.51,205.1) 169.65,205.24 169.65,206.11 169.16,206.6 PR87.2 168.96,206.52 PC20.2 167.51,206.96 PU4.17
  IN3 w0.203: v1(171.33,189.07) 171.63,189.37 172.01,189.37 172.62,189.98 172.62,192.13 169.15,195.61 169.15,200.48 169.65,200.98 169.65,204.95 v1(169.51,205.1)
  BOTTOM w0.203: v1(171.33,189.07) 171.37,189.02 PR484.2
269_EN: length 8.8
  TOP w0.14: 165.74,208.75 165.74,209.21 166.02,209.49 166.42,209.49 166.91,209.98 PR56.2 166.91,210.66 167.07,210.82 PR46.2 167.57,211.13 167.57,211.12 PC8.1 168.22,211.28 v1(169.39,211.28) 169.5,211.4 PC5.2 169.5,212.53 170.5,213.52 PQ3.2
269_FB: length 19.2
  TOP w0.14: PC7.1 161.95,212.31 PR44.2 161.87,212.32 161.47,211.92 161.47,211.27 161.88,210.85 v1(161.93,210.85)
  TOP w0.178: PC12.1 169.06,209.18 169.53,208.7 170.13,208.7 170.47,208.37 PR71.1 PR81.2
  TOP w0.203: PU4.19 166.96,207.76 v1(167.08,207.89) 167.16,207.81 167.45,207.81 167.47,207.83 PR77.1 167.9,208.49 PC13.1 168.59,209.18 PC12.1
  IN4 w0.086: v1(161.93,210.85) 163.45,212.37 165.7,212.37 166.86,211.22 166.86,208.12 v1(167.08,207.89)
269_FBRTN: length 85.2
  TOP w0.14: PU4.18 167.88,207.36 PR77.2 168.04,207.38 168.3,207.64 168.3,207.78 PR70.1 168.84,207.83 169.18,207.5 v1(169.18,207.38) ; PR117.1 167.22,150.41 167.22,154.75 167.64,155.17 168.11,155.17 169.87,156.93 169.87,160.36 170.32,160.82 170.32,162.37 170.83,162.87 170.83,165.3 171.07,165.55 v1(171.23,165.55) ; v1(158.96,207.61) 159.57,207.61 160.1,208.14 PR68.1
  TOP w0.178: PC14.1 160.67,208.09 160.62,208.14 PR68.1
  IN3 w0.089: v1(171.23,165.55) 171.23,165.61 171.68,166.07 171.68,166.45 171.46,166.67 171.12,166.67 170.33,167.45 170.33,168.29 171.32,169.27 172.42,169.27 175.55,172.4 175.55,174.09 175.75,174.29 176.12,174.29 176.62,174.79 176.62,176.11 176.18,176.55 176.18,177.08 176.71,177.61 176.71,181.03 176.48,181.26 176.48,186.3 175.26,187.52 175.26,191.37 173.44,193.19 173.44,200.05 172.33,201.16 172.33,202.42 171.27,203.48 171.27,205.07 169.66,206.68 169.66,207.02 169.3,207.38 v1(169.18,207.38)
  BOTTOM w0.14: v1(169.18,207.38) 167.6,208.95 161.55,208.95 160.05,207.46 159.11,207.46 v1(158.96,207.61)
269_GH: length 7.4
  IN1 w0.635: v3(165.97,204.7) 165.97,204.28 165.48,203.8 165.48,201.79 166.12,201.16 166.82,201.16 v3(167.1,201.44)
  BOTTOM w0.635: PQ52.1 167.52,200.24 v1(167.1,200.66) v3(167.1,201.44)
269_GL: length 18.6
  TOP w0.14: v3(168.15,193.44) v1(168.15,194.15)
  IN1 w0.635: v3(168.15,193.44) 166.99,194.6 166.99,197.83 166,198.82 164.87,198.82 163.05,200.65 163.05,201.73 162.03,202.75 162.03,203.79 162.75,204.52 v3(162.75,205.9)
  BOTTOM w0.508: PQ52.8 168.41,193.7 v3(168.15,193.44)
269_PG: length 2.3
  TOP w0.178: PR85.2 PR80.2 162.75,207.23 163.02,206.96 PU4.9
269_SWN: length 15.6
  TOP w0.14: v3(168.86,192.37) v1(169.57,192.37)
  IN1 w0.635: v3(168.86,192.37) 169.14,192.65 169.14,193.64 168.01,194.77 168.01,198.86 166.73,200.14 165.99,200.14 164.67,201.46 164.67,204.33 v3(165.06,204.71)
269_V1: length 2.7
  TOP w0.178: PU4.7 163.26,207.76 162.14,208.88 PR65.1 161.89,208.88 161.76,209 PR66.2
269_V2: length 3.3
  TOP w0.178: PU4.6 163.4,208.16 163.13,208.42 163.13,209.01 v1(162.82,209.33) PR65.2 161.7,209.33 161.39,209.63 PR59.2
269_VCC: length 4.2
  TOP w0.14: 165.34,208.75 165.34,210.05 PC9.1 166.18,210.89 166.18,211.59 165.84,211.93 PR37.1
269_VDRP: length 4
  TOP w0.178: 164.14,208.75 164.14,209.3 163.19,210.25 PR53.1 162.68,210.25 162.49,210.44 162.49,210.99 161.93,211.54
269_VID0: length 1.7
  TOP w0.178: 164.94,208.75 164.94,210.08 164.76,210.26 PR52.2
269_VID1: length 1.8
  TOP w0.178: PR51.2 164,210.26 164.54,209.72 164.54,208.75
269_VREF: length 3.4
  TOP w0.178: PR66.1 160.91,208.84 161.17,208.59 161.44,208.59 161.92,208.1 PC14.2 161.92,208.08 162.32,207.68 162.83,207.68 163.15,207.36 PU4.8
1006_I2C_SCL: length 35
  TOP w0.14: U21.4 297.53,67.03 296.97,67.59 296.97,69.77 296.67,70.07 296.67,71.09 295.41,72.35 v1(295.41,72.73) 294.29,73.85 293.6,73.85 293.38,74.07 R377.2 293.38,74.64 293.53,74.8 Q37.1 293.29,75.1 292.9,75.49 v1(292.88,75.49) ; U20.7 308.4,66.23 v1(308.35,66.18)
  IN3 w0.089: v1(308.35,66.18) 307.95,66.58 307.95,67.71 306.92,68.73 304.02,68.73 303.09,69.66 302.42,69.66 300.47,71.61 300.47,74.78 299.84,75.41 298.31,75.41 297.61,74.72 293.65,74.72 v1(292.88,75.49)
1006_I2C_SDA: length 34.6
  TOP w0.14: Q37.4 296.09,76.45 296.17,76.37 297.06,76.37 297.56,75.86 297.56,75.25 v1(297.49,75.17) 297.03,74.72 295.86,74.72 295.46,74.31 R378.2 294.83,73.95 296.17,72.61 296.17,72 296.91,71.25 296.91,70.21 297.21,69.91 297.21,67.82 297.6,67.43 U21.3 ; U20.6 308.54,66.63 v1(308.35,66.83)
  IN3 w0.089: v1(308.35,66.83) 308.35,67.79 307.06,69.08 304.16,69.08 303.23,70.01 302.57,70.01 300.82,71.76 300.82,75.45 299.84,76.42 298.74,76.42 v1(297.49,75.17)
1006_I2S_BCLK: length 29.2
  TOP w0.14: R422.1 295.54,71.41 295.23,71.72 v1(294.62,71.72) 294.52,71.72 294.39,71.84 292.28,71.84 v1(291.9,71.46) ; U20.10 308.75,65.03 308.02,64.3 v1(308.02,64.12)
  IN3 w0.089: v1(291.9,71.46) 291.9,71.77 292.23,72.1 297.09,72.1 297.94,71.25 297.94,70.72 299.27,69.39 299.27,66.3 300.36,65.2 302.72,65.2 303.34,64.59 304.93,63 306.47,63 306.97,63.5 307.14,63.5 307.57,63.93 307.83,63.93 v1(308.02,64.12)
1006_I2S_BCLK_R: length 6
  TOP w0.14: U21.6 297.58,66.23 296.8,67.01 296.43,67.01 295.83,67.61 295.83,68.2 295.89,68.27 295.89,69.66 295.71,69.83 C418.1 295.49,70.1 295.54,70.14 R422.2
1006_I2S_IN: length 31
  TOP w0.14: R417.1 C408.1 291.8,69.56 291.32,70.04 291.16,70.04 v1(290.91,70.3) ; v1(308.09,65.57) 308.48,65.57 308.74,65.83 U20.8
  IN3 w0.089: v1(308.09,65.57) 308.09,65.87 307.6,66.36 307.6,67.57 306.8,68.37 303.9,68.37 302.94,69.32 302.28,69.32 300.13,71.47 300.13,74.44 299.49,75.07 298.63,75.07 297.82,74.26 297.82,73.62 297.31,73.11 291.72,73.11 290.71,72.1 290.71,71.21 290.88,71.03 290.88,70.35 290.91,70.32 v1(290.91,70.3)
1006_I2S_IN_R: length 7.3
  TOP w0.14: U21.10 297.55,64.63 293.38,68.8 R417.2
1006_I2S_LRCK: length 27.7
  TOP w0.14: R421.1 294.82,71.07 294.68,71.21 292.97,71.21 v1(292.33,70.57) ; U20.12 309.04,64.03 309.04,63.31 v1(309.12,63.24)
  IN3 w0.089: v1(292.33,70.57) 292.84,71.08 296.24,71.08 298.33,69 298.33,65.91 299.97,64.26 302.33,64.26 303.62,62.97 303.62,62.34 303.91,62.05 307.51,62.05 307.66,62.21 308.37,62.21 309.12,62.95 v1(309.12,63.24)
1006_I2S_LRCK_R: length 7.2
  TOP w0.14: R421.2 294.82,70.09 294.77,70.04 C417.1 294.51,69.84 294.41,69.73 294.41,68.49 296.51,66.38 v1(296.8,66.38) 296.8,66.09 297.07,65.83 U21.7
1006_I2S_MCLK: length 33.8
  TOP w0.14: v1(308.52,63.5) 308.52,64.4 308.75,64.63 U20.11 ; R423.1 296.25,71.1 294.62,72.73 v1(293.83,72.73) 293.63,72.73 293.37,72.48 292.1,72.48 291.24,71.62 v1(291.24,71.46)
  IN3 w0.089: v1(308.52,63.5) 308.52,64.28 308.21,64.59 307.54,64.59 307.48,64.65 307.16,64.65 306.93,64.41 306.93,64.12 306.28,63.47 305.12,63.47 303.53,65.06 302.92,65.67 300.56,65.67 299.74,66.49 299.74,69.58 298.41,70.91 298.41,71.44 297.25,72.61 291.98,72.61 291.24,71.87 v1(291.24,71.46)
1006_I2S_MCLK_R: length 5.1
  TOP w0.14: R423.2 C419.1 296.53,69.83 296.72,69.64 296.72,67.43 297.52,66.63 U21.5
1006_I2S_OUT: length 32.4
  TOP w0.14: v1(292.99,70.61) 293,70.61 293.24,70.85 R424.1 ; U20.9 308.75,65.43 308.44,65.12 307.76,65.12 307.47,65.41 v1(307.47,65.74)
  IN3 w0.089: v1(307.47,65.74) 307.47,65.41 307.73,65.15 308.32,65.15 308.99,64.48 309.38,64.48 310.05,63.8 310.05,62.9 309.95,62.79 309.95,62.51 308.19,60.75 307.36,60.75 306.4,61.71 303.77,61.71 303.28,62.19 303.28,62.83 302.19,63.92 299.83,63.92 297.99,65.76 297.99,68.73 296.12,70.6 293.03,70.6 293.02,70.61 v1(292.99,70.61)
1006_I2S_OUT_R: length 7.7
  TOP w0.14: U21.8 297.13,65.43 294.15,68.41 294.15,69.65 293.97,69.83 C420.1 293.78,70.26 293.92,70.4 R424.2
2211_AD1: length 2.4
  TOP w0.14: v1(37.21,60.92) 37.34,60.92 37.6,61.18 R523.2 38.03,60.97 37.73,60.68 U27.17
2211_AD2: length 1.2
  TOP w0.14: R557.2 46.87,58.49 U27.41
2211_AD3: length 1.3
  TOP w0.14: R549.2 46.61,58.99 U27.42
2211_ENI2C: length 3.6
  TOP w0.14: R592.2 R591.1 37.21,56.55 36.77,57 36.77,57.2 37.05,57.49 U27.21
2211_EQ0: length 1.2
  TOP w0.14: U27.39 46.9,57.49 R570.2
2211_EQ1: length 1.1
  TOP w0.14: U27.40 47.13,57.99 R564.2
2211_EQ2: length 1.5
  TOP w0.14: U27.1 45.73,60.31 46.05,60.63 R522.2
2211_FG0: length 1.7
  TOP w0.14: U27.37 45.23,55.2 R606.2
2211_FG1: length 1.6
  TOP w0.14: R607.2 45.73,55.17 U27.38
2211_HPD#: length 3
  TOP w0.14: Q54.3 35.42,56.59 v1(36.07,57.24) 36.82,57.99 U27.20
2211_SCL: length 1.1
  TOP w0.14: U27.19 36.62,58.49 R561.1
2211_SDA: length 1
  TOP w0.14: U27.18 36.93,58.99 36.92,59 R552.1
2211_SW1: length 1.4
  TOP w0.14: R521.2 45.29,60.64 45.23,60.59 U27.2
5650_BSIN1: length 9.6
  TOP w0.14: PR63.1 v1(234.17,208.71)
  TOP w0.203: PU2.3 228.79,209.19 228.5,208.9 v1(228.5,208.73) 228.42,208.73 227.8,208.1 PR75.2
  IN2 w0.381: v1(228.5,208.73) 229.23,209.46 231.45,209.46 232.16,208.75 234.15,208.75 234.17,208.73 v1(234.17,208.71)
5650_BSIN2: length 4.7
  TOP w0.203: PR83.2 230.61,207.16 230.61,208.08 230.44,208.26 PR74.2 230.16,208.71 v1(230.24,208.79) 229.99,209.04 PU2.6
  BOTTOM w0.508: v1(230.24,208.79) 230.24,208.95 229.58,209.6 PC307.1
5650_BSIN3: length 14.2
  TOP w0.14: PU2.14 232.33,212.58 232.37,212.61 234.28,212.61 235.79,211.11 v1(235.79,210.4) 235.79,210.09 234.67,208.98 234.67,208.47 234.42,208.22 233.84,208.22 233.55,208.51 233.55,208.89 233.72,209.06 PR63.2 233.72,209.52 233.21,210.04 PR55.2 233.21,210.5 232.97,210.73 232.72,210.73 232.08,211.38 PU2.11
5650_BSOK: length 7.4
  TOP w0.14: PR60.2 225.35,209.26 224.59,208.5 224.59,206.24 224.76,206.06 PR91.1
  TOP w0.203: PU2.30 226.96,211.38 225.82,210.24 225.82,210.12 225.35,209.65 PR60.2
