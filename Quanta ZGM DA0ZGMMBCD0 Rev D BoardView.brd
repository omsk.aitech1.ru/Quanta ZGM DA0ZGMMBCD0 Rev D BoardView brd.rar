# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VMA_DQ45: length 20.1
  IN2 w0.102: v2(222.65,132.97) 222.65,132.34 218.42,128.11 216.77,128.11 214.35,125.69 210.21,125.69 209.09,126.82 209.09,127.36 209.5,127.77 v2(209.5,128.05)
  BOTTOM w0.102: v2(209.5,128.05) 209.5,128.07 VRAM8.G2 ; v2(222.65,132.97) 222.45,133.16 UG6.BG50
VMA_DQ46: length 14
  IN2 w0.102: v2(211,128.04) 211,128.04 211.4,127.63 214.5,127.63 216.75,129.88 216.75,130.66 217.12,131.03 218.77,131.03 219.22,131.47 220.14,131.47 220.86,132.2 v2(220.86,132.71)
  BOTTOM w0.102: v2(220.86,132.71) 221.05,132.53 UG6.BJ52 ; v2(211,128.04) 211,128.06 210.63,128.43 VRAM8.E2
VMA_DQ47: length 15.2
  IN2 w0.102: v2(219.94,131.09) 218,129.15 216.71,129.15 214.24,126.68 210.87,126.68 210.64,126.92 210.64,127.49 210.62,127.5 210.62,128.5 210.62,128.5 210.62,129.21 v2(211,129.59)
  BOTTOM w0.102: UG6.BK53 220.35,131.47 219.97,131.09 v2(219.94,131.09)
  BOTTOM w0.161: v2(211,129.59) 210.63,129.21 VRAM8.E3
VMA_DQ48: length 28.5
  IN1 w0.102: v2(221.25,143.45) 220.89,143.82 217.07,143.82 216.31,143.06 215.6,143.06 215.36,142.81 215.36,141.98 214.24,140.86 208.24,140.86 208.05,140.68 206.69,140.68 206.36,140.35 202.28,140.35 199.9,137.97 199.9,136.14 v2(200.42,135.62)
  BOTTOM w0.102: v2(200.42,135.62) 200.75,135.95 VRAM8.V12
  BOTTOM w0.161: UG6.AP51 221.31,143.16 221.31,143.4 v2(221.25,143.45)
VMA_DQ49: length 24.6
  IN1 w0.102: v2(201.25,136.34) 200.82,136.76 200.82,138.05 202.48,139.71 206.32,139.71 206.75,140.13 207.42,140.13 207.89,139.66 208.73,139.66 209.43,140.36 214.25,140.36 216.93,143.04 219.85,143.04 v2(219.95,143.14)
  BOTTOM w0.102: v2(201.25,136.34) 201.61,136.7 VRAM8.U13
  BOTTOM w0.161: v2(219.95,143.14) 219.95,143.13 220.35,142.73 UG6.AP53
VMA_DQ50: length 18.4
  IN1 w0.102: v2(220.7,142.37) 220.1,141.77 219.12,141.77 218.98,141.63 217.04,141.63 214.23,138.82 211.3,138.82 210.66,138.18 210.66,137.72 210.43,137.49 206.15,137.49 v2(205.75,137.09)
  BOTTOM w0.102: VRAM8.M13 205.38,136.72 v2(205.75,137.09)
  BOTTOM w0.161: UG6.AR52 v2(220.7,142.37)
VMA_DQ51: length 19.5
  IN1 w0.102: v2(219.3,142.37) 218.87,141.94 216.84,141.94 214.3,139.4 210.73,139.4 209.94,138.6 207.83,138.6 207.51,138.93 205.31,138.93 204.49,138.11 204.49,137.75 204.3,137.56 203.97,137.56 v2(203.5,137.09)
  BOTTOM w0.102: v2(219.3,142.37) 219.65,142.02 UG6.AR54 ; VRAM8.P13 203.88,136.72 v2(203.5,137.09)
VMA_DQ52: length 21.3
  IN1 w0.102: v2(221.17,141.33) 220.5,140.66 218.83,140.66 217.61,139.44 216.04,139.44 214.2,137.6 213.93,137.6 213.68,137.34 213.68,136.97 213.41,136.7 212.29,136.7 212.14,136.56 212.14,136.15 211.94,135.95 204.6,135.95 v2(204.24,136.31)
  BOTTOM w0.102: v2(204.24,136.31) VRAM8.N13
  BOTTOM w0.161: v2(221.17,141.33) 221.23,141.27 221.23,141.14 UG6.AU51
VMA_DQ53: length 26.3
  IN1 w0.102: v2(222.1,142.37) 221.71,142.76 217.13,142.76 214.3,139.93 210.41,139.93 209.79,139.3 202.9,139.3 201.63,138.03 201.63,135.92 v2(202,135.55)
  BOTTOM w0.102: v2(222.1,142.37) 221.75,142.03 UG6.AR51
  BOTTOM w0.161: VRAM8.U12 201.63,135.93 v2(202,135.55)
VMA_DQ54: length 22.8
  IN1 w0.102: v2(222.11,140.27) 221.71,139.87 218.75,139.87 217.99,139.12 216.34,139.12 214.79,137.56 214.79,136.44 214.29,135.94 213.89,135.94 213.67,135.73 213.67,135.29 213.56,135.18 203.91,135.18 v2(203.52,135.57)
  BOTTOM w0.102: VRAM8.P12 203.88,135.93 v2(203.52,135.57)
  BOTTOM w0.161: UG6.AV51 221.75,139.95 222.07,140.27 v2(222.11,140.27)
VMA_DQ55: length 31.1
  IN1 w0.102: v2(222.61,141.34) 223.19,140.77 223.19,139.21 222.53,138.55 220.89,138.55 220.12,139.32 219.2,139.32 218.28,138.4 216.77,138.4 215.69,137.31 215.69,136.04 214.79,135.13 214.79,134.07 214.08,133.36 202.03,133.36 201.64,133.75 201.64,134.46 v2(201.28,134.82)
  BOTTOM w0.102: v2(201.28,134.82) 201.63,135.17 VRAM8.U11 ; UG6.AR49 222.61,141.48 v2(222.61,141.34)
VMA_DQ56: length 21.4
  IN2 w0.102: v2(222.66,139.22) 223.19,139.75 223.19,140.42 222.66,140.95 219.27,140.95 218.75,141.48 216.54,141.48 215.21,140.15 210.74,140.15 209.09,138.5 209.09,137.8 208.84,137.54 208.56,137.54 208.36,137.35 208.36,136.71 v2(208.74,136.33)
  BOTTOM w0.102: VRAM8.G13 209.11,136.7 v2(208.74,136.33) ; UG6.AV49 223.15,139.71 v2(222.66,139.22)
VMA_DQ57: length 12.7
  IN2 w0.102: v2(209.5,137.1) 209.88,137.48 209.88,138.35 211.22,139.69 215.34,139.69 215.92,140.26 v2(219.29,140.26)
  BOTTOM w0.102: v2(219.29,140.26) 219.64,139.92 UG6.AV54 ; v2(209.5,137.1) 209.88,136.72 VRAM8.F13
VMA_DQ58: length 10.3
  IN2 w0.102: v2(221.35,138.94) 220.96,138.55 219.1,138.55 219.1,138.55 218.38,138.55 217.41,137.59 215.56,137.59 214.73,136.76 213.9,136.76 213.56,137.1 v2(213.25,137.1)
  BOTTOM w0.102: v2(221.35,138.94) 221.35,138.92 UG6.AY51 ; v2(213.25,137.1) 213.24,137.1 212.88,136.73 VRAM8.B13
VMA_DQ59: length 14.1
  IN2 w0.102: v2(210.26,136.33) 210.65,136.72 210.65,138.43 211.51,139.29 217.5,139.29 218.06,139.86 220.29,139.86 v2(220.7,140.27)
  BOTTOM w0.102: v2(210.26,136.33) 210.62,136.7 VRAM8.E13
  BOTTOM w0.161: UG6.AV52 v2(220.7,140.27)
VMA_DQ60: length 13.4
  IN2 w0.102: v2(214.02,134.79) 215.73,134.79 216.35,135.4 217.89,135.4 218.08,135.59 222.15,135.59 223.15,136.59 223.15,137.82 v2(223.5,138.16)
  BOTTOM w0.102: v2(223.5,138.16) 223.54,138.2 223.54,138.21 UG6.AY48 ; v2(214.02,134.79) 213.95,134.85 213.21,134.85 212.88,135.18 VRAM8.B11
VMA_DQ61: length 7.1
  IN2 w0.102: v2(219.3,138.17) 219.26,138.17 217.91,136.82 215.33,136.82 214.85,136.34 214.06,136.34 v2(214.05,136.33)
  BOTTOM w0.102: VRAM8.A12 213.66,135.95 214.04,136.32 214.04,136.32 v2(214.05,136.33) ; UG6.BA54 219.65,137.82 v2(219.3,138.17)
VMA_DQ62: length 9.6
  IN2 w0.102: v2(220.71,138.17) 220.54,138.17 220.08,137.71 219.25,137.71 217.96,136.42 215.76,136.42 215.28,135.94 213.62,135.94 v2(213.24,135.56)
  BOTTOM w0.102: v2(213.24,135.56) 212.88,135.93 VRAM8.B12 ; UG6.BA52 v2(220.71,138.17)
VMA_DQ63: length 14
  IN2 w0.102: v2(211,135.56) 211.19,135.56 211.58,135.18 212.34,135.18 213.94,135.18 213.95,135.17 215.16,135.17 215.59,135.6 217.58,135.6 218.42,136.45 221.24,136.45 221.66,136.87 221.66,137.73 v2(222.1,138.17)
  BOTTOM w0.102: VRAM8.E12 210.63,135.94 v2(211,135.56) ; UG6.BA51 221.75,137.82 v2(222.1,138.17)
VMA_WCK01: length 16.4
  IN4 w0.114: v2(211.95,148.29) 211.85,148.29 211.74,148.18 211.74,147.99 211.85,147.88 214.85,147.88 215.06,147.66 218.17,147.66 218.71,148.2 219.81,148.2 219.89,148.27 223.65,148.27 224.32,148.94 224.32,149.23 v2(224.15,149.4)
  BOTTOM w0.102: UG6.AE48 223.85,149.1 v2(224.15,149.4)
  BOTTOM w0.114: v2(211.95,148.29) 211.71,148.53 211.71,149.11 211.38,149.45 VRAM6.R4
VMA_WCK01#: length 16.3
  IN4 w0.114: v2(224.91,149.37) 224.75,149.37 224.54,149.16 224.54,148.85 223.74,148.06 219.98,148.06 219.9,147.98 218.8,147.98 218.26,147.44 214.97,147.44 214.76,147.66 211.76,147.66 211.52,147.9 211.52,148.15 211.41,148.27 211.36,148.27 v2(211.33,148.29)
  BOTTOM w0.102: v2(211.33,148.29) 211.5,148.47 211.5,148.82 VRAM6.R5 ; UG6.AE47 224.56,149.02 v2(224.91,149.37)
VMA_WCK23: length 17.1
  IN4 w0.102: 223.45,144.98 223.46,144.97 223.95,144.97 v2(224.18,145.19)
  IN4 w0.114: v2(210.91,145.85) 211.08,146.01 211.08,146.43 211.33,146.69 214.1,146.69 215.09,145.7 217.79,145.7 218.2,146.11 221.35,146.11 222.39,145.07 223.36,145.07 223.45,144.98
  BOTTOM w0.102: v2(224.18,145.19) 223.85,144.87 UG6.AL48
  BOTTOM w0.14: v2(210.91,145.85) 211.03,145.74 211.03,145.2 211.03,145.03 VRAM6.R11
VMA_WCK23#: length 16.9
  IN4 w0.102: v2(224.2,144.46) 224.23,144.49 224.23,144.64 224.1,144.77 223.36,144.77
  IN4 w0.114: 223.36,144.77 223.27,144.85 222.3,144.85 221.26,145.9 218.29,145.9 217.88,145.49 215,145.49 214.01,146.47 211.42,146.47 211.29,146.34 211.29,145.92 211.44,145.77 211.6,145.77 v2(211.7,145.87)
  BOTTOM w0.102: v2(224.2,144.46) 224.14,144.52 224.14,144.66 224.32,144.84 224.53,144.84 UG6.AL47
  BOTTOM w0.14: VRAM6.R10 211.27,145.3 211.27,145.66 211.49,145.88 211.68,145.88 v2(211.7,145.87)
VMA_WCK45: length 26.4
  IN4 w0.102: v2(203.49,130.31) 203.49,130.44 203.62,130.57 203.86,130.57 203.97,130.68 204.69,130.68 204.91,130.9 204.91,131.31 205.91,132.3 208.4,132.3 208.96,132.86 214.37,132.86 215.07,133.56 215.07,134.51 216.04,135.47 222.32,135.47 223.47,136.62 224.3,136.62 224.58,136.9 224.58,137.1 v2(224.94,137.45)
  BOTTOM w0.102: v2(224.94,137.45) 224.57,137.82 UG6.BA47 ; v2(203.49,130.31) 203.13,129.95 VRAM8.R4
VMA_WCK45#: length 26.4
  IN4 w0.102: v1(203.55,131.12) 203.5,131.08 203.5,130.88 203.6,130.78 203.77,130.78 203.88,130.88 204.61,130.88 204.71,130.99 204.71,131.39 205.82,132.51 208.32,132.51 208.88,133.07 214.29,133.07 214.87,133.65 214.87,134.59 215.95,135.67 222.24,135.67 223.39,136.83 224.22,136.83 224.37,136.98 224.37,137.36 224.27,137.46 v2(224.17,137.46)
  BOTTOM w0.102: VRAM8.R5 203.33,130.7 203.55,130.92 v1(203.55,131.12) ; UG6.BA48 223.95,137.82 224.17,137.6 v2(224.17,137.46)
VMA_WCK67: length 34.4
  IN4 w0.102: 224.1,140.7 224.2,140.8 v2(224.2,140.97)
  IN4 w0.114: 224.1,140.7 224.06,140.65 223.41,140.65 223.19,140.88 219.05,140.88 218.6,140.42 218.6,139.74 217.48,138.62 215.91,138.62 215.67,138.38 215.67,138.11 215.56,137.99 215.33,137.99 215.21,138.11 215.21,138.38 214.97,138.62 208.36,138.62 207.72,137.98 207.72,134.98 208.73,133.96 208.73,133.52 208.45,133.24 204.38,133.24 204.11,132.97 204.11,132.23 204,132.11 203.57,132.11 203.46,132.23 203.46,132.77 203.22,133 203.22,133.88 203.34,134 v2(203.5,134)
  BOTTOM w0.102: v2(224.2,140.97) 224.2,140.97 UG6.AU48 ; v2(203.5,134) 203.5,134.82 VRAM8.R11
VMA_WCK67#: length 34.2
  IN4 w0.102: v2(224.2,140.26) 224.2,140.38 224.15,140.44
  IN4 w0.114: v2(202.75,134) 202.87,134 203.01,133.86 203.01,132.91 203.24,132.68 203.24,132.14 203.48,131.9 204.09,131.9 204.33,132.14 204.33,132.88 204.47,133.02 208.54,133.02 208.95,133.43 208.95,134.05 207.93,135.07 207.93,137.89 208.45,138.41 214.88,138.41 215,138.29 215,138.02 215.24,137.78 215.64,137.78 215.89,138.02 215.89,138.29 216,138.41 217.57,138.41 218.82,139.65 218.82,140.33 219.14,140.66 223.1,140.66 223.32,140.44 224.15,140.44
  BOTTOM w0.102: v2(202.75,134) 202.81,133.93 202.96,133.93 203.13,134.1 203.13,134.44 VRAM8.R10 ; UG6.AU47 224.36,140.62 224.2,140.47 v2(224.2,140.26)
VMA_WCKB01: length 26.9
  IN4 w0.114: v2(202.68,148.37) 202.77,148.37 202.82,148.32 202.82,147.7 203.06,147.46 209.86,147.46 210.27,147.87 210.27,148.45 210.52,148.7 214.62,148.7 215.35,147.96 217.85,147.96 218.1,148.21 218.1,149.17 218.75,149.82 218.75,149.85 219.02,150.13 224.03,150.13 v2(224.13,150.03)
  BOTTOM w0.102: UG6.AC48 224.13,150.14 v2(224.13,150.03)
  BOTTOM w0.14: v2(202.68,148.37) 202.77,148.46 202.77,148.47 202.78,148.48 202.78,148.94 202.77,148.95 202.77,149.34 VRAM6.D4
VMA_WCKB01#: length 26.7
  IN4 w0.114: v2(203.33,148.37) 203.17,148.37 203.04,148.23 203.04,147.79 203.15,147.67 209.77,147.67 210.06,147.96 210.06,148.54 210.43,148.91 214.71,148.91 215.44,148.18 217.76,148.18 217.88,148.3 217.88,149.26 218.53,149.91 218.53,149.94 218.93,150.34 223.91,150.34 223.98,150.41 224.12,150.41 224.24,150.53 224.24,150.73 v2(224.2,150.77)
  BOTTOM w0.102: v2(224.2,150.77) 224.15,150.72 224.15,150.52 224.3,150.37 224.5,150.37 UG6.AC47
  BOTTOM w0.14: VRAM6.D5 203.02,148.84 203.02,148.57 203.08,148.51 203.08,148.4 203.17,148.3 203.26,148.3 v2(203.33,148.37)
VMA_WCKB23: length 25.3
  IN4 w0.114: v2(224.2,145.88) 224.49,146.18 224.49,146.58 224.11,146.97 218.64,146.97 218.64,146.96 216.62,146.96 216.45,146.79 214.98,146.79 214.58,147.19 210.65,147.19 210.16,146.7 203.91,146.7 203.41,146.21 203.41,145.89 v2(203.63,145.67)
  BOTTOM w0.102: v2(224.2,145.88) 224.19,145.88 224.15,145.88 223.85,146.18 UG6.AJ48 ; v2(203.63,145.67) 203.48,145.52 203.48,144.8 VRAM6.D11
VMA_WCKB23#: length 25.1
  IN4 w0.114: v2(224.91,145.87) 224.7,146.08 224.71,146.09 224.71,146.67 224.2,147.18 218.55,147.18 218.55,147.18 216.53,147.18 216.36,147 215.07,147 214.67,147.41 210.56,147.41 210.07,146.92 203.82,146.92 203.19,146.3 203.19,145.89 203.18,145.87 203.18,145.86 203.03,145.72 v2(202.98,145.72)
  BOTTOM w0.102: v2(224.91,145.87) 224.56,146.22 UG6.AJ47 ; VRAM6.D10 202.98,145.34 v2(202.98,145.72)
VMA_WCKB45: length 18.6
  IN4 w0.114: v2(224.2,136.08) 224.27,136 224.27,135.24 224.42,135.09 224.42,134.31 223.7,133.59 222.33,133.59 222.27,133.53 216.43,133.53 214.77,131.87 211.47,131.87 211.18,131.59 211.18,131.35 v2(211.01,131.18)
  BOTTOM w0.102: UG6.BC48 223.85,136.42 v2(224.2,136.08)
  BOTTOM w0.114: v2(211.01,131.18) 211.01,130.31 VRAM8.D4
VMA_WCKB45#: length 18.5
  IN4 w0.114: v2(224.9,136.08) 224.75,136.08 224.49,135.82 224.49,135.33 224.64,135.18 224.64,134.22 223.79,133.37 222.42,133.37 222.36,133.32 216.52,133.32 214.86,131.65 211.56,131.65 211.4,131.5 211.4,131.27 211.51,131.16 211.7,131.16 v2(211.72,131.18)
  BOTTOM w0.102: v2(224.9,136.08) 224.69,136.08 224.55,136.22 UG6.BC47
  BOTTOM w0.114: VRAM8.D5 211.37,130.7 211.37,131.04 211.53,131.2 211.69,131.2 v2(211.72,131.18)
VMA_WCKB67: length 21
  IN4 w0.114: v2(212.03,133.94) 211.97,133.94 211.86,133.83 211.86,133.7 212.03,133.54 214.13,133.54 214.41,133.82 214.41,135.27 215.47,136.33 217.45,136.33 218.16,137.04 218.16,137.68 218.01,137.83 218.01,138.43 219.4,139.82 222.91,139.82 223.26,139.47 223.26,138.98 223.48,138.77 224.22,138.77 224.43,138.98 224.43,139.34 v2(224.2,139.57)
  BOTTOM w0.114: VRAM8.D11 211.38,135.02 211.77,134.63 211.77,134.2 v2(212.03,133.94) ; UG6.AV48 v2(224.2,139.57)
VMA_WCKB67#: length 20.7
  IN4 w0.114: v2(211.4,133.92) 211.42,133.91 211.5,133.91 211.65,133.76 211.65,133.61 211.94,133.32 214.22,133.32 214.63,133.73 214.63,135.18 215.56,136.12 217.54,136.12 218.37,136.95 218.37,137.77 218.22,137.92 218.22,138.34 219.49,139.61 222.82,139.61 223.05,139.38 223.05,138.9 223.39,138.55 224.31,138.55 224.65,138.9 224.65,139.32 v2(224.89,139.57)
  BOTTOM w0.114: v2(224.89,139.57) 224.85,139.61 224.85,139.62 UG6.AV47 ; VRAM8.D10 211.38,133.95 v2(211.4,133.92)
VMB_CLK0: length 24.6
  IN4 w0.102: v2(226.31,159.16) 226.31,159.35 226.38,159.42 226.62,159.42 226.9,159.71 226.9,160.84 226.59,161.15 226.59,162.03 226.22,162.4 225.46,162.4 225.33,162.52 225.33,162.95 225.47,163.09 225.47,163.68 225.04,164.12 224.69,164.12 224.49,164.31 224.49,167.25 224.05,167.7 222.98,167.7 221.88,168.79 221.88,171.26 221.71,171.44 221.71,173.13 221.91,173.34 221.91,174.06 221.86,174.11 221.86,175.16 222.1,175.39 222.46,175.39 223.02,175.95 223.02,176.71 222.75,176.98 222.49,176.98 v2(222.34,177.13)
  BOTTOM w0.102: UG6.K44 226.65,159.51 v2(226.31,159.16) ; VRAM1.J10 221.91,176.91 222.12,176.91 v2(222.34,177.13)
VMB_CLK0#: length 24.6
  IN4 w0.102: v2(226.18,159.96) 226.18,159.73 226.29,159.63 226.53,159.63 226.7,159.79 226.7,160.76 226.39,161.07 226.39,161.94 226.14,162.19 225.37,162.19 225.13,162.43 225.13,163.03 225.27,163.17 225.27,163.6 224.96,163.91 224.61,163.91 224.29,164.23 224.29,167.17 223.97,167.49 222.89,167.49 221.68,168.71 221.68,171.18 221.5,171.35 221.5,173.21 221.71,173.42 221.71,173.98 221.66,174.03 221.66,175.24 222.01,175.6 222.38,175.6 222.82,176.04 222.82,176.62 222.67,176.77 222.47,176.77 222.34,176.64 v2(222.34,176.52)
  BOTTOM w0.102: v2(226.18,159.96) 226.18,159.85 226.27,159.77 226.38,159.77 226.65,160.03 UG6.J44 ; VRAM1.K10 221.89,176.71 222.15,176.71 v2(222.34,176.52)
VMB_CLK1: length 34.8
  IN4 w0.114: v2(207.77,162.93) 207.63,162.79 207.63,162.47 207.38,162.23 206.01,162.23 205.76,162.47 205.76,163.23 206.56,164.02 206.56,166.33 206.32,166.57 206.32,167.63 206.88,168.19 214.79,168.19 215.7,167.28 215.7,165.38 216.37,164.71 216.37,163.09 217.21,162.25 219.12,162.25 219.47,161.89 221.94,161.89 222.32,162.27 223.94,162.27 224.46,161.75 224.46,161.17 225.22,160.41 225.53,160.41 v2(225.65,160.53)
  BOTTOM w0.102: UG6.J46 225.34,160.22 v2(225.65,160.53)
  BOTTOM w0.114: v2(207.77,162.93) 207.63,163.07 VRAM4.J10
VMB_CLK1#: length 34.8
  IN4 w0.114: v2(225.61,159.88) 225.61,160.04 225.45,160.2 225.13,160.2 224.24,161.08 224.24,161.66 223.85,162.05 222.4,162.05 222.03,161.68 219.38,161.68 219.03,162.03 217.12,162.03 216.15,163 216.15,164.62 215.48,165.29 215.48,167.19 214.7,167.98 206.97,167.98 206.54,167.54 206.54,166.66 206.77,166.42 206.77,163.93 205.98,163.14 205.98,162.56 206.1,162.45 207.29,162.45 207.41,162.56 207.41,162.78 207.25,162.93 207.09,162.93 v2(207.07,162.92)
  BOTTOM w0.102: UG6.K46 225.25,159.66 225.27,159.68 225.27,159.83 225.38,159.93 225.56,159.93 v2(225.61,159.88) ; v2(207.07,162.92) 207.29,162.92 207.39,163.02 207.39,163.21 207.18,163.42 206.9,163.42 VRAM4.K10
VMB_DQ0: length 13.3
  IN2 w0.102: v2(232.18,164.22) 232.18,165.65 231.57,166.26 231.57,167.63 231.37,167.83 231.16,167.83 230.79,168.21 230.79,168.93 229.75,169.96 229.75,172.19 229.15,172.78 227.55,172.78 v2(227.26,173.07)
  BOTTOM w0.161: UG6.D37 231.68,163.72 v2(232.18,164.22) ; v2(227.26,173.07) 227.63,173.44 VRAM1.P2
VMB_DQ1: length 14.4
  IN2 w0.102: v2(231.19,159.88) 231.19,160.48 230.8,160.88 230.8,161.2 229.27,162.73 229.02,162.73 228.43,163.31 228.43,165.26 227.64,166.05 227.64,168.11 v2(225.72,170.03)
  BOTTOM w0.102: VRAM1.U4 226.05,171.2 225.75,170.89 225.75,170.13 225.72,170.1 v2(225.72,170.03) ; v2(231.19,159.88) 231.54,160.22 UG6.J37
VMB_DQ2: length 18.4
  IN2 w0.102: v2(227.26,174.55) 227.41,174.41 229.14,174.41 230.69,172.87 230.69,170.31 232.86,168.14 232.86,162.5 232.69,162.33 232.2,162.33 232.05,162.19 232.05,161.52 v2(232.17,161.41)
  BOTTOM w0.102: VRAM1.M2 227.63,174.92 v2(227.26,174.55)
  BOTTOM w0.161: v2(232.17,161.41) 231.77,161.41 UG6.G37
VMB_DQ3: length 15.4
  IN2 w0.102: v2(228.02,173.82) 228.19,173.65 229.13,173.65 230.28,172.51 230.28,170.06 231.8,168.53 231.8,166.99 232.03,166.76 232.39,166.76 232.63,166.52 232.63,162.93 v2(232.46,162.76)
  BOTTOM w0.102: v2(228.02,173.82) 228,173.82 VRAM1.N2
  BOTTOM w0.161: v2(232.46,162.76) 231.99,162.76 UG6.F37
VMB_DQ4: length 17.1
  IN2 w0.102: v2(226.49,173.81) 226.11,173.43 226.11,171.21 225.34,170.44 225.34,169.52 227.41,167.45 227.41,165.96 228.23,165.14 228.23,163.23 228.95,162.51 229.09,162.51 229.47,162.13 229.47,161.45 230.35,160.57 v2(230.5,160.57)
  BOTTOM w0.102: v2(226.49,173.81) 226.86,173.45 VRAM1.P3 ; v2(230.5,160.57) UG6.H38
VMB_DQ5: length 10.2
  IN2 w0.102: v2(231.19,163.37) 230.67,163.9 230.67,164.46 230.2,164.94 230.2,165.69 229.66,166.23 229.66,168.04 228.64,169.07 228.47,169.07 227.67,169.87 227.67,170.47 v2(228.02,170.83)
  BOTTOM w0.102: VRAM1.U2 227.65,171.2 v2(228.02,170.83)
  BOTTOM w0.161: UG6.E38 231.19,163.36 v2(231.19,163.37)
VMB_DQ6: length 11.8
  IN2 w0.102: v2(230.42,162.74) 230.03,162.74 229.48,163.28 229.48,165.63 229.21,165.9 228.85,165.9 228.49,166.26 228.49,167.82 226.88,169.43 226.88,170.4 226.49,170.79 v2(226.49,170.81)
  BOTTOM w0.161: v2(230.42,162.74) 230.39,162.71 229.84,162.71 UG6.F40 ; v2(226.49,170.81) 226.88,171.19 VRAM1.U3
VMB_DQ7: length 8.4
  IN2 w0.102: v2(227.27,170.03) 227.27,169.74 227.37,169.64 228.38,168.63 228.53,168.63 229.45,167.71 229.45,166.02 229.69,165.78 229.69,164.79 v2(230.11,164.37)
  BOTTOM w0.161: UG6.D40 230.1,164.37 v2(230.11,164.37) ; VRAM1.V3 226.88,170.42 v2(227.27,170.03)
VMB_DQ8: length 21.9
  IN1 w0.102: v2(234.09,162.74) 233.7,163.13 233.7,163.61 232.86,164.45 232.86,168.1 231.32,169.64 231.2,169.64 229.25,171.58 229.25,171.9 229.15,172 228.72,172 228.42,172.3 228.42,179.93 228.01,180.34 v2(228.01,180.59)
  BOTTOM w0.102: VRAM1.E2 228.01,180.58 v2(228.01,180.59)
  BOTTOM w0.161: v2(234.09,162.74) 234.07,162.74 UG6.F34
VMB_DQ9: length 32.1
  IN1 w0.102: v2(234.1,159.98) 234.1,159.98 234.1,160.12 235.77,161.8 235.77,167.74 234.11,169.4 233.49,169.4 233.08,169.81 233.08,170.31 232.87,170.53 232.49,170.53 232.25,170.77 232.25,171.22 231.29,172.19 231.29,182.02 229.24,184.07 226.93,184.07 v2(226.51,183.65)
  BOTTOM w0.102: v2(234.1,159.98) 233.89,159.98 UG6.J34
  BOTTOM w0.161: VRAM1.A3 226.88,183.26 226.78,183.36 226.78,183.38 v2(226.51,183.65)
VMB_DQ10: length 24.8
  IN1 w0.102: v2(234.06,164.11) 234.48,164.53 234.48,165.65 233.95,166.19 233.95,168.15 232.87,169.23 232.54,169.23 231.85,169.92 231.85,170.06 230.26,171.65 230.26,177.2 229.72,177.74 229.72,181.8 229.07,182.44 226.85,182.44 v2(226.49,182.08)
  BOTTOM w0.102: UG6.D34 233.67,163.72 v2(234.06,164.11)
  BOTTOM w0.161: VRAM1.B3 226.86,182.45 v2(226.49,182.08)
VMB_DQ11: length 28
  IN1 w0.102: v2(227.24,182.83) 227.24,182.83 227.65,183.23 229.14,183.23 230.13,182.25 230.13,178.05 230.75,177.43 230.75,171.74 232.23,170.27 232.23,169.95 232.53,169.65 232.96,169.65 234.83,167.78 234.83,161.88 v2(234.36,161.42)
  BOTTOM w0.161: UG6.G34 233.85,161.42 v2(234.36,161.42) ; v2(227.24,182.83) VRAM1.B2
VMB_DQ12: length 19.9
  IN1 w0.102: v2(233.3,163.36) 232.61,164.05 232.61,167.95 231.41,169.15 231.1,169.15 229.03,171.22 228.47,171.22 227.64,172.05 227.64,174.08 227.85,174.29 227.85,175.62 227.64,175.83 227.64,177.72 227.99,178.08 v2(227.99,179.06)
  BOTTOM w0.161: v2(227.99,179.06) 227.63,178.7 VRAM1.G2 ; UG6.E35 233.29,163.36 v2(233.3,163.36)
VMB_DQ13: length 30.1
  IN1 w0.102: v2(233.3,159.17) 232.92,159.55 232.92,160.22 232.23,160.91 231.73,160.91 231.66,160.84 231.09,160.84 230.8,161.12 230.8,165.53 230.78,165.54 230.78,167.76 229.25,169.29 226.94,169.29 226.68,169.55 225.6,169.55 225.31,169.84 225.31,180.69 225.58,180.96 226.13,180.96 v2(226.5,180.59)
  BOTTOM w0.102: UG6.K34 v2(233.3,159.17)
  BOTTOM w0.161: VRAM1.E3 226.88,180.22 v2(226.5,180.59)
VMB_DQ14: length 25.6
  IN1 w0.102: v2(233.3,160.58) 232.88,161 232.88,162.06 232.62,162.32 232.34,162.32 231.59,163.08 231.59,167.54 231.2,167.92 231.06,167.92 230.78,168.21 230.78,168.36 229.53,169.61 227.09,169.61 226.88,169.82 226.88,170.18 226.64,170.41 226.35,170.41 226.11,170.65 226.11,178.53 227.23,179.65 v2(227.23,179.82)
  BOTTOM w0.102: v2(227.23,179.82) 227.61,179.45 VRAM1.F2 ; v2(233.3,160.58) 232.96,160.92 UG6.H35
VMB_DQ15: length 32.6
  IN1 w0.102: v2(232.53,159.96) 231.92,159.96 231.53,160.35 231.29,160.35 230.48,161.16 230.48,162.14 229.71,162.91 229.71,163.41 230.5,164.19 230.5,167.57 229.04,169.02 226.72,169.02 226.46,169.27 225.18,169.27 224.17,170.28 224.17,182.78 224.52,183.13 225.45,183.13 v2(225.74,182.84)
  BOTTOM w0.102: v2(232.53,159.96) 232.95,159.54 UG6.K35
  BOTTOM w0.161: v2(225.74,182.84) 226.13,182.46 VRAM1.B4
VMB_DQ16: length 19
  IN2 w0.102: v2(218.97,174.57) 218.63,174.23 217.84,174.23 217.19,173.57 217.19,169.28 220.02,166.45 220.02,166.18 220.69,165.51 220.69,164.93 222.54,163.08 222.93,163.08 223.19,162.82 223.19,162.5 223.65,162.04 224.84,162.04 v2(224.91,161.97)
  BOTTOM w0.161: UG6.G47 224.58,161.62 224.91,161.95 v2(224.91,161.97)
  BOTTOM w0.216: VRAM1.M13 219.35,174.95 v2(218.97,174.57)
VMB_DQ17: length 17.4
  IN2 w0.102: v2(226.99,162.68) 226.99,163.14 226.56,163.58 226.56,167.45 222.98,171.03 222.98,173.54 222.48,174.04 222.04,174.04 221.44,173.44 220.99,173.44 220.13,173.44 v2(219.75,173.83)
  BOTTOM w0.102: VRAM1.N13 v2(219.75,173.83) ; v2(226.99,162.68) UG6.E44
VMB_DQ18: length 11.8
  IN2 w0.102: v2(225.73,162.78) 225.3,163.21 225.3,165.65 224.29,166.66 224.29,167.15 223.34,168.1 222.7,168.1 220.89,169.91 220.89,170.44 v2(221.27,170.82)
  BOTTOM w0.102: UG6.F46 225.26,162.32 v2(225.73,162.78) ; v2(221.27,170.82) 220.9,171.2 VRAM1.U11
VMB_DQ19: length 15
  IN2 w0.102: v2(220.52,173.06) 221.48,172.1 221.48,171.9 222.12,171.27 222.44,171.27 222.8,170.9 222.8,170.04 225.32,167.52 225.32,166.65 226.3,165.66 226.3,163.55 226.49,163.36 226.49,162.48 v2(226.99,161.97)
  BOTTOM w0.102: v2(220.52,173.06) 220.13,173.45 VRAM1.P12 ; v2(226.99,161.97) 226.99,162 226.68,162.32 UG6.F44
VMB_DQ20: length 11.6
  IN2 w0.102: v2(220.51,171.57) 220.13,171.19 220.13,169.1 222.59,166.64 222.97,166.64 223.17,166.44 223.17,166.09 224.41,164.85 224.41,164.49 224.56,164.34 224.56,163.74 224.86,163.44 224.86,163.41 224.88,163.39 224.88,163.38 v2(224.89,163.37)
  BOTTOM w0.102: UG6.E46 225.25,163.03 224.91,163.37 v2(224.89,163.37)
  BOTTOM w0.161: v2(220.51,171.57) 220.14,171.2 VRAM1.U12
VMB_DQ21: length 8.6
  IN2 w0.102: v2(224.9,164.78) 224.48,165.2 224.48,165.2 223.45,166.24 223.45,167.27 223.05,167.66 222.35,167.66 220.51,169.5 v2(220.51,170.07)
  BOTTOM w0.102: UG6.C47 224.55,164.43 v2(224.9,164.78) ; VRAM1.V12 220.13,170.44 220.5,170.07 v2(220.51,170.07)
VMB_DQ22: length 11.5
  IN2 w0.102: v2(223.6,164.14) 224.03,164.57 224.03,164.9 223.73,165.2 223.51,165.2 222.94,165.76 222.55,165.76 222.03,166.29 222.03,166.57 219.36,169.23 219.36,170.45 v2(219.74,170.83)
  BOTTOM w0.102: v2(219.74,170.83) 219.74,170.83 VRAM1.U13 ; v2(223.6,164.14) 223.61,164.13 223.87,164.13 224.24,163.76 224.24,163.51 224.55,163.2 UG6.E47
VMB_DQ23: length 13.8
  IN2 w0.102: v2(218.98,173.08) 218.62,173.08 218.29,173.41 217.95,173.41 217.72,173.19 217.72,169.55 221.01,166.26 221.01,165.27 221.19,165.1 222.48,165.1 v2(222.81,164.77)
  BOTTOM w0.102: VRAM1.P13 219.35,173.45 v2(218.98,173.08)
  BOTTOM w0.161: v2(222.81,164.77) 222.83,164.77 223.15,164.45 UG6.C49
VMB_DQ24: length 33.1
  IN1 w0.102: v2(230.06,161.4) 229.51,161.95 229.51,163.52 229.72,163.73 229.72,165.67 229.66,165.73 229.66,167.82 228.9,168.59 226.73,168.59 226.3,169.02 224.86,169.02 223.7,170.18 223.7,183.18 222.82,184.07 220.45,184.07 220.1,183.72 220.1,183.19 v2(219.73,182.82)
  BOTTOM w0.161: v2(230.06,161.4) 229.68,161.4 UG6.G40 ; VRAM1.B13 219.38,182.46 v2(219.73,182.82)
VMB_DQ25: length 24.3
  IN1 w0.102: v2(229.1,164.77) 229,164.77 228.71,165.06 228.71,165.62 228.43,165.9 228.43,166.93 228.02,167.34 227.86,167.34 227.38,167.82 226.62,167.82 226.15,168.29 225.12,168.29 224.95,168.47 224.3,168.47 222.86,169.91 222.86,181.96 222.42,182.41 221.65,182.41 v2(221.24,182.81)
  BOTTOM w0.102: v2(229.1,164.77) 228.76,164.42 UG6.C41
  BOTTOM w0.161: v2(221.24,182.81) VRAM1.B11
VMB_DQ26: length 28.1
  IN1 w0.102: v2(229.09,163.37) 229.09,163.4 229.52,163.83 229.52,165.58 229.15,165.95 228.94,165.95 228.64,166.24 228.64,167.25 228.42,167.47 228.42,167.93 228.12,168.23 226.64,168.23 226.25,168.62 225.28,168.62 225.16,168.74 224.57,168.74 223.28,170.03 223.28,182.49 222.55,183.23 220.88,183.23 v2(220.52,183.59)
  BOTTOM w0.161: v2(220.52,183.59) 220.52,183.59 VRAM1.A12 ; v2(229.09,163.37) 228.75,163.03 UG6.E41
VMB_DQ27: length 26.2
  IN1 w0.102: v2(229.09,161.97) 229.09,162.37 228.42,163.04 228.42,165.33 227.42,166.33 227.42,166.75 227.23,166.93 226.82,166.93 226.57,167.18 226.57,167.46 226.11,167.92 224.78,167.92 224.54,168.16 223.96,168.16 223.07,169.05 222.79,169.05 221.66,170.17 221.66,180.73 221.22,181.17 220.52,181.87 v2(220.52,182.07)
  BOTTOM w0.102: v2(229.09,161.97) 228.75,162.31 UG6.F41
  BOTTOM w0.161: v2(220.52,182.07) 220.14,182.45 VRAM1.B12
VMB_DQ28: length 24.1
  IN1 w0.102: v2(219.73,179.82) 219.73,179.58 219.36,179.21 219.36,169.91 220.56,168.72 220.99,168.72 222.26,167.44 222.93,167.44 223.46,166.9 223.46,166.22 223.63,166.05 224.03,166.05 224.39,166.4 225.04,166.4 226.28,165.16 226.28,164.27 227.17,163.37 227.7,163.37 227.71,163.36 v2(227.73,163.36)
  BOTTOM w0.102: UG6.F43 227.69,162.66 227.69,163.32 v2(227.73,163.36)
  BOTTOM w0.161: VRAM1.F13 219.73,179.81 v2(219.73,179.82)
VMB_DQ29: length 21
  IN1 w0.102: v2(227,164.76) 227,164.92 224.92,167 224.48,167 223.99,167.48 223.42,167.48 222.94,167.96 222.53,167.96 221.28,169.2 220.75,169.2 220.13,169.82 220.13,179.98 220.49,180.35 v2(220.49,180.56)
  BOTTOM w0.102: v2(227,164.76) 226.66,164.42 UG6.C44
  BOTTOM w0.161: VRAM1.E12 v2(220.49,180.56)
VMB_DQ30: length 26.1
  IN1 w0.102: v2(229.09,161.26) 228.48,161.88 228.48,162.02 228.16,162.34 227.88,162.34 226.44,163.78 225.53,163.78 225.3,164.01 225.3,165.66 225.06,165.9 224.55,165.9 224.24,165.59 223.55,165.59 223.16,165.99 223.16,166.43 222.95,166.64 222.3,166.64 220.61,168.32 220.08,168.32 218.76,169.64 218.55,169.85 218.55,178.43 218.97,178.86 v2(218.97,179.07)
  BOTTOM w0.102: v2(218.97,179.07) 219.34,178.7 VRAM1.G13 ; UG6.H41 v2(229.09,161.26)
VMB_DQ31: length 26.6
  IN1 w0.102: v2(227,161.28) 226.95,161.28 226.42,161.82 226.42,162.01 226.1,162.33 225.4,162.33 224.49,163.24 224.49,164.73 224.06,165.17 223.44,165.17 222.86,165.75 222.46,165.75 220.47,167.74 219.99,167.74 218.09,169.64 217.45,170.28 217.45,179.67 217.97,180.19 218.65,180.19 v2(219.01,180.56)
  BOTTOM w0.102: UG6.H44 226.65,160.94 v2(227,161.28) ; VRAM1.E13 v2(219.01,180.56)
VMB_DQ32: length 25
  IN1 w0.102: v2(201.25,159.32) 201.25,159.33 200.81,159.77 200.81,160.6 201.62,161.41 217.92,161.41 218.64,160.68 219.95,160.68 220.96,159.68 221.58,159.68 v2(222.1,159.16)
  BOTTOM w0.102: UG6.L51 222.09,159.16 v2(222.1,159.16)
  BOTTOM w0.161: v2(201.25,159.32) VRAM4.U4
VMB_DQ33: length 23
  IN1 w0.102: v2(220.69,159.17) 220.01,159.85 219.02,159.85 218.1,160.78 201.92,160.78 201.57,160.42 201.57,159.61 201.63,159.55 201.63,158.95 v2(202,158.59)
  BOTTOM w0.102: v2(220.69,159.17) 221.04,158.82 UG6.L52
  BOTTOM w0.161: VRAM4.U3 201.63,158.21 v2(202,158.59)
VMB_DQ34: length 19.5
  IN1 w0.102: v2(221.27,158.07) 221.21,158.01 220.38,158.01 219.88,158.5 219.08,158.5 218.9,158.32 218.25,158.32 217.66,158.91 214.92,158.91 214.2,158.19 204.44,158.19 204.26,158.02 v2(204.26,157.83)
  BOTTOM w0.102: v2(204.26,157.83) 204.26,157.8 204.61,157.45 VRAM4.N2
  BOTTOM w0.161: v2(221.27,158.07) 221.27,157.9 UG6.N51
VMB_DQ35: length 30.4
  IN1 w0.102: v2(223.5,158.48) 223.19,158.78 223.19,161.41 222.8,161.81 201.17,161.81 199.82,160.47 199.82,159.23 v2(200.49,158.56)
  BOTTOM w0.102: VRAM4.V3 200.86,158.2 v2(200.49,158.56) ; v2(223.5,158.48) 223.15,158.82 UG6.L49
VMB_DQ36: length 18.7
  IN1 w0.102: v2(219.3,159.16) 219.15,159.16 218.55,159.76 203.26,159.76 203.09,159.59 203.09,159 v2(203.5,158.59)
  BOTTOM w0.102: UG6.L54 219.31,159.16 v2(219.3,159.16) ; VRAM4.P3 203.88,158.21 v2(203.5,158.59)
VMB_DQ37: length 21.8
  IN1 w0.102: v2(224.91,157.77) 224.59,157.45 222.1,157.45 221.94,157.61 220.71,157.61 220.55,157.45 218.32,157.45 218.22,157.56 215.29,157.56 214.36,156.62 205.42,156.62 v2(205,157.04)
  BOTTOM w0.102: UG6.N47 224.56,157.42 v2(224.91,157.77) ; VRAM4.M2 205.38,157.43 205,157.06 v2(205,157.04)
VMB_DQ38: length 21.1
  IN1 w0.102: v2(203.5,157.04) 203.53,157.04 203.85,156.72 203.85,156.05 204.13,155.77 214.3,155.77 215.2,156.67 221.7,156.67 v2(222.1,157.07)
  BOTTOM w0.102: v2(203.5,157.04) 203.5,157.06 203.88,157.44 VRAM4.P2
  BOTTOM w0.161: UG6.P51 221.78,156.72 222.1,157.04 v2(222.1,157.07)
VMB_DQ39: length 25.8
  IN1 w0.102: v2(223.51,156.38) 222.2,156.38 222.15,156.42 219.32,156.42 219.23,156.33 219.01,156.11 217.9,156.11 217.59,156.42 215.81,156.42 214.73,155.35 202.32,155.35 201.62,156.05 201.62,157.43 v2(201.25,157.81)
  BOTTOM w0.102: v2(201.25,157.81) 201.61,157.45 VRAM4.U2
  BOTTOM w0.161: UG6.P49 223.17,156.72 v2(223.51,156.38)
VMB_DQ40: length 11.4
  IN2 w0.102: v2(212.51,158.57) 212.89,158.19 214.15,158.19 215.91,156.44 217.53,156.44 217.75,156.22 219.01,156.22 219.17,156.38 220.67,156.38 221.01,156.04 v2(221.24,156.04)
  BOTTOM w0.102: VRAM4.B3 212.88,158.21 v2(212.51,158.57)
  BOTTOM w0.161: v2(221.24,156.04) 221.24,155.74 221.66,155.32 UG6.T51
VMB_DQ41: length 8.7
  IN2 w0.102: v2(214.03,158.58) 214.43,158.58 216.33,156.68 219.62,156.68 v2(220,157.05)
  BOTTOM w0.102: VRAM4.A3 213.65,158.2 v2(214.03,158.58) ; UG6.P52 220.81,156.72 220.45,157.08 220.04,157.08 220.02,157.05 v2(220,157.05)
VMB_DQ42: length 8
  IN2 w0.102: v2(219.3,157.06) 219.15,157.06 218.72,157.49 216.27,157.49 214.8,158.97 213.62,158.97 v2(213.25,159.34)
  BOTTOM w0.102: UG6.P54 219.65,156.73 219.32,157.06 v2(219.3,157.06) ; VRAM4.B4 212.88,158.97 v2(213.25,159.34)
VMB_DQ43: length 20.5
  IN2 w0.102: v2(224.92,154.27) 224.6,154.59 223.91,154.59 223.83,154.67 223.21,154.67 223.13,154.59 222.04,154.59 221.73,154.28 221.73,153.86 221.4,153.53 220.71,153.53 220.04,154.19 219.25,154.19 218.78,153.72 217.87,153.72 217.61,153.46 215.39,153.46 214.17,154.69 211.14,154.69 209.92,155.91 209.92,156.68 210.24,156.99 v2(210.24,157.81)
  BOTTOM w0.102: v2(224.92,154.27) 224.57,154.62 UG6.U47 ; VRAM4.F2 v2(210.24,157.81)
VMB_DQ44: length 14.7
  IN2 w0.102: v2(211,157.04) 211,156.66 210.75,156.42 210.75,155.98 211.48,155.26 214.32,155.26 215.32,154.26 217.66,154.26 217.81,154.11 218.77,154.11 219.23,154.57 221.53,154.57 221.92,154.97 v2(222.11,154.97)
  BOTTOM w0.102: VRAM4.E2 210.63,157.42 v2(211,157.04)
  BOTTOM w0.161: UG6.U51 221.75,154.65 222.07,154.97 v2(222.11,154.97)
VMB_DQ45: length 9.3
  IN2 w0.102: v2(214.03,157.02) 215.69,155.36 220.15,155.36 220.54,154.97 v2(220.7,154.97)
  BOTTOM w0.102: v2(214.03,157.02) 213.96,157.09 213.23,157.09 VRAM4.B2
  BOTTOM w0.161: UG6.U52 v2(220.7,154.97)
VMB_DQ46: length 12
  IN2 w0.102: v2(219.29,154.97) 219.14,154.97 218.7,154.53 215.75,154.53 214.58,155.7 212.45,155.7 212.24,155.92 212.24,156.68 211,157.92 v2(211,158.58)
  BOTTOM w0.102: VRAM4.E3 210.64,158.2 211,158.56 v2(211,158.58) ; UG6.U54 219.64,154.62 v2(219.29,154.97)
VMB_DQ47: length 18.4
  IN2 w0.102: v2(209.5,157.04) 209.1,156.64 209.1,156.06 211,154.17 213.99,154.17 214.95,153.21 217.71,153.21 217.77,153.27 218.96,153.27 218.96,153.27 221.77,153.27 221.83,153.33 222.76,153.33 223.09,153.66 223.09,153.94 223.42,154.27 v2(223.51,154.27)
  BOTTOM w0.102: v2(223.51,154.27) 223.16,154.62 UG6.U49 ; VRAM4.G2 209.13,157.42 v2(209.5,157.04)
VMB_DQ48: length 26.7
  IN1 w0.102: v2(201.25,165.34) 201.63,165.72 201.63,168.24 202.15,168.76 206.34,168.76 206.8,168.3 217.5,168.3 219.2,166.59 219.2,166.18 219.45,165.93 220.23,165.93 v2(221.45,164.72)
  BOTTOM w0.161: v2(221.45,164.72) 221.45,164.12 UG6.D52 ; v2(201.25,165.34) 201.61,165.7 VRAM4.U13
VMB_DQ49: length 27.6
  IN1 w0.102: v2(200.42,164.62) 200.42,164.72 200.77,165.07 200.77,168.24 201.56,169.04 207.03,169.04 207.23,168.84 217.6,168.84 219.75,166.68 220.05,166.68 v2(220.43,166.31)
  BOTTOM w0.102: UG6.C53 220.39,164.42 220.69,164.71 220.69,166.05 v2(220.43,166.31) ; VRAM4.V12 200.75,164.95 v2(200.42,164.62)
VMB_DQ50: length 17.1
  IN1 w0.102: v2(218.36,165.63) 218.36,165.52 217.96,165.12 217.64,165.12 217.44,165.32 217.1,165.32 216.9,165.12 215.98,165.12 215.79,165.32 214.57,166.53 205.43,166.53 v2(205,166.1)
  BOTTOM w0.102: v2(205,166.1) 205.38,165.73 VRAM4.M13 ; v2(218.36,165.63) 218.65,165.34 218.65,164.99 218.82,164.82 219.26,164.82 UG6.C54
VMB_DQ51: length 18
  IN1 w0.102: v2(203.51,166.08) 203.59,166.08 204.96,167.45 214.49,167.45 216.36,165.58 217.12,165.58 v2(217.26,165.72)
  BOTTOM w0.102: VRAM4.P13 203.88,165.71 v2(203.51,166.08) ; v2(217.26,165.72) 217.26,165.5 217.71,165.05 217.71,165.05 217.95,164.82 218.36,164.82 218.75,164.42 UG6.C55
VMB_DQ52: length 16.6
  IN1 w0.102: v2(203.5,164.56) 203.88,164.18 214.29,164.18 214.77,163.7 218.26,163.7 v2(218.59,163.37)
  BOTTOM w0.102: VRAM4.P12 203.88,164.93 v2(203.5,164.56) ; v2(218.59,163.37) 218.6,163.37 UG6.D55
VMB_DQ53: length 16.9
  IN1 w0.102: v2(204.23,165.33) 204.62,165.72 214.75,165.72 216.13,164.34 v2(217.22,164.34)
  BOTTOM w0.102: v2(217.22,164.34) 217.49,164.07 219.3,164.07 UG6.D54
  BOTTOM w0.161: v2(204.23,165.33) 204.6,165.7 VRAM4.N13
VMB_DQ54: length 17.7
  IN1 w0.102: v2(201.98,164.58) 203.18,163.37 214.25,163.37 214.94,162.68 v2(217.84,162.68)
  BOTTOM w0.102: VRAM4.U12 201.63,164.93 v2(201.98,164.58)
  BOTTOM w0.161: v2(217.84,162.68) 218.2,162.32 UG6.F56
VMB_DQ55: length 24.4
  IN1 w0.102: v2(222.8,162.66) 222.43,162.28 221.78,162.28 221.08,162.98 219.9,162.98 219.16,162.24 202.16,162.24 201.71,162.69 201.71,163.35 v2(201.24,163.81)
  BOTTOM w0.102: UG6.F49 223.14,162.32 v2(222.8,162.66) ; VRAM4.U11 201.61,164.2 201.24,163.83 v2(201.24,163.81)
VMB_DQ56: length 13.7
  IN2 w0.102: v2(210.25,165.33) 211.44,166.52 214.69,166.52 216.73,164.49 216.73,164.11 217,163.84 218.7,163.84 219.03,163.51 219.03,162.99 v2(219.74,162.28)
  BOTTOM w0.102: v2(210.25,165.33) 210.26,165.34 210.28,165.34 210.63,165.69 VRAM4.E13 ; v2(219.74,162.28) 220.35,161.66 UG6.G53
VMB_DQ57: length 19.1
  IN2 w0.102: v2(210.25,166.1) 210.24,166.1 209.91,166.44 209.91,167.2 210.19,167.48 214.5,167.48 216.66,165.32 217.43,165.32 217.64,165.12 218.27,165.12 219.6,163.79 219.6,163.13 220.97,161.76 223.17,161.76 v2(223.58,161.35)
  BOTTOM w0.102: UG6.H49 v2(223.58,161.35) ; VRAM4.F13 209.88,165.73 v2(210.25,166.1)
VMB_DQ58: length 12.7
  IN2 w0.102: v2(222.1,161.27) 221.68,160.85 218.44,160.85 218.1,161.2 216.57,161.2 215.34,162.43 215.34,163.84 214.23,164.95 213.63,164.95 v2(213.24,164.56)
  BOTTOM w0.102: UG6.H51 v2(222.1,161.27) ; VRAM4.B12 212.88,164.93 v2(213.24,164.56)
VMB_DQ59: length 18.4
  IN2 w0.102: v2(209.5,166.1) 209.67,166.27 209.67,167.68 210.1,168.12 216.98,168.12 219.02,166.07 219.02,165.91 220.31,164.62 220.71,164.62 221.24,164.09 v2(221.24,162.28)
  BOTTOM w0.102: v2(209.5,166.1) 209.13,165.73 VRAM4.G13 ; v2(221.24,162.28) 221.24,162.28 221.75,161.77 UG6.G51
VMB_DQ60: length 11.4
  IN2 w0.102: v2(220.7,161.27) 220.23,161.74 219.63,161.74 219.16,162.2 216.96,162.2 216.32,162.85 216.32,164.3 214.89,165.72 213.63,165.72 v2(213.25,166.1)
  BOTTOM w0.102: v2(220.7,161.27) 221.04,160.92 UG6.H52 ; VRAM4.B13 213.24,166.06 213.24,166.09 v2(213.25,166.1)
VMB_DQ61: length 8.8
  IN2 w0.102: v2(219.3,161.28) 218.85,161.74 216.77,161.74 215.81,162.69 215.81,164.09 214.56,165.34 v2(214.05,165.34)
  BOTTOM w0.102: VRAM4.A12 213.68,164.95 214.05,165.32 v2(214.05,165.34) ; UG6.H54 219.65,160.93 v2(219.3,161.28)
VMB_DQ62: length 17.2
  IN2 w0.102: v2(223.61,160.03) 222.36,158.78 216.24,158.78 212.73,162.29 212.73,163.1 212.45,163.38 212.17,163.38 v2(210.99,164.56)
  BOTTOM w0.102: UG6.K48 223.61,159.76 v2(223.61,160.03) ; v2(210.99,164.56) 210.99,164.57 210.63,164.93 VRAM4.E12
VMB_DQ63: length 12.2
  IN2 w0.102: v2(214.05,163.76) 214.05,163.74 214.43,163.36 214.43,161.86 216.47,159.81 220.65,159.81 v2(221.1,160.26)
  BOTTOM w0.102: v2(214.05,163.76) 213.97,163.83 213.24,163.83 VRAM4.B11 ; UG6.K51 221.75,159.66 221.15,160.26 v2(221.1,160.26)
VMB_WCK01: length 19.3
  IN4 w0.102: v2(229.8,159.86) 229.8,159.75 229.71,159.66 229.55,159.66 229.41,159.79 229.41,160.56 229.68,160.82 229.68,161.86 229.72,161.9 229.72,164.48 229.69,164.52 229.69,165.71 229.33,166.06 228.56,166.06 228.48,165.98 228.27,165.98 227.63,166.61 227.63,167.62 225.93,169.32 225.55,169.32 225.36,169.51
  IN4 w0.114: 225.36,169.51 224.9,169.51 224.38,170.03 224.38,172.38 224.52,172.51 224.68,172.51 224.88,172.31 v2(224.88,172.28)
  BOTTOM w0.102: UG6.J40 229.45,160.21 v2(229.8,159.86)
  BOTTOM w0.114: VRAM1.R4 225.91,172.7 225.55,172.34 224.94,172.34 v2(224.88,172.28)
VMB_WCK01#: length 19.3
  IN4 w0.102: v2(229.81,159.15) 229.81,159.35 229.71,159.45 229.46,159.45 229.21,159.71 229.21,160.64 229.47,160.91 229.47,161.94 229.52,161.99 229.52,164.39 229.48,164.43 229.48,165.62 229.25,165.86 228.65,165.86 228.57,165.77 228.19,165.77 227.43,166.53 227.43,167.53 225.84,169.12 225.46,169.12 225.29,169.3 225.28,169.3
  IN4 w0.114: v2(224.86,172.91) 224.7,172.75 224.69,172.75 224.67,172.73 224.43,172.73 224.17,172.47 224.17,169.94 224.81,169.3 225.28,169.3
  BOTTOM w0.102: v2(229.81,159.15) 229.45,159.51 UG6.K40
  BOTTOM w0.114: v2(224.86,172.91) 225.17,172.91 VRAM1.R5
VMB_WCK23: length 18.1
  IN4 w0.114: v2(227.77,160.52) 227.64,160.39 227.48,160.39 227.36,160.51 227.36,160.71 227.61,160.96 227.61,162.91 226.44,164.08 226.44,165.09 225.05,166.48 225.05,167.45 224.35,168.16 223.71,168.16 222.99,168.88 222.99,172.64 222.75,172.88 222.31,172.88 222.25,172.95 v2(222.25,173.07)
  BOTTOM w0.102: v2(227.77,160.52) 227.76,160.51 227.64,160.51 UG6.J43 ; v2(222.25,173.07) 222.2,173.12 221.29,173.12 VRAM1.R11
VMB_WCK23#: length 18.1
  IN4 w0.114: v2(227.73,159.92) 227.73,160.03 227.59,160.18 227.4,160.18 227.15,160.42 227.15,160.8 227.4,161.05 227.4,162.82 226.23,163.99 226.23,165 224.84,166.39 224.84,167.37 224.26,167.95 223.62,167.95 222.77,168.79 222.77,172.55 222.66,172.67 222.36,172.67 222.24,172.55 222.24,172.36 v2(222.25,172.35)
  BOTTOM w0.102: UG6.K43 227.27,159.6 227.27,159.78 227.4,159.92 227.52,159.92 227.52,159.92 v2(227.73,159.92) ; v2(222.25,172.35) 222.3,172.4 222.3,172.54 222.14,172.7 222.07,172.7 221.92,172.85 221.78,172.85 VRAM1.R10
VMB_WCK45: length 28.6
  IN4 w0.114: v2(202.56,160.22) 202.64,160.22 202.76,160.34 202.76,160.87 203.02,161.13 206.69,161.13 207.08,161.51 208.56,161.51 209.06,162.01 214.38,162.01 215.79,160.61 215.79,159.83 216.47,159.14 217.52,159.14 218.07,158.59 218.86,158.59 219,158.74 219.91,158.74 220.97,157.68 221.53,157.68 221.63,157.78 222.24,157.78 222.35,157.67 223.76,157.67 223.79,157.63 224.61,156.81 224.61,156.51 224.75,156.37 v2(224.9,156.37)
  BOTTOM w0.102: UG6.P47 224.55,156.7 224.88,156.37 v2(224.9,156.37) ; 202.76,160.02 202.78,160 202.78,159.75 202.8,159.74 202.79,159.73
  BOTTOM w0.114: 202.76,160.02 v2(202.56,160.22) ; VRAM4.R4 203.13,159.16 202.79,159.49 202.79,159.73
VMB_WCK45#: length 28.6
  IN4 w0.114: v2(224.16,156.34) 224.28,156.34 224.4,156.46 224.4,156.72 223.67,157.45 222.26,157.45 222.15,157.56 221.72,157.56 221.62,157.47 220.88,157.47 219.82,158.52 219.09,158.52 218.94,158.37 217.98,158.37 217.43,158.93 216.39,158.93 215.57,159.74 215.57,160.52 214.29,161.8 209.15,161.8 208.65,161.3 207.17,161.3 206.78,160.91 203.11,160.91 202.98,160.78 202.98,160.1 203.1,159.98 203.26,159.98 203.39,160.11 v2(203.39,160.23)
  BOTTOM w0.102: v2(203.39,160.23) 203.26,160.36 203.12,160.36 202.99,160.23 202.99,159.98 202.99,159.83 VRAM4.R5 ; UG6.P48 223.85,156.76 223.97,156.88 224.12,156.88 224.25,156.76 224.25,156.43 v2(224.16,156.34)
VMB_WCK67: length 37.2
  IN4 w0.114: v2(202.8,162.9) 203.02,162.68 203.02,162.06 203.28,161.8 208.36,161.8 208.94,162.37 208.94,163.1 208.62,163.43 208.32,163.43 207.96,163.79 207.96,166.29 208.28,166.61 208.28,167.24 208.46,167.43 214.51,167.43 214.79,167.15 214.79,164.95 215.51,164.22 215.51,162.86 217.16,161.21 217.71,161.21 218.25,160.66 223.58,160.66 224.04,160.2 224.04,159.74 224.42,159.36 224.7,159.36 v2(224.89,159.17)
  BOTTOM w0.102: VRAM4.R11 203.13,163.92 202.78,163.58 202.78,162.91 v2(202.8,162.9) ; UG6.K47 224.55,159.51 v2(224.89,159.17)
VMB_WCK67#: length 37.2
  IN4 w0.114: v2(203.52,162.9) 203.37,162.9 203.23,162.77 203.23,162.14 203.37,162.01 208.27,162.01 208.73,162.46 208.73,163.01 208.53,163.21 208.23,163.21 207.74,163.7 207.74,166.38 208.06,166.7 208.06,167.33 208.37,167.64 214.6,167.64 215,167.24 215,165.03 215.73,164.31 215.73,162.95 217.24,161.43 217.79,161.43 218.34,160.88 223.67,160.88 224.26,160.28 224.26,159.83 224.51,159.58 224.79,159.58 224.9,159.69 224.9,159.86 v2(224.89,159.87)
  BOTTOM w0.102: VRAM4.R10 203.12,163.44 203.12,163.12 203.34,162.9 v2(203.52,162.9) ; UG6.J47 224.38,160.22 224.28,160.12 224.28,159.93 224.38,159.82 224.85,159.82 v2(224.89,159.87)
VMB_WCKB01: length 29.9
  IN4 w0.102: v2(230.51,159.17) 230.51,159.59 230.81,159.89 230.81,160.05 231.79,161.02 231.79,168.83 231.07,169.54 231.07,177.04 229.37,178.75 228.34,178.75 228.22,178.62 227.83,178.62 227.09,179.37 225.63,179.37 225.37,179.63 225.37,181 225.15,181.22 224.89,181.22 v2(224.71,181.41)
  BOTTOM w0.102: v2(230.51,159.17) 230.85,159.51 UG6.K38
  BOTTOM w0.114: v2(224.71,181.41) 224.75,181.36 225.47,181.36 225.88,180.95 VRAM1.D4
VMB_WCKB01#: length 29.9
  IN4 w0.102: v2(224.66,180.61) 224.38,180.61 224.27,180.72 224.27,180.91 224.38,181.01 225.06,181.01 225.16,180.91 225.16,179.54 225.54,179.16 227,179.16 227.75,178.42 228.3,178.42 228.43,178.55 229.28,178.55 230.87,176.96 230.87,169.46 231.58,168.75 231.58,161.11 230.61,160.13 230.61,159.97 230.54,159.9 230.47,159.9 v2(230.37,160.01)
  BOTTOM w0.102: UG6.J38 230.82,160.19 230.82,159.96 230.64,159.78 230.5,159.78 230.37,159.91 v2(230.37,160.01)
  BOTTOM w0.114: VRAM1.D5 225.21,181.11 224.96,181.11 224.71,180.86 224.71,180.65 v2(224.66,180.61)
VMB_WCKB23: length 28.5
  IN4 w0.114: v2(222.14,181.34) 222.3,181.17 223.16,181.17 223.66,180.68 223.66,169.74 224.56,168.84 225.04,168.84 226.57,167.31 226.57,166.27 226.69,166.14 227.42,166.14 228.18,165.39 228.25,165.39 228.67,164.97 228.67,161.13 229,160.81 229,159.56 228.77,159.34 228.57,159.34 v2(228.41,159.17)
  BOTTOM w0.102: v2(228.41,159.17) 228.41,159.18 UG6.K41
  BOTTOM w0.114: v2(222.14,181.34) 221.27,181.34 VRAM1.D11
VMB_WCKB23#: length 28.6
  IN4 w0.114: v2(228.38,159.87) 228.36,159.84 228.36,159.68 228.49,159.55 228.68,159.55 228.78,159.65 228.78,160.72 228.46,161.04 228.46,164.88 228.16,165.17 228.09,165.17 227.33,165.93 226.6,165.93 226.36,166.18 226.36,167.22 224.95,168.62 224.47,168.62 223.44,169.65 223.44,180.59 223.08,180.96 222.19,180.96 222.05,180.82 222.05,180.66 v2(222.13,180.59)
  BOTTOM w0.102: v2(228.38,159.87) 228.99,159.87 229.06,159.94 229.06,160.11 228.93,160.24 228.77,160.24 UG6.J41
  BOTTOM w0.114: VRAM1.D10 222.05,180.95 222.18,180.81 222.18,180.64 v2(222.13,180.59)
VMB_WCKB45: length 19
  IN4 w0.114: v2(211.01,160.38) 211.16,160.24 211.16,159.82 211.49,159.48 212.01,159.48 212.27,159.75 214.18,159.75 214.41,159.51 214.41,159.31 215.42,158.31 215.42,157.86 215.66,157.61 215.66,156.93 216.15,156.44 219.82,156.44 220.05,156.21 220.71,156.21 220.93,156.43 222.03,156.43 223.32,155.14 224.02,155.14 v2(224.19,154.97)
  BOTTOM w0.102: UG6.T48 223.85,155.32 v2(224.19,154.97)
  BOTTOM w0.114: v2(211.01,160.38) 210.96,160.33 210.96,159.36 VRAM4.D4
VMB_WCKB45#: length 19
  IN4 w0.114: v2(224.2,155.68) 224.22,155.66 224.22,155.47 224.11,155.36 223.41,155.36 222.12,156.64 220.84,156.64 220.62,156.42 220.14,156.42 219.91,156.66 216.24,156.66 215.88,157.02 215.88,157.7 215.63,157.95 215.63,158.4 214.63,159.4 214.63,159.6 214.27,159.96 212.18,159.96 211.92,159.7 211.58,159.7 211.37,159.91 211.37,160.24 211.51,160.38 v2(211.72,160.38)
  BOTTOM w0.102: UG6.T47 224.42,155.32 224.2,155.54 v2(224.2,155.68)
  BOTTOM w0.114: VRAM4.D5 211.38,159.62 211.26,159.51 211.18,159.59 211.18,160 211.56,160.38 v2(211.72,160.38)
VMB_WCKB67: length 19.9
  IN4 w0.114: v2(211.73,162.91) 211.65,162.91 211.58,162.84 211.58,162.6 211.72,162.47 212.65,162.47 212.77,162.59 212.77,163.33 212.98,163.54 213.37,163.54 213.57,163.33 213.57,162.62 213.64,162.55 214.52,162.55 216.23,160.85 216.23,160.02 216.55,159.7 218.22,159.7 218.36,159.84 222.32,159.84 222.66,159.5 223.96,159.5 224.65,158.81 224.65,158.56 224.69,158.52 224.74,158.46 v2(224.9,158.46)
  BOTTOM w0.102: 211.73,163.55 211.38,163.91 VRAM4.D11 ; UG6.L47 224.55,158.81 224.76,158.6 v2(224.9,158.46)
  BOTTOM w0.114: 211.73,163.55 v2(211.73,162.91)
VMB_WCKB67#: length 19.9
  IN4 w0.114: v2(211.05,162.92) 211.05,162.92 211.24,162.92 211.36,162.8 211.36,162.51 211.63,162.25 212.74,162.25 212.99,162.5 212.99,163.24 213.07,163.32 213.28,163.32 213.35,163.24 213.35,162.53 213.55,162.34 214.43,162.34 216.01,160.76 216.01,159.93 216.46,159.48 218.31,159.48 218.45,159.62 222.23,159.62 222.57,159.28 223.87,159.28 224.43,158.72 224.43,158.55 224.32,158.43 v2(224.17,158.43)
  BOTTOM w0.102: v2(224.17,158.43) 224.25,158.51 224.25,158.84 224.12,158.96 223.97,158.96 223.85,158.84 UG6.L48
  BOTTOM w0.114: v2(211.05,162.92) 211.2,162.92 211.43,163.15 211.43,163.39 VRAM4.D10
VMC_CLK0: length 24.9
  IN4 w0.102: v2(250.99,176.82) 250.87,176.82 250.77,176.71 250.77,176.34 250.51,176.08 250.11,176.08 249.73,176.46 249.32,176.46 248.77,175.9 247.82,175.9 247.59,175.67 247.59,174.54 247.29,174.24 246.75,174.24 246.56,174.05 246.56,169.46 245.35,168.24 245.35,166.16 244.39,165.2 244.39,161.01 243.67,160.3 243.67,159.74 243.34,159.41 242.52,159.41 242.42,159.31 v2(242.42,159.15)
  BOTTOM w0.102: UG6.K22 v2(242.42,159.15)
  BOTTOM w0.114: v2(250.99,176.82) 250.63,177.18 VRAM3.J10
VMC_CLK0#: length 24.9
  IN4 w0.102: v2(250.24,176.82) 250.47,176.82 250.57,176.72 250.57,176.42 250.42,176.28 250.2,176.28 249.82,176.66 249.24,176.66 248.68,176.1 247.74,176.1 247.39,175.76 247.39,174.63 247.2,174.44 246.66,174.44 246.36,174.14 246.36,169.54 245.14,168.33 245.14,166.24 244.18,165.28 244.18,161.09 243.47,160.38 243.47,159.83 243.25,159.61 242.51,159.61 242.4,159.71 v2(242.4,159.88)
  BOTTOM w0.102: v2(242.4,159.88) 242.2,159.88 242.05,160.03 UG6.J22 ; v2(250.24,176.82) 250.4,176.82 250.63,176.6 VRAM3.K10
VMC_CLK1: length 28.5
  IN4 w0.102: v2(241.7,159.17) 241.7,159.36 241.63,159.43 241.37,159.43 241.12,159.67 241.12,160.17 241.6,160.65 241.78,160.65 242.09,160.95 242.09,165.8 241.94,165.94 241.26,165.94 241,166.2 241,167.76 242.17,168.92 243.61,168.92 244.45,169.76 244.45,176.68 243.7,177.43 240.27,177.43 239.71,176.86 239.4,176.86 239.3,176.76 v2(239.3,176.65)
  BOTTOM w0.102: UG6.K23 v2(241.7,159.17)
  BOTTOM w0.114: VRAM2.J10 239.68,176.65 v2(239.3,176.65)
VMC_CLK1#: length 28.4
  IN4 w0.102: v2(239.34,177.28) 239.34,177.17 239.44,177.06 239.62,177.06 240.19,177.63 243.78,177.63 244.65,176.76 244.65,169.67 243.69,168.72 242.25,168.72 241.21,167.67 241.21,166.29 241.35,166.15 242.03,166.15 242.29,165.88 242.29,160.87 241.87,160.44 241.68,160.44 241.33,160.09 241.33,159.76 241.45,159.63 241.6,159.63 241.71,159.74 v2(241.71,159.87)
  BOTTOM w0.102: v2(241.71,159.87) 241.35,160.22 UG6.J23
  BOTTOM w0.114: v2(239.34,177.28) 239.42,177.2 VRAM2.K10
VMC_DQ0: length 11.9
  IN2 w0.102: v2(257.02,170.82) 256.64,170.44 256.64,169.79 255.38,168.53 254.05,168.53 252.92,167.39 252.92,165.3 252.59,164.97 252.59,162.98 v2(252.9,162.67)
  BOTTOM w0.102: VRAM3.U2 256.64,171.2 v2(257.02,170.82)
  BOTTOM w0.161: UG6.F7 v2(252.9,162.67)
VMC_DQ1: length 19.5
  IN2 w0.102: v2(256.26,174.56) 256.63,174.19 258.03,174.19 259.44,172.78 259.44,169.55 256.03,166.15 256.03,164.24 254.53,162.74 254.53,162.27 254.69,162.11 254.69,161.69 254.27,161.28 v2(254.27,160.54)
  BOTTOM w0.102: VRAM3.M2 256.63,174.93 v2(256.26,174.56) ; v2(254.27,160.54) 253.95,160.86 UG6.H5
VMC_DQ2: length 12.7
  IN2 w0.102: v2(255.5,170.84) 253.95,170.84 251.59,168.48 251.59,163.71 251.79,163.51 251.79,162.87 252.2,162.45 v2(252.2,161.97)
  BOTTOM w0.102: VRAM3.U3 255.85,171.2 255.5,170.85 v2(255.5,170.84)
  BOTTOM w0.161: v2(252.2,161.97) UG6.F8
VMC_DQ3: length 15.8
  IN2 w0.102: v2(254.29,161.97) 254.29,162.81 255.63,164.15 255.63,166.43 258.75,169.54 258.75,172.7 258.04,173.42 257.41,173.42 257.02,173.81 v2(257.02,173.81)
  BOTTOM w0.102: v2(257.02,173.81) 257.01,173.81 VRAM3.N2
  BOTTOM w0.161: v2(254.29,161.97) 253.95,161.63 UG6.G5
VMC_DQ4: length 18.4
  IN2 w0.102: v2(255.5,173.8) 255.13,173.44 254.38,173.44 254.01,173.81 253.53,173.81 253.23,173.5 253.23,171.33 250.5,168.6 250.5,161.33 251.29,160.54 v2(251.48,160.54)
  BOTTOM w0.102: v2(251.48,160.54) 251.48,160.55 UG6.H8 ; v2(255.5,173.8) 255.5,173.8 255.86,173.45 VRAM3.P3
