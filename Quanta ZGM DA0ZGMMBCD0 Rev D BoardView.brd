# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USBP+_KB: length 77.2
  IN1 w0.086: v1(190.13,64.12) 189.96,64.12 189.83,64.25 189.83,64.41 190.02,64.6 190.44,64.6 191.13,65.29 192.69,65.29 193.91,64.08 195.26,64.08 195.44,64.26 195.44,64.87 195.26,65.06 194.23,65.06 193.34,65.95 193.34,66.07 193.64,66.37 193.76,66.37 194.21,65.93 194.5,65.93 194.86,66.28 194.86,66.58 194.42,67.02 194.42,67.14 194.72,67.44 194.84,67.44 195.64,66.64 195.64,66.34 195.42,66.12 195.42,65.82 195.81,65.44 196.07,65.44 196.61,65.97 196.61,66.98 195.49,68.1 195.49,68.22 195.79,68.52 195.91,68.52 197.19,67.24 197.45,67.24 197.83,67.63 197.83,67.91 196.57,69.17 196.57,69.29 196.87,69.59 196.99,69.59 197.46,69.12 197.72,69.12 198.12,69.51 198.12,69.77 197.64,70.25 197.64,70.37 197.94,70.67 198.06,70.67 198.6,70.13 198.91,70.13 199.26,70.48 199.26,70.78 198.72,71.32 198.72,71.44 199.12,71.84 199.12,72.4 199.87,73.15 199.87,73.59 200.19,73.91 200.79,73.91 201.83,74.95 202,74.95 202.18,74.77 202.44,74.77 202.76,75.09 202.76,75.51 202.64,75.63 202.64,75.85 202.82,76.03 203.89,76.03 204.85,76.99 204.85,77.1 205.06,77.3 205.06,77.55 205.67,78.17 206.9,78.17 207.18,78.45 208.31,78.45 208.65,78.78 208.65,79.13 208.26,79.52 208.26,79.98 208.04,80.19 207.86,80.19 v1(207.65,80.41)
  BOTTOM w0.102: U49.L3 206.68,78.24 206.81,78.24 206.88,78.3 206.88,78.95 207.03,79.1 207.03,79.93 207.27,80.17 207.41,80.17 v1(207.65,80.41)
  BOTTOM w0.14: R1144.1 183.9,48.23 183.9,48.6 184.19,48.9 184.19,50.32 185.29,51.42 185.29,52.94 185.43,53.08 187.53,53.08 187.87,53.42 187.87,53.98 187.57,54.27 185.43,54.27 185.29,54.41 185.29,55 185.46,55.17 186.72,55.17 187.02,55.47 187.02,56.79 186.72,57.08 186.55,57.08 186.41,57.22 186.41,57.59 186.55,57.73 186.72,57.73 187.02,58.03 187.02,61.14 187.85,61.97 189.01,61.97 189.92,62.88 189.92,63.91 v1(190.13,64.12)
USBP+_MB: length 208.6
  IN1 w0.086: v1(61.17,56.18) 61.45,56.18 61.61,56.34 61.61,56.93 62.64,57.97 64.8,57.97 65.64,58.8 77.68,58.8 78.73,59.84 90.23,59.84 90.56,59.51 91.56,59.51 91.81,59.77 109.97,59.77 110.46,59.28 117.62,59.28 118.29,59.96 122.68,59.96 123.31,60.59 133.08,60.59 133.4,60.91 143.24,60.91 143.98,61.64 148.63,61.64 149.62,62.64 157.83,62.64 158.2,62.27 160.67,62.27 161.15,61.79 163.56,61.79 163.83,62.06 166,62.06 167.79,63.86 169.05,63.86 169.42,64.23 176.73,64.23 176.94,64.44 187.29,64.44 190.38,67.52 192.27,67.52 197.15,72.41 197.15,73.86 200.09,76.8 200.57,76.8 202.78,79 204.24,79 205.45,80.21 205.45,81.64 206.32,82.51 206.6,82.51 v1(206.8,82.71)
  IN4 w0.086: v1(61.17,56.18) 61.52,56.52 61.52,56.65 61.42,56.74 60.96,56.74 57.91,53.7 40.69,53.7 37.54,50.55 26.13,50.55 25.71,50.97 25.71,51.73 v1(25.36,52.07)
  BOTTOM w0.102: v1(206.8,82.71) 206.76,82.67 206.16,82.67 205.31,81.82 205.31,78.86 205.34,78.82 205.34,78.48 U49.K4
  BOTTOM w0.14: v1(25.36,52.07) 25.58,52.29 25.58,52.44 24.81,53.22 24.69,53.22 24.57,53.1 U52.3
USBP+_MB_C: length 7.7
  BOTTOM w0.14: U52.10 20.38,53.1 20.24,53.25 20.04,53.25 19.85,53.05 19.85,52.65 19.44,52.24 19.44,51.6 19.69,51.35 20.54,51.35 21.14,50.75 21.14,49.9 20.75,49.52 20.75,48.71 21,48.46 21.2,48.46 R1138.1
USBP+_MB_C_R: length 14.7
  IN4 w0.086: CN15.3 16.27,52.38 16.36,52.47 16.99,52.47 17.11,52.35 17.11,49.58 17.69,48.99 17.69,46.12 17.97,45.85 18.18,45.85 v1(18.5,45.53)
  BOTTOM w0.14: v1(18.5,45.53) 18.67,45.71 19.05,45.71 19.71,45.05 20.61,45.05 20.91,45.34 20.91,45.53 20.96,45.59 D72.2 20.96,46.14 21.26,46.44 R1138.2
USBP+_TC1: length 271.6
  TOP w0.14: v1(20.58,95.8) 20.31,95.53 20.04,95.53 19.96,95.62 U8.2 U8.7 17.88,95.62 17.81,95.54 17.31,95.54 15.91,94.14 15.68,94.14 v1(15.46,94.37)
  IN4 w0.086: v2(8.2,93.25) 8.4,93.06 12.5,93.06 13.51,94.07 15.17,94.07 v1(15.46,94.37) ; v1(204.32,80.46) 204.22,80.55 204.22,80.74 204.42,80.94 204.7,80.94 204.87,80.77 204.87,77.63 204.43,77.19 204.43,76.77 203.69,76.02 202.79,76.02 202.18,76.63 200.01,76.63 199.83,76.46 198.4,76.46 192.72,70.78 191.71,70.78 191,71.49 189.91,71.49 189.62,71.19 180.47,71.19 180.23,70.96 178.66,70.96 177.83,70.13 164.79,70.13 164.43,70.49 152.75,70.49 152.38,70.12 151.01,70.12 148.64,67.75 147.97,67.75 146.25,66.03 140.71,66.03 138.39,63.71 134.36,63.71 132.5,61.85 126.75,61.85 122.57,57.67 120.68,57.67 117.9,54.88 112.14,54.88 110.21,56.81 108.06,56.81 103.58,61.29 97.82,61.29 94.78,64.33 84.88,64.33 84.26,63.71 63.72,63.71 62.78,64.64 44.11,64.64 43.57,65.19 29.04,65.19 28.82,65.41 28.82,65.98 25.71,69.09 25.71,73.29 21.41,77.59 21.41,78.43 17.76,82.08 15.1,82.08 11.76,85.42 11.76,88.7 15.11,92.04 19.28,92.04 21.82,94.58 21.82,95.19 21.52,95.49 20.68,95.49 20.58,95.59 v1(20.58,95.8)
  BOTTOM w0.102: U49.G5 204.44,77.8 204.58,77.8 204.68,77.9 204.68,78.99 204.83,79.14 204.83,80.71 204.63,80.91 204.22,80.91 204.11,80.81 204.11,80.56 204.22,80.46 v1(204.32,80.46)
  BOTTOM w0.14: CN5.A6 9.58,92.85 9.73,93 10.07,93 10.41,93.35 10.63,93.35 10.68,93.31 D57.2 11.12,93.31 11.4,93.03 13.18,93.03 13.61,92.6 14.82,92.6 15.04,92.82 15.76,92.82 16.23,93.28 16.23,93.84 15.88,94.18 15.64,94.18 v1(15.46,94.37) ; v2(8.2,93.25) 8.12,93.25 7.96,93.1 CN5.B6
USBP+_TC2: length 242.8
  TOP w0.14: v1(15.71,79.06) 15.9,78.88 16.16,78.88 16.22,78.93 U15.7 16.97,78.93 17.04,78.86 17.47,78.86 17.54,78.93 U15.2 18.31,78.93 18.39,78.84 18.66,78.84 v1(18.93,79.11)
  IN4 w0.086: v1(15.71,79.06) 15.71,78.91 15.61,78.8 15.33,78.8 15.02,78.48 14.3,78.48 13.73,79.06 8.4,79.06 v2(8.2,79.25) ; v1(18.93,79.11) 18.69,78.87 18.38,78.87 17.97,78.47 17.97,77.58 19.45,76.11 21.04,76.11 23.44,73.71 23.44,70.96 24.83,69.56 24.83,67.89 25.38,67.34 26.23,67.34 28.1,65.47 28.1,65.11 28.74,64.47 34.63,64.47 35.39,63.7 42.95,63.7 43.16,63.92 62.07,63.92 63.11,62.88 85.36,62.88 85.84,63.36 92.6,63.36 95.52,60.44 102.41,60.44 107.38,55.47 107.38,55.06 107.73,54.71 108.56,54.71 108.89,55.04 110.32,55.04 111.39,53.98 112.95,53.98 113.13,54.16 118.19,54.16 120.98,56.95 122.87,56.95 127.05,61.13 133.13,61.13 134.99,62.99 138.69,62.99 140.98,65.28 146.52,65.28 148.17,66.92 148.84,66.92 151.31,69.4 152.68,69.4 153.05,69.77 164.08,69.77 164.44,69.41 177.06,69.41 177.53,68.94 179.82,68.94 180.5,69.62 182.76,69.62 183.06,69.92 185.83,69.92 185.97,70.06 193.42,70.06 199.1,75.73 200.13,75.73 200.31,75.91 201.57,75.91 203.08,74.41 204.21,74.41 205.15,73.47 206.65,73.47 207.23,74.04 207.9,74.04 208.63,74.77 v1(208.96,74.77)
  BOTTOM w0.102: U49.R11 208.39,74.83 208.91,74.83 v1(208.96,74.77)
  BOTTOM w0.14: v1(15.71,79.06) 15.88,78.9 16.29,78.9 16.72,78.46 16.72,77.9 15.93,77.1 14.5,77.1 13.72,77.88 13.72,78.65 13.32,79.05 11.42,79.05 11.14,79.32 D59.2 10.38,79.32 10.09,79.03 9.76,79.03 9.58,78.85 CN9.A6 ; CN9.B6 7.96,79.1 8.12,79.25 v2(8.2,79.25)
USBP+_WLAN: length 103.5
  IN4 w0.086: v1(208.55,73.72) 208.34,73.5 208.13,73.5 207.85,73.23 207.85,72.59 208.1,72.35 208.79,72.35 209.39,72.95 209.39,73.86 209.72,74.19 211.31,74.19 211.75,73.76 212.13,73.76 212.43,73.45 212.43,72.06 213.68,70.82 217.33,70.82 217.84,71.32 218.86,71.32 219.24,70.94 220.8,70.94 221.26,70.49 222.27,70.49 222.44,70.66 226.05,70.66 227.57,69.13 227.57,65.27 227.83,65.02 227.83,59.79 228.25,59.37 228.78,59.37 229.36,58.79 229.36,58.61 229.82,58.15 230.15,58.15 230.92,57.38 230.92,56.78 231.29,56.41 232.26,56.41 234.65,54.02 234.65,52.79 236.76,50.69 240.53,50.69 242.02,49.2 255.5,49.2 256.73,50.42 261.91,50.42 263.92,52.44 267.45,52.44 267.91,51.97 270.13,51.97 271.88,53.73 274.65,53.73 279.59,58.67 279.59,58.92 280.04,59.37 280.04,60.1 v1(280.31,60.37)
  BOTTOM w0.102: v1(280.31,60.37) 280.12,60.56 280.12,60.77 280.84,61.49 CN12.3 ; v1(208.55,73.72) 208.14,73.31 U49.P13
USBP+_WWAN: length 112.1
  IN1 w0.086: v1(205.31,76.96) 205.65,77.3 205.65,77.42 206.02,77.79 206.99,77.79 207.29,78.1 208.51,78.1 209.76,79.35 212.85,79.35 214.21,80.71 214.71,80.71 214.89,80.53 216.38,80.53 216.62,80.77 218.51,80.77 218.82,80.47 219.7,80.47 220.04,80.82 220.62,80.82 220.93,80.51 223.71,80.51 223.85,80.37 224.35,80.37 225.72,79 229.73,79 230.24,78.48 230.24,77.42 232.58,75.08 234.89,75.08 235.73,74.24 236.06,74.24 237.35,72.95 242.71,72.95 243.1,73.34 246.45,73.34 247.85,74.74 248.15,74.74 253.38,79.97 254.15,79.97 256.13,81.96 268,81.96 268.57,82.53 282.46,82.53 284.24,84.3 288.82,84.3 289.04,84.52 292.49,84.52 293.17,85.21 295.54,85.21 296.48,86.15 296.48,86.85 296.36,86.97 v1(296.2,86.97)
  BOTTOM w0.102: U49.H7 204.56,76.63 204.46,76.73 204.46,76.97 204.57,77.08 205.19,77.08 v1(205.31,76.96)
  BOTTOM w0.14: v1(296.2,86.97) 296.22,86.97 296.46,87.21 296.46,87.88 296.79,88.22 296.79,91.36 297.35,91.92 298.6,91.92 298.74,92.06 R841.2
USBP+_WWAN_R: length 1.9
  BOTTOM w0.14: CN7.7 299.88,91.75 299.71,91.92 299.43,91.92 R841.1
USBP-_CCD: length 222.7
  TOP w0.14: v1(282.31,192.38) 282.11,192.57 281.77,192.57 281.63,192.43 281.63,190.25 280.93,189.55 280.24,189.55 R66.1
  IN4 w0.086: v1(207.66,74.68) 207.5,74.84 206.65,74.84 206.32,75.17 206.32,76.64 206.63,76.95 206.63,77.48 205.43,78.67 205.43,82.99 205.07,83.36 205.07,85.94 202.2,88.81 202.2,89.52 202.83,90.15 202.83,93.6 206.59,97.35 208.92,97.35 209.5,96.77 210.63,96.77 210.76,96.64 211.22,96.64 211.49,96.91 211.49,97.42 209.61,99.3 207.67,99.3 205.73,101.25 203.69,101.25 203.11,101.83 203.11,103.29 201.95,104.45 201.95,106.7 201.53,107.12 200.66,107.12 199.41,108.38 199.41,109.96 200.4,110.96 203.97,110.96 205.31,112.31 247.09,112.31 247.7,112.92 250.5,112.92 251.62,111.79 262.25,111.79 262.61,112.14 275.64,112.14 281.41,117.92 281.41,140.12 281.21,140.33 281.21,152.07 282.14,153 282.14,189.19 283.58,190.63 283.58,192.18 283.11,192.65 282.58,192.65 v1(282.31,192.38)
  BOTTOM w0.102: U49.N11 207.13,74.54 207.28,74.39 207.52,74.39 207.66,74.52 v1(207.66,74.68)
USBP-_CCD_R: length 10.3
  TOP w0.14: CN2.29 271.04,189.35 271.08,189.39 272.23,189.39 272.68,189.84 276.2,189.84 276.43,189.61 276.95,189.61 277.01,189.56 D6.1 277.74,189.56 278.15,189.15 279.47,189.15 279.61,189.29 R66.2
USBP-_DB1: length 148.2
  TOP w0.14: U7.2 316.22,96.22 316.04,96.04 315.78,96.04 315.48,95.74 315.48,94.14 315.74,93.88 315.74,92.79 v1(315.45,92.5)
  IN4 w0.086: v1(207.01,76.34) 207.24,76.11 207.52,76.11 207.76,75.87 208.28,75.87 209.96,77.55 210.96,77.55 211.29,77.88 212.31,77.88 212.6,77.58 215.21,77.58 217.75,80.13 217.75,80.71 218.84,81.8 220.64,81.8 220.83,81.61 222.63,81.61 223.01,81.98 223.01,82.84 223.79,83.62 223.79,84.23 224.26,84.7 224.84,84.7 225.03,84.5 230.6,84.5 231.92,83.19 231.92,82.32 236.78,77.46 242.15,77.46 245.99,73.62 245.99,68.89 247.96,66.92 251.03,66.92 253.48,69.37 262.92,69.37 264.24,70.69 269.33,70.69 269.93,70.09 271.8,70.09 274.16,72.44 274.16,74.18 275.49,75.52 275.49,76.89 276.16,77.56 276.16,80.67 277.17,81.67 280.92,81.67 281.7,80.89 294.67,80.89 297.6,83.82 297.6,85.04 298.99,86.43 298.99,87.45 301.77,90.23 307.02,90.23 308.11,91.32 312.73,91.32 313.35,91.95 315.7,91.95 315.79,92.03 315.79,92.16 v1(315.45,92.5)
  BOTTOM w0.102: U49.K7 205.93,76.67 206.68,76.67 v1(207.01,76.34)
USBP-_DB1_C: length 23.8
  TOP w0.14: v1(320.39,90.62) 320.57,90.8 320.84,90.8 321.26,91.22 321.26,95.85 320.97,96.14 320.89,96.22 U7.11
  IN4 w0.086: v1(320.39,90.62) 320.39,90.78 320.25,90.92 319.97,90.92 319.84,90.79 319.84,88.08 320.65,87.26 320.65,81.06 320.03,80.44 320.03,79.8 319.32,79.1 318.89,79.1 v1(318.62,78.82)
  BOTTOM w0.14: CN10.16 316.8,78.91 316.92,79.03 318.41,79.03 v1(318.62,78.82)
USBP-_DB2: length 139.1
  TOP w0.14: U6.2 309.79,96.22 309.67,96.11 308.83,96.11 308.53,95.81 307.79,95.81 307.37,96.23 307.37,96.53 307.53,96.69 v1(307.75,96.69)
  IN4 w0.086: v1(206.32,80.64) 206.54,80.42 206.7,80.42 207,80.12 207,78.87 207.5,78.37 210.52,78.37 210.64,78.5 214.89,78.5 216.34,79.95 216.34,80.5 217.05,81.2 217.05,81.83 218.41,83.19 222.57,83.19 223.15,83.77 223.15,84.38 224.03,85.26 225.2,85.26 225.4,85.06 230.83,85.06 232.47,83.42 232.47,82.55 236.18,78.84 247.19,78.84 252.4,73.64 253.38,73.64 254.12,72.9 254.12,72.58 254.22,72.47 254.22,71.9 255.1,71.03 256.67,71.03 257.11,71.47 263.01,71.47 263.24,71.25 266.7,71.25 267.12,71.67 268.09,71.67 268.15,71.72 270.79,71.72 270.97,71.9 270.97,72.58 271.46,73.07 272.08,73.07 274.48,75.47 274.48,77.06 275.61,78.19 275.61,80.9 276.94,82.23 281.15,82.23 281.94,81.45 287.81,81.45 288.33,81.97 294.76,81.97 297.04,84.25 297.04,85.27 298.43,86.66 298.43,87.78 301.51,90.86 301.51,91.81 304.08,94.37 304.08,95.93 305.59,97.44 307.13,97.44 307.41,97.17 307.41,96.78 307.49,96.69 v1(307.75,96.69)
  BOTTOM w0.102: U49.L4 206.02,78.12 205.92,78.22 205.92,78.37 206.01,78.46 206.01,78.82 205.72,79.11 205.72,80.13 205.94,80.35 206.17,80.35 206.32,80.5 v1(206.32,80.64)
USBP-_DB2_C: length 29.1
  TOP w0.14: U6.11 314.07,96.22 314.15,96.14 314.43,96.14 314.91,95.66 314.91,94.17 314.43,93.68 314.43,92.47 316.07,90.84 316.07,89.66 v1(316.24,89.49)
  IN4 w0.086: v1(317.78,74.23) 318.06,74.51 318.36,74.51 318.92,75.06 318.92,77.07 318.67,77.32 317.56,77.32 315.73,79.15 315.73,80.93 316.45,81.66 316.45,86.53 316.91,86.99 316.91,87.86 315.98,88.79 315.98,89.23 v1(316.24,89.49)
  BOTTOM w0.14: CN10.25 316.77,74.41 316.89,74.53 317.48,74.53 v1(317.78,74.23)
USBP-_KB: length 77.2
  IN1 w0.086: v1(207.65,79.76) 207.65,79.9 207.78,80.03 207.97,80.03 208.09,79.91 208.09,79.45 208.48,79.06 208.48,78.85 208.24,78.61 207.11,78.61 206.83,78.33 205.6,78.33 204.89,77.62 204.89,77.37 204.69,77.17 204.69,77.06 203.82,76.19 202.75,76.19 202.47,75.92 202.47,75.56 202.59,75.44 202.59,75.16 202.37,74.94 202.25,74.94 202.07,75.12 201.76,75.12 200.72,74.08 200.12,74.08 199.7,73.66 199.7,73.22 198.95,72.47 198.95,71.91 198.55,71.51 198.55,71.25 199.09,70.72 199.09,70.55 198.84,70.3 198.67,70.3 198.13,70.83 197.87,70.83 197.48,70.44 197.48,70.18 197.95,69.7 197.95,69.58 197.65,69.28 197.53,69.28 197.06,69.76 196.8,69.76 196.4,69.36 196.4,69.1 197.67,67.84 197.67,67.7 197.38,67.41 197.25,67.41 195.98,68.68 195.72,68.68 195.33,68.29 195.33,68.03 196.44,66.92 196.44,66.04 196,65.6 195.88,65.6 195.59,65.89 195.59,66.05 195.81,66.27 195.81,66.7 194.91,67.61 194.65,67.61 194.25,67.21 194.25,66.95 194.69,66.51 194.69,66.35 194.43,66.09 194.27,66.09 193.83,66.53 193.57,66.53 193.18,66.14 193.18,65.88 194.16,64.89 195.19,64.89 195.28,64.81 195.28,64.33 195.19,64.24 193.97,64.24 192.76,65.46 191.06,65.46 190.37,64.76 189.95,64.76 189.66,64.48 189.66,64.3 189.48,64.12 v1(189.28,64.12)
  BOTTOM w0.102: U49.M4 207.08,78.21 207.08,78.87 207.23,79.02 207.23,79.85 207.35,79.97 207.44,79.97 v1(207.65,79.76)
  BOTTOM w0.14: v1(189.28,64.12) 189.42,64.12 189.65,63.88 189.65,62.99 188.9,62.24 187.74,62.24 186.75,61.25 186.75,58.14 186.61,58 186.44,58 186.14,57.7 186.14,57.11 186.44,56.82 186.61,56.82 186.75,56.68 186.75,55.58 186.61,55.44 185.35,55.44 185.03,55.11 185.03,54.3 185.32,54.01 187.46,54.01 187.6,53.87 187.6,53.53 187.42,53.35 185.32,53.35 185.03,53.05 185.03,51.53 183.92,50.43 183.92,49.01 183.63,48.71 183.63,48.22 R1143.1
USBP-_MB: length 208.6
  IN1 w0.086: v1(206.76,82.06) 206.76,82.23 206.65,82.34 206.39,82.34 205.62,81.57 205.62,80.15 204.31,78.84 202.85,78.84 200.64,76.63 200.16,76.63 197.32,73.79 197.32,72.34 192.33,67.36 190.45,67.36 187.36,64.27 177,64.27 176.8,64.06 169.49,64.06 169.12,63.69 167.86,63.69 166.06,61.9 163.9,61.9 163.63,61.63 161.08,61.63 160.6,62.1 158.13,62.1 157.76,62.47 149.69,62.47 148.69,61.48 144.05,61.48 143.31,60.74 133.46,60.74 133.14,60.42 123.38,60.42 122.75,59.79 118.36,59.79 117.69,59.12 110.39,59.12 109.9,59.6 91.88,59.6 91.63,59.35 90.49,59.35 90.16,59.68 78.79,59.68 77.75,58.64 65.7,58.64 64.87,57.8 62.71,57.8 61.77,56.87 61.77,56.43 v1(62.02,56.18)
  IN4 w0.086: v1(26.21,52.07) 25.87,51.73 25.87,51.04 26.2,50.71 37.47,50.71 40.62,53.86 57.84,53.86 60.89,56.91 61.49,56.91 61.68,56.71 61.68,56.52 v1(62.02,56.18)
  BOTTOM w0.102: v1(206.76,82.06) 206.65,82.06 206.55,82.16 206.55,82.36 206.45,82.47 206.24,82.47 206.08,82.3 206.08,82.16 206.15,82.09 206.15,81.93 206.05,81.83 205.91,81.83 205.83,81.91 205.69,81.91 205.51,81.74 205.51,78.94 205.55,78.91 205.55,78.58 205.62,78.51 205.68,78.51 U49.K3
  BOTTOM w0.14: v1(26.21,52.07) 25.85,52.43 25.85,52.55 24.92,53.49 24.71,53.49 24.59,53.6 U52.2
USBP-_MB_C: length 7.7
  BOTTOM w0.14: U52.11 20.27,53.6 20.18,53.51 19.93,53.51 19.58,53.16 19.58,52.76 19.17,52.35 19.17,51.49 19.58,51.08 20.43,51.08 20.52,50.99 20.87,50.64 20.87,50.01 20.48,49.63 20.48,48.71 R1137.1
USBP-_MB_C_R: length 14.7
  IN4 w0.086: v1(18.5,46.38) 18.5,46.1 18.41,46.01 18.04,46.01 17.86,46.19 17.86,49.06 17.28,49.65 17.28,52.41 17.06,52.63 16.36,52.63 16.27,52.72 CN15.2
  BOTTOM w0.14: v1(18.5,46.38) 18.5,46.11 18.64,45.98 19.16,45.98 19.82,45.31 20.5,45.31 20.64,45.45 20.64,45.57 20.59,45.62 D72.1 20.59,46.14 20.29,46.44 R1137.2
USBP-_TC1: length 271.6
  TOP w0.14: v1(20.6,94.94) 20.27,95.27 20,95.27 19.95,95.22 U8.1 U8.8 17.88,95.22 17.82,95.28 17.42,95.28 16.01,93.86 15.71,93.86 v1(15.48,93.63)
  IN4 w0.086: v2(8.2,92.69) 8.41,92.9 12.57,92.9 13.58,93.91 15.15,93.91 15.15,93.91 15.2,93.91 v1(15.48,93.63) ; v1(204.29,81.32) 204.51,81.1 204.77,81.1 205.03,80.84 205.03,77.56 204.6,77.12 204.6,76.7 203.76,75.86 202.72,75.86 202.11,76.47 200.08,76.47 199.9,76.29 198.46,76.29 192.79,70.61 191.64,70.61 190.93,71.32 189.98,71.32 189.68,71.03 180.53,71.03 180.3,70.79 178.73,70.79 177.9,69.96 164.72,69.96 164.36,70.32 152.82,70.32 152.45,69.95 151.08,69.95 148.71,67.59 148.04,67.59 146.32,65.86 140.77,65.86 138.46,63.55 134.43,63.55 132.57,61.68 126.82,61.68 122.64,57.5 120.75,57.5 117.96,54.72 112.07,54.72 110.15,56.64 107.99,56.64 103.51,61.13 97.76,61.13 94.71,64.17 84.95,64.17 84.33,63.55 63.65,63.55 62.72,64.48 44.04,64.48 43.5,65.02 28.97,65.02 28.65,65.34 28.65,65.91 25.54,69.02 25.54,73.22 21.24,77.52 21.24,78.36 17.69,81.92 15.04,81.92 11.6,85.35 11.6,88.76 15.04,92.2 19.21,92.2 21.66,94.65 21.66,95.12 21.45,95.33 20.98,95.33 v1(20.6,94.94)
  BOTTOM w0.102: U49.H5 204.89,77.78 204.89,78.91 205.03,79.05 205.03,80.8 204.71,81.11 204.5,81.11 v1(204.29,81.32)
  BOTTOM w0.14: v2(8.2,92.69) 8.11,92.6 CN5.B7 ; CN5.A7 9.58,93.35 9.66,93.27 9.96,93.27 10.3,93.61 10.56,93.61 10.63,93.68 D57.1 11.18,93.68 11.72,94.22 12.33,94.22 12.63,93.93 12.63,93.44 12.77,93.3 13.3,93.3 13.72,92.87 14.71,92.87 14.93,93.08 15.65,93.08 15.96,93.39 15.96,93.73 15.77,93.92 15.62,93.92 15.48,93.78 v1(15.48,93.63)
USBP-_TC2: length 242.8
  TOP w0.14: v1(18.95,78.25) 18.62,78.58 18.35,78.58 18.3,78.53 U15.1 17.56,78.53 17.51,78.53 17.45,78.6 17.13,78.6 17.06,78.53 U15.8 16.27,78.53 16.19,78.61 16.01,78.61 v1(15.74,78.34)
  IN4 w0.086: v1(208.72,75.41) 208.73,75.41 208.82,75.33 208.82,75.19 207.83,74.2 207.16,74.2 206.59,73.63 205.22,73.63 204.28,74.57 203.14,74.57 201.64,76.08 200.24,76.08 200.06,75.9 199.03,75.9 193.35,70.22 185.9,70.22 185.77,70.08 182.99,70.08 182.7,69.79 180.43,69.79 179.75,69.11 177.59,69.11 177.13,69.57 164.51,69.57 164.15,69.93 152.98,69.93 152.61,69.56 151.24,69.56 148.77,67.09 148.1,67.09 146.45,65.44 140.91,65.44 138.62,63.16 134.92,63.16 133.06,61.29 126.98,61.29 122.8,57.11 120.91,57.11 118.13,54.32 113.06,54.32 112.88,54.14 111.46,54.14 110.39,55.21 108.82,55.21 108.49,54.88 107.8,54.88 107.55,55.13 107.55,55.54 102.48,60.61 95.59,60.61 92.67,63.53 85.77,63.53 85.29,63.05 63.18,63.05 62.14,64.09 43.1,64.09 42.88,63.87 35.46,63.87 34.7,64.63 28.81,64.63 28.26,65.18 28.26,65.54 26.3,67.51 25.45,67.51 25,67.96 25,69.63 23.6,71.03 23.6,73.78 21.11,76.27 19.52,76.27 18.14,77.65 18.14,78.4 18.45,78.71 18.86,78.71 18.95,78.62 v1(18.95,78.25) ; v1(15.74,78.34) 15.74,78.46 15.57,78.63 15.4,78.63 15.09,78.32 14.23,78.32 13.66,78.89 8.4,78.89 v2(8.2,78.69)
  BOTTOM w0.102: U49.P9 v1(208.72,75.41)
  BOTTOM w0.14: CN9.B7 8.11,78.6 v2(8.2,78.69) ; v1(15.74,78.34) 15.74,78.49 15.88,78.63 16.18,78.63 16.46,78.35 16.46,78.01 15.82,77.37 14.61,77.37 13.99,77.99 13.99,78.76 13.43,79.31 12.77,79.31 12.63,79.45 12.63,79.89 12.33,80.18 11.68,80.18 11.2,79.7 D59.1 10.65,79.7 10.54,79.59 10.27,79.59 9.98,79.29 9.66,79.29 9.6,79.35 CN9.A7
USBP-_WLAN: length 103.5
  IN4 w0.086: v1(279.63,60.38) 279.87,60.14 279.87,59.44 279.42,58.99 279.42,58.74 274.58,53.89 271.82,53.89 270.06,52.14 267.98,52.14 267.52,52.6 263.86,52.6 261.84,50.59 256.66,50.59 255.43,49.36 242.08,49.36 240.6,50.85 236.83,50.85 234.81,52.86 234.81,54.09 232.33,56.58 231.36,56.58 231.09,56.85 231.09,57.45 230.22,58.32 229.89,58.32 229.53,58.67 229.53,58.85 228.84,59.54 228.32,59.54 228,59.86 228,65.09 227.74,65.34 227.74,69.2 226.11,70.83 222.37,70.83 222.2,70.65 221.33,70.65 220.87,71.11 219.3,71.11 218.93,71.49 217.77,71.49 217.26,70.98 213.75,70.98 212.6,72.13 212.6,73.52 212.19,73.93 211.81,73.93 211.38,74.36 209.65,74.36 209.22,73.93 209.22,73.02 208.72,72.51 208.17,72.51 208.02,72.66 208.02,73.16 208.2,73.34 208.43,73.34 208.57,73.2 208.57,73.07 v1(208.48,72.99)
  BOTTOM w0.102: U49.P15 208.09,72.59 v1(208.48,72.99) ; v1(279.63,60.38) 279.81,60.38 279.92,60.5 279.92,60.86 280.75,61.69 281.94,61.69 282.24,61.99 CN12.5
USBP-_WWAN: length 112.1
  IN1 w0.086: v1(296.86,86.97) 296.65,86.76 296.65,86.08 295.61,85.04 293.24,85.04 292.56,84.36 289.11,84.36 288.89,84.14 284.31,84.14 282.53,82.36 268.64,82.36 268.07,81.79 256.2,81.79 254.22,79.81 253.45,79.81 248.22,74.58 247.92,74.58 246.52,73.18 243.17,73.18 242.77,72.78 237.29,72.78 235.99,74.08 235.66,74.08 234.83,74.91 232.51,74.91 230.08,77.35 230.08,78.42 229.66,78.83 225.65,78.83 224.28,80.2 223.78,80.2 223.64,80.34 220.86,80.34 220.55,80.65 220.11,80.65 219.76,80.3 218.75,80.3 218.44,80.61 216.69,80.61 216.45,80.37 214.82,80.37 214.65,80.54 214.27,80.54 212.92,79.19 209.83,79.19 208.58,77.93 207.36,77.93 207.06,77.62 206.09,77.62 205.82,77.35 205.82,76.55 205.59,76.32 v1(205.6,76.32)
  BOTTOM w0.102: U49.G7 204.31,76.59 204.57,76.33 204.82,76.33 204.84,76.34 205.13,76.34 205.15,76.32 v1(205.6,76.32)
  BOTTOM w0.14: R845.2 298.49,91.65 297.46,91.65 297.06,91.25 297.06,88.1 296.72,87.77 296.72,87.11 v1(296.86,86.97)
USBP-_WWAN_R: length 2
  BOTTOM w0.14: CN7.9 300.15,91.25 299.92,91.49 299.76,91.49 299.6,91.66 299.44,91.66 R845.1
VCORE_CSN1: length 44.6
  IN2 w0.203: v1(121.86,202.4) 121.23,203.02 116.6,203.02 114.83,204.79 v1(114.83,204.99)
  IN3 w0.203: v1(112.91,182.74) 112.54,183.11 111.8,183.11 111.22,183.69 111.22,187.76 112.31,188.85 113.48,188.85 116.5,191.88 116.5,195.4 115.81,196.09 115.81,201.04 114.48,202.38 114.48,204.79 114.68,204.99 v1(114.83,204.99)
  BOTTOM w0.203: v1(121.86,202.4) 122.26,202.8 PR420.1 ; PR6041.1 114.13,204.29 v1(114.83,204.99) 114.83,205.99 115.15,206.31 PC329.1 116.97,207.99 116.97,208.71 117.39,209.13 PU20.22 ; PR494.2 112.98,182.81 v1(112.91,182.74)
VCORE_CSN2: length 38.8
  IN2 w0.203: v1(116.06,205) 116.06,204.93 117.62,203.37 121.87,203.37 123,202.24 v1(123.24,202.24)
  IN3 w0.203: v1(121.72,182.51) 121.43,182.81 120.85,182.81 120.2,183.46 120.2,189.88 121.19,190.88 121.19,197.45 123.36,199.62 123.36,201.74 123.24,201.86 v1(123.24,202.24)
  BOTTOM w0.14: v1(116.06,205) 116.01,205.05 116.01,205.85 116.44,206.27 PC328.1
  BOTTOM w0.152: PU20.20 118.34,207.87 117.6,207.12 117.24,207.12 PC328.1
  BOTTOM w0.203: PR6040.1 116.06,204.99 v1(116.06,205) ; PR421.1 123.23,202.25 v1(123.24,202.24) ; PR495.1 122.19,182.81 121.89,182.51 v1(121.72,182.51)
VCORE_CSN3: length 40.1
  IN2 w0.203: v1(117.19,205.02) 118.49,203.73 121.99,203.73 122.67,203.05 123.58,203.05 v1(124.21,202.43)
  IN3 w0.203: v1(130.72,182.81) 130.55,182.98 129.82,182.98 128.88,183.92 128.88,188.38 129.87,189.37 129.87,195.47 124.55,200.79 124.55,202.09 v1(124.21,202.43)
  BOTTOM w0.14: PC326.1 117.19,205.87 v1(117.19,205.02)
  BOTTOM w0.152: PC326.1 117.67,206.33 119.15,207.81 PU20.18
  BOTTOM w0.203: PR422.1 v1(124.21,202.43) ; v1(117.19,205.02) 117.16,205 117.16,204.44 PR6039.1 ; PR496.1 v1(130.72,182.81)
VCORE_CSN4: length 47.9
  IN2 w0.203: v1(125.44,202.38) 124.29,203.52 122.83,203.52 122.26,204.09 119.28,204.09 v1(118.32,205.05)
  IN3 w0.203: v1(125.44,202.38) 125.44,202.27 128.99,198.72 138.16,198.72 139.53,197.35 139.53,183.78 139.96,183.35 v1(139.96,182.97)
  BOTTOM w0.152: v1(118.32,205.05) 118.32,205.79 118.81,206.28 PC327.1
  BOTTOM w0.203: v1(139.96,182.97) 140.11,182.81 PR497.1 ; v1(125.44,202.38) 125.35,202.47 PR423.1 ; v1(118.32,205.05) 118.32,204.78 118.54,204.55 PR6038.1 ; PC327.1 119.95,207.46 PU20.16
VCORE_CSN5: length 56.4
  IN2 w0.203: v1(126.58,202.44) 125.1,203.92 123.2,203.92 122.63,204.48 120.09,204.48 v1(119.55,205.02)
  IN3 w0.203: v1(126.58,202.44) 127.74,201.28 129.54,201.28 130.94,199.88 141.33,199.88 142.47,198.74 146.91,198.74 147.71,197.94 148.62,197.94 149.18,197.38 149.18,186.66 148.59,186.07 148.59,183.85 149.3,183.14 149.65,183.14 v1(149.93,182.86)
  BOTTOM w0.14: v1(119.55,205.02) 119.55,205.85 PC325.1
  BOTTOM w0.152: PC325.1 120.18,206.48 120.18,206.86 120.74,207.42 PU20.14
  BOTTOM w0.203: PR424.1 126.5,202.52 v1(126.58,202.44) ; v1(119.55,205.02) 119.66,204.91 PR6037.1 ; PR498.1 149.98,182.81 v1(149.93,182.86)
VCORE_CSN6: length 60.9
  IN2 w0.203: v1(120.99,204.98) 120.99,204.99 122.87,204.99 123.4,204.46 125.77,204.46 v1(127.75,202.48)
  IN3 w0.203: v1(127.75,202.48) 129.94,202.48 131.42,200.99 142.24,200.99 142.95,200.28 150.22,200.28 155.11,195.39 155.11,189.45 156.75,187.81 156.75,185 158.8,182.95 159.83,182.95 v1(159.97,182.81)
  BOTTOM w0.178: v1(120.99,204.98) 120.8,205.17 120.8,205.91 PC323.1
  BOTTOM w0.203: v1(120.99,204.98) 120.99,204.62 121.05,204.56 PR6036.1 ; PR499.1 v1(159.97,182.81) ; PR425.1 127.64,202.59 v1(127.75,202.48) ; PC323.1 121.24,207.01 121.55,207.31 PU20.12
VCORE_CSP1: length 36.6
  IN1 w0.203: v1(123.7,204.94) 123.28,204.52 116.67,204.52 v1(114.94,202.78)
  IN3 w0.203: v1(114.94,202.78) 116.16,201.56 116.16,196.23 116.84,195.54 116.84,191.73 113.62,188.51 112.45,188.51 111.56,187.62 111.56,183.84 111.94,183.45 v1(112.88,183.45)
  BOTTOM w0.203: PR414.1 114.94,203.36 v1(114.94,202.78) ; v1(123.7,204.94) 123.19,205.45 PR403.1 ; PR488.1 113.68,183.26 113.07,183.26 v1(112.88,183.45)
VCORE_CSP2: length 38.6
  IN1 w0.203: v1(124.72,204.94) 123.99,204.22 117.52,204.22 v1(116.08,202.78)
  IN3 w0.203: v1(124.72,204.94) 123.7,203.92 123.7,199.48 121.54,197.31 121.54,190.73 120.54,189.74 120.54,183.6 121,183.15 121.62,183.15 v1(121.87,183.4)
  BOTTOM w0.203: v1(124.72,204.94) 124.21,205.45 PR404.1 ; v1(116.08,202.78) 116.08,201.92 115.64,201.48 PR415.1 ; PR489.1 123.29,183.22 122.05,183.22 v1(121.87,183.4)
VCORE_CSP3: length 39.9
  IN1 w0.203: v1(117.22,202.51) 118.63,203.91 124.7,203.91 v1(125.86,205.07)
  IN3 w0.203: v1(125.86,205.07) 125.86,203.73 124.89,202.76 124.89,200.93 130.22,195.61 130.22,189.23 129.23,188.24 129.23,184.06 129.92,183.37 130.45,183.37 v1(130.69,183.6)
  BOTTOM w0.203: v1(130.69,183.6) 130.98,183.31 132.69,183.31 132.89,183.51 PR490.1 ; v1(125.86,205.07) 125.85,205.07 PR405.1 ; v1(117.22,202.51) 116.67,201.95 PR416.1
VCORE_CSP4: length 47.2
  IN1 w0.203: v1(127,204.94) 125.59,203.52 119.38,203.52 v1(118.37,202.51)
  IN3 w0.203: v1(127,204.94) 127,203.91 126.04,202.95 126.04,202.16 129.12,199.07 138.29,199.07 139.87,197.5 139.87,183.92 140.19,183.6 v1(140.47,183.6)
  BOTTOM w0.203: PR417.1 118.42,202.03 118.42,202.03 118.42,202.45 v1(118.37,202.51) ; v1(140.47,183.6) 140.8,183.27 142.64,183.27 PR491.1 ; v1(127,204.94) 126.5,205.45 PR406.1
VCORE_CSP5: length 56.6
  IN1 w0.203: v1(128.15,204.94) 126.41,203.2 120.21,203.2 119.56,202.56 v1(119.56,202.52)
  IN3 w0.203: v1(128.15,204.94) 128.15,203.83 127.18,202.86 127.18,202.34 127.55,201.97 129.8,201.97 131.55,200.22 141.47,200.22 142.61,199.08 147.05,199.08 147.83,198.31 148.74,198.31 149.52,197.53 149.52,186.52 148.93,185.92 148.93,184 149.44,183.49 149.74,183.49 v1(149.99,183.73)
  BOTTOM w0.203: PR492.1 152.28,183.26 150.46,183.26 v1(149.99,183.73) ; PR418.1 119.56,201.82 v1(119.56,202.52) ; v1(128.15,204.94) 127.64,205.45 PR407.1
VCORE_CSP6: length 58.1
  IN1 w0.203: v1(128.78,204.69) 127.01,202.91 121.17,202.91 v1(120.74,202.48)
  IN3 w0.203: v1(128.78,204.69) 132.13,201.33 142.38,201.33 143.09,200.62 150.36,200.62 155.45,195.53 155.45,189.59 157.09,187.95 157.09,185.24 158.98,183.34 159.81,183.34 v1(159.98,183.51)
  BOTTOM w0.203: v1(120.74,202.48) 120.67,202.42 120.67,201.99 120.72,201.94 PR419.1 ; v1(159.98,183.51) PR493.1 ; PR408.1 v1(128.78,204.69)
VCORE_PWM1: length 17.6
  IN1 w0.178: v1(112.58,201.93) 112.04,202.46 112.04,202.78 112.97,203.71 112.97,205.36 115.95,208.33 115.95,209.54 116.47,210.07 v1(116.57,210.07)
  BOTTOM w0.14: PR445.1 110.51,199.08 110.51,200.76 111.13,201.38 112.04,201.38 v1(112.58,201.93)
  BOTTOM w0.152: PU20.25 117.08,210.33 116.82,210.07 v1(116.57,210.07) 116.52,210.07 115.7,210.89 PR389.1
VCORE_PWM2: length 21.2
  IN1 w0.086: v2(116.7,210.87) 116.99,210.58 116.99,208.78 113.41,205.2 113.41,202.44 116.03,199.82 119.44,199.82 v1(119.89,199.37)
  BOTTOM w0.14: v1(119.89,199.37) PR447.1
  BOTTOM w0.152: PR385.1 116.16,211.56 116.16,211.25 116.54,210.87 v2(116.7,210.87) 116.75,210.87 116.89,210.73 PU20.26
VCORE_PWM3: length 29.7
  IN1 w0.086: v1(129.14,199.86) 128.96,200.04 116.07,200.04 113.6,202.52 113.6,205.12 117.2,208.72 117.2,210.99 v2(116.72,211.47)
  BOTTOM w0.14: PU20.27 117.37,211.13 117.04,211.46 116.73,211.46 v2(116.72,211.47) ; PR449.1 129.54,199.45 v1(129.14,199.86)
VCORE_PWM4: length 39.9
  IN1 w0.086: v1(139.2,199.31) 138.77,199.73 134.29,199.73 133.75,200.28 116.11,200.28 113.79,202.6 113.79,205.04 117.45,208.7 117.45,211.32 v2(116.69,212.08)
  BOTTOM w0.14: PU20.28 117.49,211.53 116.95,212.08 v2(116.69,212.08) ; v1(139.2,199.31) PR451.1
VCORE_PWM5: length 50.7
  IN1 w0.086: v1(147.86,199.21) 147.46,198.81 142.65,198.81 141.45,200.01 134.35,200.01 133.89,200.47 116.18,200.47 113.97,202.68 113.97,204.96 117.71,208.7 117.71,211.6 v2(116.64,212.67)
  BOTTOM w0.14: PU20.29 117.5,211.93 116.75,212.67 v2(116.64,212.67) ; PR455.1 148.28,198.5 147.86,198.92 v1(147.86,199.21)
VCORE_PWM6: length 62.2
  IN1 w0.086: v2(116.91,213.23) 117.98,212.16 117.98,208.7 114.16,204.88 114.16,202.75 116.26,200.65 134.19,200.65 134.64,200.2 141.53,200.2 142.73,199 146.78,199 147.39,199.61 148.02,199.61 148.9,198.73 153.41,198.73 154.25,199.57 157.81,199.57 158.16,199.22 158.83,199.22 v1(158.92,199.32)
  BOTTOM w0.14: PR453.1 158.78,198.82 158.92,198.96 v1(158.92,199.32) ; PU20.30 117.6,212.33 117.39,212.54 117.39,212.75 v2(116.91,213.23)
VGA_XTALIN: length 9.9
  BOTTOM w0.127: 257.44,122.84 256.53,123.76 256.15,123.76 253.78,126.13 253.78,126.91 UG6.BT5
  BOTTOM w0.14: 257.44,122.84 257.71,122.57 CG520.1 257.71,120.73 YG1.1
VGA_XTALOUT: length 1.9
  BOTTOM w0.14: RG148.1 257.14,122.3 257.4,122.04 257.4,121.53 257.23,121.36 YG1.3
VGA_XTALOUT_R: length 6.8
  BOTTOM w0.127: UG6.BR5 253.9,128.07 253.71,128.07 253.55,127.91 253.55,126.04 256.05,123.53 256.42,123.53 256.67,123.29 RG145.2
VGPU_CORE_SENSE: length 157.6
  TOP w0.127: PR212.2 269.22,76.55 269.42,76.55 v1(269.71,76.26)
  IN1 w0.127: v1(207,120.76) 206.71,120.47 206.71,115.86 200.94,110.1 200.94,109.34 v1(201.15,109.13)
  IN4 w0.127: v1(269.71,76.26) 269.71,76.35 269.88,76.52 270.08,76.52 270.21,76.39 270.21,75.88 268.15,73.83 267.54,73.83 266.47,72.76 262.54,72.76 262.07,72.29 257.29,72.29 256.47,73.11 254.97,73.11 254.43,73.65 254.43,75.11 253.85,75.69 253.33,75.69 252.71,76.31 252.71,77.84 250.58,79.98 236.65,79.98 233.76,82.87 233.76,84.61 232.52,85.84 226.47,85.84 226.19,86.12 223.68,86.12 222.58,85.03 217.64,85.03 216.33,83.72 216.33,82.36 215.45,81.47 215.45,80.49 214.35,79.39 211.13,79.39 210.07,80.45 210.07,81.46 205.98,85.55 205.98,86.42 203.76,88.64 203.76,93.15 206.46,95.85 210.12,95.85 210.32,95.65 211.51,95.65 212.4,96.53 212.4,97.81 209.81,100.4 208.03,100.4 206.08,102.36 205.3,102.36 204.96,102.69 204.96,103.72 203.28,105.39 203.28,107.39 202.15,108.53 201.23,108.53 201.11,108.65 201.11,109.09 v1(201.15,109.13)
  BOTTOM w0.102: UG6.BT48 223.85,127.13 221.69,124.97 221.69,124.57 RG140.2 221.85,124.12 221.77,124.12 221.47,123.81 221.47,123.66 221.35,123.55
  BOTTOM w0.127: v1(207,120.76) 206.71,121.05 206.71,121.71 208.41,123.41 221.21,123.41 221.35,123.55
VGPU_ICMNT: length 388.2
  TOP w0.14: U23.70 182.07,60.9 v1(181.9,60.73) ; v1(221.08,192.31) 221.51,191.88 223.89,191.88 224.38,192.37 225.12,192.37 225.69,191.79 PR103.1
  IN2 w0.089: v1(108.14,58.14) 108.58,58.58 110.69,58.58 113.29,61.19 121.79,61.19 125.07,64.47 129.97,64.47 130.79,65.29 147.98,65.29 148.23,65.54 156.76,65.54 157.32,66.1 158.26,66.1 159.29,65.07 160.17,65.07 161.57,63.67 161.69,63.67 161.78,63.58 163.8,63.58 164.62,62.76 164.88,62.76 164.96,62.69 168,62.69 168.79,61.89 169.44,61.89 170.15,61.18 174.52,61.18 174.81,61.48 181,61.48 181.76,60.73 v1(181.9,60.73) ; v1(115.6,159.76) 115.63,159.76 117.17,158.22 117.17,157.02 120.84,153.35 120.84,145.65 118.71,143.51 118.71,141.06 112.01,134.36 112.01,127.18 110.98,126.15 110.98,118.9 v1(112.14,117.74)
  IN3 w0.089: v1(147.96,209.9) 148.92,208.94 151.76,208.94 152.73,207.96 158.25,207.96 162.42,212.13 165.64,212.13 166.65,211.11 167.59,211.11 170.67,208.03 170.67,206.9 171.99,205.58 171.99,203.7 v1(174.42,201.26)
  IN4 w0.086: v1(147.96,209.9) 147.61,209.9 147.21,209.5 137.14,209.5 134.71,211.92 134.71,212.87 134.39,213.19 128.84,213.19 128.59,212.93 128.59,212.01 126.79,210.21 124.07,210.21 119.02,205.15 119.02,204.76 118.09,203.82 112.2,203.82 110.06,201.69 110.06,196.37 109.26,195.57 109.26,162.33 111.84,159.76 v1(115.6,159.76) ; v1(221.08,192.31) 221.08,192.26 219.91,191.09 216.6,191.09 213.85,193.83 208.17,193.83 207.74,194.26 201.1,194.26 199.76,192.93 196.65,192.93 194.86,194.72 180.28,194.72 177.29,197.71 176.7,197.71 174.42,200 v1(174.42,201.26)
  BOTTOM w0.14: v1(112.14,117.74) 111.73,117.74 105.34,111.36 105.34,107.42 100.7,102.78 100.7,98.82 102.98,96.54 105.04,96.54 106.39,95.18 106.39,92.81 108.23,90.98 108.23,79.83 107.55,79.15 107.55,76.8 106.49,75.75 106.49,59.79 v1(108.14,58.14)
VL: length 2.5
  TOP w0.178: PC220.1 154.64,55.03 153.8,55.87 PU15.13
VMA_CLK0: length 21.3
  IN4 w0.114: v2(224.2,142.37) 224.34,142.37 224.42,142.44 224.42,142.91 224.28,143.04 223.38,143.04 222.56,143.86 219.04,143.86 218.97,143.79 218.32,143.79 217.99,144.12 217.99,144.52 217.65,144.86 214.79,144.86 214.42,145.23 207.4,145.23 207.15,145.48 207.15,145.48 207.12,145.51 207.12,145.76 206.95,145.93 v2(206.93,145.93)
  BOTTOM w0.102: UG6.AP48 223.98,142.72 224.2,142.5 v2(224.2,142.37) ; v2(206.93,145.93) 206.93,145.88 207.05,145.77 207.05,145.37 VRAM6.J10
VMA_CLK0#: length 21.2
  IN4 w0.114: v2(224.89,142.38) 224.75,142.38 224.63,142.49 224.63,142.99 224.37,143.25 223.47,143.25 222.65,144.07 218.95,144.07 218.88,144 218.41,144 218.21,144.2 218.21,144.61 217.74,145.08 214.88,145.08 214.51,145.45 207.48,145.45 207.34,145.6 207.34,145.76 207.48,145.91 v2(207.55,145.91)
  BOTTOM w0.102: UG6.AP47 224.55,142.57 224.74,142.38 v2(224.89,142.38)
  BOTTOM w0.114: v2(207.55,145.91) 207.55,145.9 207.55,145.27 VRAM6.K10
VMA_CLK1: length 27.3
  IN4 w0.102: v2(207.65,133.74) 207.58,133.68 207.44,133.68 207.31,133.81 207.31,134.2 206.46,135.04 206.46,137.71 206.88,138.13 206.88,138.79 207.21,139.11 217.58,139.11 218.15,139.69 218.15,141.38 218.51,141.74 222.41,141.74 222.47,141.8 223.46,141.8 223.56,141.7 v2(223.56,141.6)
  BOTTOM w0.102: v2(223.56,141.6) 223.52,141.6 223.42,141.71 223.42,141.88 223.55,142.01 223.84,142.01 UG6.AR48 ; v2(207.65,133.74) 207.59,133.69 207.44,133.69 207.3,133.83 207.3,133.91 207.13,134.08 207.13,134.21 207.35,134.43 207.61,134.43 VRAM8.J10
VMA_CLK1#: length 27
  IN4 w0.102: v2(206.93,133.74) 206.98,133.74 207.09,133.85 207.09,134.13 206.26,134.96 206.26,137.8 206.68,138.21 206.68,138.87 207.12,139.32 217.49,139.32 217.95,139.78 217.95,141.46 218.43,141.94 222.32,141.94 222.38,142 223.72,142 v2(224.14,141.59)
  BOTTOM w0.102: v2(206.93,133.74) 206.93,134.39 VRAM8.K10
  BOTTOM w0.114: v2(224.14,141.59) 224.55,142 UG6.AR47
VMA_DQ0: length 13.9
  IN2 w0.102: v2(210.99,150.83) 210.99,151.58 211.49,152.08 214.37,152.08 215.05,151.4 217.54,151.4 217.77,151.62 219.01,151.62 219.51,151.12 220.17,151.12 220.22,151.17 220.86,151.17 221.23,150.8 222.07,150.8 v2(222.11,150.76)
  BOTTOM w0.102: v2(210.99,150.83) 210.63,151.2 VRAM6.P2 ; UG6.AC51 221.92,150.42 222.11,150.61 v2(222.11,150.76)
VMA_DQ1: length 18.6
  IN2 w0.102: v2(209.5,151.6) 209.73,151.83 209.73,152.96 210.32,153.55 214.04,153.55 214.96,152.64 215.82,152.64 216.02,152.44 222.69,152.44 223.22,151.91 223.22,151.43 223.44,151.21 223.91,151.21 v2(224.19,151.49)
  BOTTOM w0.102: v2(209.5,151.6) 209.13,151.22 VRAM6.M2 ; UG6.AB48 223.85,151.15 v2(224.19,151.49)
VMA_DQ2: length 8.1
  IN2 w0.102: v2(214.09,150.84) 214.49,150.84 214.98,150.34 220.27,150.34 v2(220.71,150.78)
  BOTTOM w0.102: v2(220.71,150.78) 221.05,150.44 UG6.AC52
  BOTTOM w0.216: VRAM6.V3 213.69,150.45 214.08,150.84 v2(214.09,150.84)
VMA_DQ3: length 17.2
  IN2 w0.102: v2(210.25,151.6) 209.97,151.88 209.97,152.73 210.47,153.23 213.82,153.23 215.08,151.96 215.65,151.96 215.88,152.19 220.11,152.19 220.92,151.37 220.98,151.37 221.18,151.17 222.93,151.17 223.32,150.77 v2(223.49,150.77)
  BOTTOM w0.102: UG6.AC49 223.15,150.43 v2(223.49,150.77) ; v2(210.25,151.6) 209.88,151.23 VRAM6.N2
VMA_DQ4: length 10
  IN2 w0.102: v2(220.69,148.66) 220.28,148.25 219.21,148.25 219.06,148.1 214.67,148.1 214.08,148.69 213.12,148.69 v2(212.5,149.3)
  BOTTOM w0.102: v2(212.5,149.3) 212.88,149.67 VRAM6.U4
  BOTTOM w0.161: UG6.AF52 220.71,148.66 v2(220.69,148.66)
VMA_DQ5: length 7.6
  IN2 w0.102: v2(219.31,150.77) 219.15,150.77 218.73,151.2 217.97,151.2 217.9,151.13 216.28,151.13 216.15,151 214.86,151 214.59,151.27 213.59,151.27 v2(213.25,151.6)
  BOTTOM w0.102: v2(213.25,151.6) 212.88,151.22 VRAM6.U2 ; v2(219.31,150.77) 219.65,150.43 UG6.AC54
VMA_DQ6: length 10
  IN2 w0.102: v2(221.25,149.73) 221,149.73 220.63,150.1 216.33,150.1 216.2,149.97 214.79,149.97 214.31,150.45 213.63,150.45 v2(213.24,150.07)
  BOTTOM w0.102: v2(213.24,150.07) 213.23,150.07 212.88,150.43 VRAM6.U3
  BOTTOM w0.161: UG6.AE51 221.25,149.52 v2(221.25,149.73)
VMA_DQ7: length 15.7
  IN2 w0.102: v2(210.26,150.07) 209.87,149.68 209.87,149.09 210.18,148.78 210.18,148.15 210.64,147.69 219.39,147.69 219.67,147.97 221.4,147.97 v2(222.09,148.66)
  BOTTOM w0.102: v2(210.26,150.07) 210.63,150.43 VRAM6.P3
  BOTTOM w0.161: UG6.AF51 v2(222.09,148.66)
VMA_DQ8: length 26.6
  IN1 w0.102: v2(200.4,150.11) 199.96,150.55 199.96,152.57 201.36,153.97 214.78,153.97 215.33,154.51 219.78,154.51 220.48,153.81 221.14,153.81 v2(221.24,153.91)
  BOTTOM w0.102: v2(221.24,153.91) 221.24,153.84 221.75,153.32 UG6.W51 ; v2(200.4,150.11) 200.73,150.45 VRAM6.A3
VMA_DQ9: length 32.2
  IN1 w0.102: v2(222.59,153.73) 222.59,153.88 223.19,154.48 223.19,155.13 222.96,155.36 221,155.36 221,155.36 215.39,155.36 214.83,154.79 208.86,154.79 208.45,154.38 201.01,154.38 199.56,152.93 199.56,150.28 200.17,149.67 200.89,149.67 v2(201.25,149.31)
  BOTTOM w0.102: v2(222.59,153.73) 222.45,153.59 UG6.W50
  BOTTOM w0.161: VRAM6.B4 201.63,149.69 v2(201.25,149.31)
VMA_DQ10: length 23.2
  IN1 w0.102: v2(201.24,150.81) 201.24,150.83 200.82,151.26 200.82,152.65 201.74,153.58 215.34,153.58 216.01,154.25 217.98,154.25 218.44,153.79 v2(219.87,153.79)
  BOTTOM w0.103: UG6.W53 220.35,153.31 v2(219.87,153.79)
  BOTTOM w0.161: v2(201.24,150.81) 201.27,150.81 201.63,151.17 VRAM6.B2
VMA_DQ11: length 17.4
  IN1 w0.102: v2(219.29,152.86) 218.88,152.45 215.09,152.45 214.72,152.08 204.03,152.08 203.55,151.59 v2(203.51,151.59)
  BOTTOM w0.102: VRAM6.E2 203.88,151.22 v2(203.51,151.59) ; UG6.Y54 219.63,152.52 v2(219.29,152.86)
VMA_DQ12: length 17.6
  IN1 w0.102: v2(220.7,152.86) 220.32,152.48 219.43,152.48 219.14,152.2 215.57,152.2 214.59,151.22 205.33,151.22 v2(204.98,151.57)
  BOTTOM w0.102: UG6.Y52 221.04,152.52 v2(220.7,152.86)
  BOTTOM w0.161: v2(204.98,151.57) 205.35,151.2 VRAM6.G2
VMA_DQ13: length 24.5
  IN1 w0.102: v2(201.98,150.06) 201.63,150.41 201.63,152.33 202.27,152.97 215.64,152.97 216.01,153.34 221.63,153.34 v2(222.09,152.88)
  BOTTOM w0.102: v2(222.09,152.88) 222.09,152.83 221.78,152.52 UG6.Y51
  BOTTOM w0.161: VRAM6.B3 201.63,150.43 201.98,150.07 v2(201.98,150.06)
VMA_DQ14: length 23.9
  IN1 w0.102: v2(203.51,150.06) 203.89,149.68 203.89,149.17 204.22,148.84 214.08,148.84 215.59,150.34 219.73,150.34 220.56,151.17 221.44,151.17 221.73,151.45 221.73,152.15 222.01,152.43 222.5,152.43 222.79,152.14 v2(223.52,152.14)
  BOTTOM w0.102: v2(223.52,152.14) 223.15,152.52 UG6.Y49 ; v2(203.51,150.06) 203.88,150.43 VRAM6.E3
VMA_DQ15: length 19.5
  IN1 w0.102: v2(204.26,150.81) 205.39,149.69 214.39,149.69 215.83,151.13 217.55,151.13 217.59,151.16 219.62,151.16 219.66,151.12 220.11,151.12 220.59,151.6 v2(221.29,151.6)
  BOTTOM w0.102: v2(221.29,151.6) 221.29,151.56 221.73,151.12 UG6.AB51
  BOTTOM w0.161: VRAM6.F2 204.63,151.18 v2(204.26,150.81)
VMA_DQ16: length 8.6
  IN2 w0.102: v2(212.5,144.08) 212.89,143.69 215.06,143.69 216.22,144.85 218.76,144.85 219.14,144.47 v2(219.3,144.47)
  BOTTOM w0.102: v2(212.5,144.08) 212.88,143.71 VRAM6.U12 ; UG6.AM54 219.65,144.12 v2(219.3,144.47)
VMA_DQ17: length 10.1
  IN2 w0.102: v2(221.31,145.29) 220.49,146.11 215.53,146.11 214.7,145.28 213.66,145.28 213.25,144.86 v2(213.25,144.85)
  BOTTOM w0.102: UG6.AL51 221.31,145.26 v2(221.31,145.29) ; v2(213.25,144.85) 212.88,144.48 VRAM6.U11
VMA_DQ18: length 9.3
  IN2 w0.102: v2(220.69,144.47) 220.29,144.07 218.69,144.07 218.58,143.95 215.95,143.95 214.93,142.93 213.62,142.93 v2(213.24,143.31)
  BOTTOM w0.102: v2(213.24,143.31) 213.24,143.31 VRAM6.U13 ; v2(220.69,144.47) 220.7,144.47 UG6.AM52
VMA_DQ19: length 11.2
  IN2 w0.102: v2(210.99,144.08) 211.32,144.41 211.32,144.96 211.59,145.23 212.28,145.23 212.78,145.72 212.78,145.96 213.38,146.56 216.35,146.56 216.77,146.98 218.89,146.98 v2(219.29,146.58)
  BOTTOM w0.102: v2(210.99,144.08) 210.63,143.71 VRAM6.P12 ; UG6.AJ54 v2(219.29,146.58)
VMA_DQ20: length 16.1
  IN2 w0.102: v2(224.9,143.77) 224.63,144.04 223.87,144.04 223.77,144.13 223.06,144.13 222.98,144.05 221.03,144.05 220.8,143.82 219.22,143.82 218.59,143.19 215.83,143.19 214.75,142.11 211.44,142.11 v2(211,142.55)
  BOTTOM w0.102: v2(211,142.55) 210.63,142.92 VRAM6.P13 ; UG6.AM47 v2(224.9,143.77)
VMA_DQ21: length 10
  IN2 w0.102: v2(222.1,144.46) 221.71,144.85 219.23,144.85 218.73,145.34 216.05,145.34 214.8,144.09 214.08,144.09 214.07,144.08 v2(214.07,144.08)
  BOTTOM w0.102: v2(214.07,144.08) 213.69,143.7 VRAM6.V12 ; v2(222.1,144.46) 222.09,144.46 UG6.AM51
VMA_DQ22: length 14.5
  IN2 w0.102: v2(210.25,142.54) 210.25,142.4 210.69,141.96 210.69,141.51 210.91,141.3 215.03,141.3 216.49,142.76 221.79,142.76 v2(222.12,143.09)
  BOTTOM w0.102: VRAM6.N13 210.25,142.57 v2(210.25,142.54)
  BOTTOM w0.161: v2(222.12,143.09) 222.12,143.05 UG6.AP50
VMA_DQ23: length 17.9
  IN2 w0.102: v2(223.54,143.74) 223.54,143.27 222.21,141.95 218.21,141.95 216.35,141.95 215.07,140.67 210.63,140.67 209.81,141.49 209.81,142.23 v2(209.5,142.55)
  BOTTOM w0.102: v2(223.54,143.74) 223.53,143.74 223.15,144.12 UG6.AM49
  BOTTOM w0.161: VRAM6.M13 209.13,142.92 v2(209.5,142.55)
VMA_DQ24: length 22.5
  IN1 w0.102: v2(201.26,144.8) 200.76,145.3 200.76,146.05 201.76,147.06 214.75,147.06 216.14,148.45 216.14,148.66 216.53,149.05 218.91,149.05 v2(219.3,148.66)
  BOTTOM w0.102: UG6.AF54 219.64,148.32 v2(219.3,148.66) ; VRAM6.B11 201.61,144.45 v2(201.26,144.8)
VMA_DQ25: length 26.1
  IN1 w0.102: v2(223.5,148.67) 222.92,148.09 216.32,148.09 214.91,146.69 202.17,146.69 201.73,146.25 201.73,144.36 v2(202,144.09)
  BOTTOM w0.161: v2(202,144.09) 201.63,143.71 VRAM6.B12 ; UG6.AF49 v2(223.5,148.67)
VMA_DQ26: length 21
  IN1 w0.102: v2(221.05,147.59) 220.65,147.19 216.52,147.19 214.65,145.32 203.98,145.32 203.48,144.81 v2(203.48,144.08)
  BOTTOM w0.102: v2(203.48,144.08) 203.49,144.07 203.49,144.07 203.86,143.7 VRAM6.E12
  BOTTOM w0.161: v2(221.05,147.59) 221.08,147.59 UG6.AH51
VMA_DQ27: length 30.4
  IN1 w0.102: v2(224.89,147.97) 223.8,149.06 219.42,149.06 219.15,149.33 215.73,149.33 215.23,148.83 215.23,148.24 214.42,147.44 201.42,147.44 199.95,145.97 199.95,144.6
  IN1 w0.127: v2(200.46,144.11) 200.44,144.11 199.95,144.6
  BOTTOM w0.102: VRAM6.A12 v2(200.46,144.11)
  BOTTOM w0.161: v2(224.89,147.97) 224.89,147.97 224.87,147.97 224.59,148.32 UG6.AF47
VMA_DQ28: length 18.8
  IN1 w0.102: v2(220.69,146.57) 220.3,146.17 216.7,146.17 214.22,143.69 204.64,143.69 v2(204.25,143.3)
  BOTTOM w0.102: v2(220.69,146.57) 220.7,146.57 220.71,146.55 220.72,146.55 221.05,146.22 UG6.AJ52
  BOTTOM w0.161: VRAM6.F13 204.61,142.95 v2(204.25,143.3)
VMA_DQ29: length 19.3
  IN1 w0.102: v2(204.99,142.57) 205.24,142.57 205.6,142.93 214.2,142.93 214.44,143.16 214.44,143.5 216.57,145.63 218.22,145.63 218.46,145.87 220.74,145.87 221.41,146.54 v2(221.41,146.56)
  BOTTOM w0.102: v2(221.41,146.56) UG6.AJ51
  BOTTOM w0.161: v2(204.99,142.57) 205,142.57 VRAM6.G13
VMA_DQ30: length 31.3
  IN1 w0.102: v2(201.25,143.3) 201.6,142.95 201.6,141.65 202.47,140.78 206.28,140.78 206.6,141.1 207.71,141.1 207.86,141.26 214.06,141.26 214.98,142.17 214.98,143.1 216.64,144.77 217.68,144.77 218.42,144.02 222.96,144.02 223.18,144.24 223.18,145.44 223.87,146.14 223.87,147.49 v2(223.74,147.62)
  BOTTOM w0.102: v2(223.74,147.62) 223.85,147.51 UG6.AH48 ; VRAM6.B13 201.61,142.95 v2(201.25,143.3)
VMA_DQ31: length 23.4
  IN1 w0.102: v2(203.5,142.57) 203.95,142.13 214.21,142.13 214.7,142.61 214.7,143.25 216.6,145.15 218.47,145.15 218.99,145.67 221.5,145.67 222.01,146.18 223.11,146.18 v2(223.49,146.56)
  BOTTOM w0.102: UG6.AJ49 223.15,146.24 223.47,146.56 v2(223.49,146.56) ; VRAM6.E13 203.88,142.94 v2(203.5,142.57)
VMA_DQ32: length 29.4
  IN1 w0.102: v2(223.53,137.45) 223.2,137.78 218.45,137.78 218.3,137.94 217,137.94 216.56,137.5 216.56,136.36 215.09,134.88 215.09,133.63 214.38,132.91 202.31,132.91 200.74,131.34 200.74,130.86 201.25,130.35 v2(201.25,130.34)
  BOTTOM w0.102: v2(223.53,137.45) 223.16,137.82 UG6.BA49 ; v2(201.25,130.34) 201.27,130.34 201.63,129.98 VRAM8.U4
VMA_DQ33: length 32.4
  IN1 w0.102: v2(200.49,129.52) 200.82,129.19 200.82,128.66 200.66,128.51 200.66,127.29 201.39,126.56 203.69,126.56 203.88,126.37 214.98,126.37 216.23,127.63 218.62,127.63 223.09,132.09 223.09,133.03 224.03,133.98 v2(224.03,134.93)
  BOTTOM w0.102: v2(200.49,129.52) 200.81,129.2 VRAM8.V3 ; UG6.BD47 224.03,135.2 v2(224.03,134.93)
VMA_DQ34: length 20.6
  IN1 w0.102: v2(219.3,136.06) 217.7,134.46 217.06,134.46 216.79,134.19 216.79,133.4 216.56,133.17 216.56,132.63 214.72,130.79 204.11,130.79 203.87,130.56 203.87,129.95 203.52,129.59 v2(203.52,129.58)
  BOTTOM w0.102: UG6.BD54 219.64,135.72 v2(219.3,136.06) ; v2(203.52,129.58) 203.88,129.22 VRAM8.P3
VMA_DQ35: length 21.7
  IN1 w0.102: v2(204.26,128.81) 204.65,129.2 211.18,129.2 211.19,129.21 211.99,129.21 212.01,129.19 214.47,129.19 216.64,131.36 216.64,132.12 217.02,132.5 217.88,132.5 218.19,132.81 218.19,134.15 219.27,135.23 219.87,135.23 v2(220.7,136.06)
  BOTTOM w0.102: VRAM8.N2 204.62,128.45 v2(204.26,128.81) ; UG6.BD52 221.05,135.72 220.71,136.06 v2(220.7,136.06)
VMA_DQ36: length 27
  IN1 w0.102: v2(201.98,129.57) 201.97,129.58 201.97,129.61 201.63,129.95 201.63,131.44 202.72,132.53 214.56,132.53 215.37,133.34 215.37,134.67 217.36,136.65 217.36,137.39 217.6,137.63 217.94,137.63 218.1,137.47 220,137.47 220.51,136.97 221.21,136.97 v2(221.24,136.99)
  BOTTOM w0.102: v2(221.24,136.99) 221.24,136.91 221.73,136.42 UG6.BC51
  BOTTOM w0.161: VRAM8.U3 201.63,129.21 v2(201.98,129.57)
VMA_DQ37: length 22.6
  IN1 w0.102: v2(205.01,128.08) 205.48,128.08 205.84,128.43 207.45,128.43 207.52,128.5 207.71,128.5 207.78,128.43 214.53,128.43 217.18,131.08 217.58,131.08 218.19,131.68 218.19,132.04 219.51,133.36 220.04,133.36 220.37,133.69 220.37,135.14 220.82,135.59 221.61,135.59 v2(222.1,136.08)
  BOTTOM w0.102: v2(222.1,136.08) 221.75,135.73 UG6.BD51
  BOTTOM w0.161: v2(205.01,128.08) 205.38,128.44 VRAM8.M2
VMA_DQ38: length 23.7
  IN1 w0.102: v2(221.31,134.76) 220.99,134.44 220.99,133.38 220.42,132.81 220.42,131.03 218.57,129.18 216.14,129.18 214.59,127.63 203.96,127.63 v2(203.51,128.07)
  BOTTOM w0.102: VRAM8.P2 203.88,128.44 203.63,128.19 v2(203.51,128.07)
  BOTTOM w0.161: UG6.BF51 v2(221.31,134.76)
VMA_DQ39: length 30.9
  IN1 w0.102: v2(223.51,136.08) 223.51,135.78 223.19,135.46 223.19,135.15 223.12,135.09 223.12,134.27 221.71,132.86 221.71,131.47 218.6,128.36 216.15,128.36 214.46,126.66 204.07,126.66 203.87,126.85 201.68,126.85 201.38,127.15 201.38,127.15 200.87,127.67 200.87,128.43 v2(201.25,128.81)
  BOTTOM w0.102: UG6.BD49 v2(223.51,136.08)
  BOTTOM w0.161: v2(201.25,128.81) 201.61,128.45 VRAM8.U2
VMA_DQ40: length 11
  IN2 w0.102: v2(214,129.59) 214.51,129.59 215.57,130.64 215.57,131.74 216.34,132.51 217.94,132.51 218.2,132.76 218.2,132.95 218.43,133.18 218.83,133.18 219.14,133.49 220.92,133.49 v2(221.4,133.96)
  BOTTOM w0.102: UG6.BG52 221.39,133.96 v2(221.4,133.96)
  BOTTOM w0.161: VRAM8.A3 213.63,129.21 v2(214,129.59)
VMA_DQ41: length 12.6
  IN2 w0.102: v2(222.11,133.97) 221.73,134.35 218.35,134.35 218.2,134.2 218.2,133.84 217.96,133.61 216.04,133.61 214.77,132.34 214.77,131.27 214.28,130.78 213.69,130.78 213.26,130.35 v2(213.25,130.35)
  BOTTOM w0.102: v2(222.11,133.97) 221.76,133.62 UG6.BG51 ; VRAM8.B4 212.88,130.09 213.13,130.35 v2(213.25,130.35)
VMA_DQ42: length 9.5
  IN2 w0.102: v2(219.31,133.97) 219.3,133.97 219.18,133.84 219.03,133.84 218.64,133.45 218.16,133.45 218.02,133.32 216.49,133.32 215.18,132.01 215.18,130.95 214.24,130.01 213.67,130.01 v2(213.25,129.59)
  BOTTOM w0.102: VRAM8.B3 213.25,129.57 v2(213.25,129.59) ; v2(219.31,133.97) 219.65,133.63 UG6.BG54
VMA_DQ43: length 20.5
  IN2 w0.102: v2(210.23,128.81) 210.23,127.91 209.86,127.53 209.86,127.01 210.65,126.23 214.36,126.23 216.69,128.56 218.19,128.56 221.78,132.15 221.78,132.78 222.34,133.35 222.87,133.35 223.49,133.96 v2(223.49,133.98)
  BOTTOM w0.102: VRAM8.F2 210.23,128.8 v2(210.23,128.81)
  BOTTOM w0.161: UG6.BF49 223.49,133.98 v2(223.49,133.98)
VMA_DQ44: length 10.6
  IN2 w0.102: v2(219.89,132.77) 219.89,132.53 219.6,132.25 218.83,132.25 218.75,132.33 218.47,132.33 218.19,132.05 218.19,131.61 218.02,131.43 217.11,131.43 216.31,130.64 216.31,130.1 214.64,128.42 213.64,128.42 v2(213.25,128.81)
  BOTTOM w0.102: UG6.BJ54 219.89,132.46 v2(219.89,132.77) ; VRAM8.B2 212.88,128.45 v2(213.25,128.81)
