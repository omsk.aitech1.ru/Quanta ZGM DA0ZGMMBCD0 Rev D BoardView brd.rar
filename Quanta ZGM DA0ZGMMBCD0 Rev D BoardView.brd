# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Nets (continued)
M_B_CLKP0: JDIM1.137 U42.BK8
M_B_CLKP1: JDIM1.138 U42.BK6
M_B_CS#0: JDIM1.149 U42.AV8
M_B_CS#1: JDIM1.157 U42.AN9
M_B_DIM0_ODT0: JDIM1.155 U42.AR9
M_B_DIM0_ODT1: JDIM1.161 U42.AM9
M_B_DQ0: JDIM1.3 U42.CK22
M_B_DQ1: JDIM1.8 U42.CJ22
M_B_DQ2: JDIM1.21 U42.CJ20
M_B_DQ3: JDIM1.4 U42.CM22
M_B_DQ4: JDIM1.7 U42.CM21
M_B_DQ5: JDIM1.20 U42.CK20
M_B_DQ6: JDIM1.16 U42.CM20
M_B_DQ7: JDIM1.17 U42.CL18
M_B_DQ8: JDIM1.25 U42.CK17
M_B_DQ9: JDIM1.29 U42.CJ17
M_B_DQ10: JDIM1.38 U42.CJ14
M_B_DQ11: JDIM1.24 U42.CM17
M_B_DQ12: JDIM1.37 U42.CM16
M_B_DQ13: JDIM1.41 U42.CK14
M_B_DQ14: JDIM1.28 U42.CM14
M_B_DQ15: JDIM1.42 U42.CL13
M_B_DQ16: JDIM1.50 U42.CK12
M_B_DQ17: JDIM1.45 U42.CJ12
M_B_DQ18: JDIM1.49 U42.CM9
M_B_DQ19: JDIM1.46 U42.CM12
M_B_DQ20: JDIM1.62 U42.CN6
M_B_DQ21: JDIM1.63 U42.CM8
M_B_DQ22: JDIM1.59 U42.CM6
M_B_DQ23: JDIM1.58 U42.CK7
M_B_DQ24: JDIM1.84 U42.CJ9
M_B_DQ25: JDIM1.83 U42.CF9
M_B_DQ26: JDIM1.80 U42.CE7
M_B_DQ27: JDIM1.79 U42.CF8
M_B_DQ28: JDIM1.71 U42.CF6
M_B_DQ29: JDIM1.67 U42.CJ8
M_B_DQ30: JDIM1.66 U42.CJ6
M_B_DQ31: JDIM1.70 U42.CH6
M_B_DQ32: JDIM1.174 U42.AF6
M_B_DQ33: JDIM1.173 U42.AG6
M_B_DQ34: JDIM1.169 U42.AG8
M_B_DQ35: JDIM1.182 U42.AD6
M_B_DQ36: JDIM1.187 U42.AD8
M_B_DQ37: JDIM1.170 U42.AG9
M_B_DQ38: JDIM1.183 U42.AD9
M_B_DQ39: JDIM1.186 U42.AC7
M_B_DQ40: JDIM1.194 U42.Y6
M_B_DQ41: JDIM1.191 U42.AB6
M_B_DQ42: JDIM1.190 U42.AB8
M_B_DQ43: JDIM1.203 U42.W6
M_B_DQ44: JDIM1.208 U42.W8
M_B_DQ45: JDIM1.195 U42.AB9
M_B_DQ46: JDIM1.204 U42.W9
M_B_DQ47: JDIM1.207 U42.V7
M_B_DQ48: JDIM1.215 U42.R6
M_B_DQ49: JDIM1.211 U42.U6
M_B_DQ50: JDIM1.216 U42.U8
M_B_DQ51: JDIM1.225 U42.P6
M_B_DQ52: JDIM1.224 U42.P8
M_B_DQ53: JDIM1.212 U42.U9
M_B_DQ54: JDIM1.228 U42.P9
M_B_DQ55: JDIM1.229 U42.N7
M_B_DQ56: JDIM1.236 U42.K6
M_B_DQ57: JDIM1.233 U42.L6
M_B_DQ58: JDIM1.237 U42.L8
M_B_DQ59: JDIM1.249 U42.H6
M_B_DQ60: JDIM1.246 U42.H8
M_B_DQ61: JDIM1.232 U42.L9
M_B_DQ62: JDIM1.250 U42.H9
M_B_DQ63: JDIM1.245 U42.G7
M_B_DQSN0: JDIM1.11 U42.CJ21
M_B_DQSN1: JDIM1.32 U42.CJ16
M_B_DQSN2: JDIM1.53 U42.CN9
M_B_DQSN3: JDIM1.74 U42.CH9
M_B_DQSN4: JDIM1.177 U42.AF9
M_B_DQSN5: JDIM1.198 U42.Y9
M_B_DQSN6: JDIM1.219 U42.R9
M_B_DQSN7: JDIM1.240 U42.K9
M_B_DQSN8: JDIM1.95 R115.1
M_B_DQSP0: JDIM1.13 U42.CK21
M_B_DQSP1: JDIM1.34 U42.CK16
M_B_DQSP2: JDIM1.55 U42.CN8
M_B_DQSP3: JDIM1.76 U42.CH8
M_B_DQSP4: JDIM1.179 U42.AF8
M_B_DQSP5: JDIM1.200 U42.Y8
M_B_DQSP6: JDIM1.221 U42.R8
M_B_DQSP7: JDIM1.242 U42.K8
M_B_DQSP8: JDIM1.97 R117.1
M_B_PARITY: JDIM1.143 U42.BE6
M_B_RAS#: JDIM1.152 U42.AW8
M_B_WE#: JDIM1.151 U42.AR7
MAIND: PC214.1 PQ21.2 PQ28.3 PR299.2
MAINON: PQ16.2 PQ27.2 PR142.1 PR253.1 PR256.1 PR292.1 PR647.2 R67.1 R560.1 U23.30
MAINON_ON_G: PQ22.2 PQ23.2 PQ24.2 PQ27.3 PQ28.2 PR276.1 PR286.2
MB_THRMTRIP#: D50.1(CATHODE) R684.2 U35.4
MB_THRMTRIP#_2: D56.1(CATHODE) R822.2 U46.4
MBCLK: PC256.1 PD5.1 PR324.2 PR334.2 R337.1 R357.1 U23.110
MBCLK1_GPU: PR195.1 PR198.1 QG12.3 R34.2
MBCLK1_OVRM: PR16.2 RG1.1
MBCLK_CONN: PJ19.5 PR324.1
MBDATA: PC257.1 PD4.1 PR323.2 PR333.2 R336.1 R356.1 U23.111
MBDATA1_GPU: PR200.1 PR204.1 QG12.6 R33.2
MBDATA1_OVRM: PR25.2 RG2.1
MBDATA_CONN: PJ19.4 PR323.1
MCU_INT#: Q9.1(S) R44.2 U23.113
ME_WR#: R1036.2 U23.109
MEM_VDD_CTRL: PR35.2 RG65.1 UG6.BK6
MEM_VREF_CTL: PR379.2 RG125.1 UG6.BK4
MIC2-L: CN10.41 U20.30
MIC2-R: CN10.40 U20.31
MIC2-VREFO-L: CN10.39 U20.28
MIC2-VREFO-R: CN10.38 U20.29
MIC-JD: CN10.37 R376.1
MIC-JD_R: R376.2 R387.2 U20.47
MIC_VCC: C606.2 C608.1 C609.2 CN2.35 R741.2
MKB_INT#: Q57.1(S) R533.1 R620.1 U23.76
MKB_INT#_R: R533.2 U49.AY38
MKB_PWR_EN: R477.1 R1233.1 R1234.1
MODE: R496.2 U24.30
MODEM_CLKREQ: R463.1 R482.1 U22.1 U22.2 U49.AY33
MODEM_CLKREQ_L: CN12.14 R482.2 U22.4
MUX_CNTL: QG1.5 R688.2 TP83.1 UG11.4(Y)
MUX_CNTL_C: QG1.6 U36.6 U37.1
MUX_CNTL_INTERNAL: RG165.1 RG169.1 TP18.1 UG6.BM4
MUX_CTRL_EC: R593.2 RG91.1 RG92.1 U23.56
MUX_CTRL_PCH: R1100.1 RG170.1 RG173.1 TP22.1 TP165.1 U49.Y46
NBSWON#: C602.1 C790.2 D54.1 R54.1 R358.1 R1027.1 SW1.1 SW1.2 U23.107
NBSWON#_C: CN1.8 R54.2
NGFF1_PEDET1: CN6.69 TP124.1
NGFF1_RST#: CN6.50 R197.1 R198.2 U12.4
NGFF2_RST#: CN13.50 R495.1 R504.2 U25.4
NRESET: Q124.1(S) R1196.1 R1210.1 U49.W45
NRESET_R: CN19.5 R1192.2 R1193.2 R1194.1 R1195.1
NVVDD: C148.2 C149.1 C150.1 C686.2 C687.1 C688.1 CG103.2 CG111.2 CG113.2 CG114.2 CG115.2 CG117.2 CG122.2 CG125.2 CG126.2 CG132.2 CG133.2 CG134.2 CG135.2 CG138.2 CG140.2 CG142.2 CG145.2 CG147.2 CG148.2 CG149.2 CG150.2 CG151.2 CG160.2 CG166.1 CG168.1 CG170.1 CG171.1 CG176.2 CG180.1 CG181.1 CG183.2 CG186.2 CG188.2 CG193.1 CG195.1 CG200.2 CG201.1 CG202.1 CG205.2 CG210.1 CG211.1 CG217.2 CG218.2 CG222.2 CG223.1 CG225.1 CG226.1 CG227.1 CG228.1 CG229.1 CG231.2 CG237.2 CG238.1 CG239.1 CG240.1 CG241.1 CG242.1 CG243.1 CG246.2 CG252.1 CG254.2 CG255.1 CG256.1 CG257.1 CG258.1 CG259.1 CG260.2 CG267.2 CG268.2 CG269.1 CG270.1 CG271.1 CG272.1 CG273.1 CG274.1 CG282.2 CG283.2 CG284.2 CG285.2 CG286.2 CG287.2 CG288.2 CG289.2 CG294.2 CG295.2 CG296.2 CG297.2 CG298.2 CG300.2 CG301.2 CG302.2 CG304.2 CG307.2 CG309.2 CG310.2 CG311.2 CG312.2 CG313.2 CG314.2 CG316.2 CG340.2 CG341.2 PC103.1 PC104.1 PC105.1 PC106.1 PC107.1 PC108.1 PC109.1 PC110.1 PC111.1 PC112.1 PC113.1 PC114.1 PC115.1 PC117.1 PC118.1 PC119.1 PL14.2 PL15.2 PL16.2 PL17.2 PL18.2 PL19.2 PL20.2 PL21.2 PR162.1 PR221.1 PR519.2 PR520.2 PR521.2 PR522.2 PR523.2 PR524.2 PR525.2 PR527.2 UG6.AB13 UG6.AB14 UG6.AB15 UG6.AB16 UG6.AB17 UG6.AB18 UG6.AB19 UG6.AB20 UG6.AB21 UG6.AB22 UG6.AB23 UG6.AB24 UG6.AB25 UG6.AB26 UG6.AB27 UG6.AB28 UG6.AB29 UG6.AB30 UG6.AB31 UG6.AB32 UG6.AB33 UG6.AB34 UG6.AB35 UG6.AB36 UG6.AB37 UG6.AB38 UG6.AB39 UG6.AB40 UG6.AB41 UG6.AB42 UG6.AB43 UG6.AB44 UG6.AD13 UG6.AD14 UG6.AD15 UG6.AD16 UG6.AD17 UG6.AD18 UG6.AD19 UG6.AD20 UG6.AD21 UG6.AD22 UG6.AD23 UG6.AD24 UG6.AD25 UG6.AD26 UG6.AD27 UG6.AD28 UG6.AD29 UG6.AD30 UG6.AD31 UG6.AD32 UG6.AD33 UG6.AD34 UG6.AD35 UG6.AD36 UG6.AD37 UG6.AD38 UG6.AD39 UG6.AD40 UG6.AD41 UG6.AD42 UG6.AD43 UG6.AD44 UG6.AF13 UG6.AF14 UG6.AF15 UG6.AF16 UG6.AF17 UG6.AF18 UG6.AF19 UG6.AF20 UG6.AF21 UG6.AF22 UG6.AF23 UG6.AF24 UG6.AF25 UG6.AF26 UG6.AF27 UG6.AF28 UG6.AF29 UG6.AF30 UG6.AF31 UG6.AF32 UG6.AF33 UG6.AF34 UG6.AF35 UG6.AF36 UG6.AF37 UG6.AF38 UG6.AF39 UG6.AF40 UG6.AF41 UG6.AF42 UG6.AF43 UG6.AF44 UG6.AH13 UG6.AH14 UG6.AH15 UG6.AH16 UG6.AH17 UG6.AH18 UG6.AH19 UG6.AH20 UG6.AH21 UG6.AH22 UG6.AH23 UG6.AH24 UG6.AH25 UG6.AH26 UG6.AH27 UG6.AH28 UG6.AH29 UG6.AH30 UG6.AH31 UG6.AH32 UG6.AH33 UG6.AH34 UG6.AH35 UG6.AH36 UG6.AH37 UG6.AH38 UG6.AH39 UG6.AH40 UG6.AH41 UG6.AH42 UG6.AH43 UG6.AH44 UG6.AK13 UG6.AK14 UG6.AK15 UG6.AK16 UG6.AK17 UG6.AK18 UG6.AK19 UG6.AK20 UG6.AK21 UG6.AK22 UG6.AK23 UG6.AK24 UG6.AK25 UG6.AK26 UG6.AK27 UG6.AK28 UG6.AK29 UG6.AK30 UG6.AK31 UG6.AK32 UG6.AK33 UG6.AK34 UG6.AK35 UG6.AK36 UG6.AK37 UG6.AK38 UG6.AK39 UG6.AK40 UG6.AK41 UG6.AK42 UG6.AK43 UG6.AK44 UG6.AM13 UG6.AM14 UG6.AM15 UG6.AM16 UG6.AM17 UG6.AM18 UG6.AM19 UG6.AM20 UG6.AM21 UG6.AM22 UG6.AM23 UG6.AM24 UG6.AM25 UG6.AM26 UG6.AM27 UG6.AM28 UG6.AM29 UG6.AM30 UG6.AM31 UG6.AM32 UG6.AM33 UG6.AM34 UG6.AM35 UG6.AM36 UG6.AM37 UG6.AM38 UG6.AM39 UG6.AM40 UG6.AM41 UG6.AM42 UG6.AM43 UG6.AM44 UG6.AP13 UG6.AP14 UG6.AP15 UG6.AP16 UG6.AP17 UG6.AP18 UG6.AP19 UG6.AP20 UG6.AP21 UG6.AP22 UG6.AP23 UG6.AP24 UG6.AP25 UG6.AP26 UG6.AP27 UG6.AP28 UG6.AP29 UG6.AP30 UG6.AP31 UG6.AP32 UG6.AP33 UG6.AP34 UG6.AP35 UG6.AP36 UG6.AP37 UG6.AP38 UG6.AP39 UG6.AP40 UG6.AP41 UG6.AP42 UG6.AP43 UG6.AP44 UG6.AT13 UG6.AT14 UG6.AT15 UG6.AT16 UG6.AT17 UG6.AT18 UG6.AT19 UG6.AT20 UG6.AT21 UG6.AT22 UG6.AT23 UG6.AT24 UG6.AT25 UG6.AT26 UG6.AT27 UG6.AT28 UG6.AT29 UG6.AT30 UG6.AT31 UG6.AT32 UG6.AT33 UG6.AT34 UG6.AT35 UG6.AT36 UG6.AT37 UG6.AT38 UG6.AT39 UG6.AT40 UG6.AT41 UG6.AT42 UG6.AT43 UG6.AT44 UG6.AU13 UG6.AU44 UG6.AV13 UG6.AV14 UG6.AV15 UG6.AV16 UG6.AV17 UG6.AV18 UG6.AV19 UG6.AV20 UG6.AV21 UG6.AV22 UG6.AV23 UG6.AV24 UG6.AV25 UG6.AV26 UG6.AV27 UG6.AV28 UG6.AV29 UG6.AV30 UG6.AV31 UG6.AV32 UG6.AV33 UG6.AV34 UG6.AV35 UG6.AV36 UG6.AV37 UG6.AV38 UG6.AV39 UG6.AV40 UG6.AV41 UG6.AV42 UG6.AV43 UG6.AV44 UG6.AW13 UG6.AW44 UG6.AY1 UG6.AY2 UG6.AY3 UG6.AY4 UG6.AY5 UG6.AY6 UG6.AY7 UG6.AY8 UG6.AY9 UG6.AY10 UG6.AY11 UG6.AY13 UG6.AY14 UG6.AY15 UG6.AY16 UG6.AY17 UG6.AY18 UG6.AY19 UG6.AY20 UG6.AY21 UG6.AY22 UG6.AY23 UG6.AY24 UG6.AY25 UG6.AY26 UG6.AY27 UG6.AY28 UG6.AY29 UG6.AY30 UG6.AY31 UG6.AY32 UG6.AY33 UG6.AY34 UG6.AY35 UG6.AY36 UG6.AY37 UG6.AY38 UG6.AY39 UG6.AY40 UG6.AY41 UG6.AY42 UG6.AY43 UG6.AY44 UG6.BA1 UG6.BA2 UG6.BA3 UG6.BA4 UG6.BA5 UG6.BA6 UG6.BA7 UG6.BA8 UG6.BA9 UG6.BA10 UG6.BA11 UG6.BA13 UG6.BA44 UG6.BB2 UG6.BB4 UG6.BB6 UG6.BB8 UG6.BB10 UG6.BB13 UG6.BB14 UG6.BB15 UG6.BB16 UG6.BB17 UG6.BB18 UG6.BB19 UG6.BB20 UG6.BB21 UG6.BB22 UG6.BB23 UG6.BB24 UG6.BB25 UG6.BB26 UG6.BB27 UG6.BB28 UG6.BB29 UG6.BB30 UG6.BB31 UG6.BB32 UG6.BB33 UG6.BB34 UG6.BB35 UG6.BB36 UG6.BB37 UG6.BB38 UG6.BB39 UG6.BB40 UG6.BB41 UG6.BB42 UG6.BB43 UG6.BB44 UG6.BC1 UG6.BC2 UG6.BC3 UG6.BC4 UG6.BC5 UG6.BC6 UG6.BC7 UG6.BC8 UG6.BC9 UG6.BC10 UG6.BC11 UG6.BC13 UG6.BC44 UG6.BD1 UG6.BD2 UG6.BD3 UG6.BD4 UG6.BD5 UG6.BD6 UG6.BD7 UG6.BD8 UG6.BD9 UG6.BD10 UG6.BD11 UG6.BD13 UG6.BD14 UG6.BD17 UG6.BD18 UG6.BD21 UG6.BD22 UG6.BD25 UG6.BD26 UG6.BD28 UG6.BD29 UG6.BD31 UG6.BD32 UG6.BD35 UG6.BD36 UG6.BD39 UG6.BD40 UG6.BD43 UG6.BD44 UG6.BD46 UG6.BE47 UG6.BF44 UG6.BF46 UG6.BF47 UG6.BF48 UG6.BG45 UG6.BG46 UG6.BG47 UG6.BG48 UG6.BH46 UG6.BH47 UG6.BH49 UG6.BJ46 UG6.BJ47 UG6.BJ48 UG6.BJ49 UG6.BJ50 UG6.BJ51 UG6.BK47 UG6.BK49 UG6.BK50 UG6.BK51 UG6.BK52 UG6.BL48 UG6.BL49 UG6.BL50 UG6.BL51 UG6.BL53 UG6.BM49 UG6.BM50 UG6.BM52 UG6.BM53 UG6.BM54 UG6.BN50 UG6.BN51 UG6.BN52 UG6.BN53 UG6.BN54 UG6.BN55 UG6.BP52 UG6.BP53 UG6.BP54 UG6.BP55 UG6.BP56 UG6.BR52 UG6.BR53 UG6.BR54 UG6.BR55 UG6.BR56 UG6.BT52 UG6.BT54 UG6.BT55 UG6.N13 UG6.N15 UG6.N17 UG6.N19 UG6.N21 UG6.N23 UG6.N25 UG6.N27 UG6.N30 UG6.N32 UG6.N34 UG6.N36 UG6.N38 UG6.N40 UG6.N42 UG6.N44 UG6.P13 UG6.P14 UG6.P15 UG6.P16 UG6.P17 UG6.P18 UG6.P19 UG6.P20 UG6.P21 UG6.P22 UG6.P23 UG6.P24 UG6.P25 UG6.P26 UG6.P27 UG6.P28 UG6.P29 UG6.P30 UG6.P31 UG6.P32 UG6.P33 UG6.P34 UG6.P35 UG6.P36 UG6.P37 UG6.P38 UG6.P39 UG6.P40 UG6.P41 UG6.P42 UG6.P43 UG6.P44 UG6.T13 UG6.T14 UG6.T15 UG6.T16 UG6.T17 UG6.T18 UG6.T19 UG6.T20 UG6.T21 UG6.T22 UG6.T23 UG6.T24 UG6.T25 UG6.T26 UG6.T27 UG6.T28 UG6.T29 UG6.T30 UG6.T31 UG6.T32 UG6.T33 UG6.T34 UG6.T35 UG6.T36 UG6.T37 UG6.T38 UG6.T39 UG6.T40 UG6.T41 UG6.T42 UG6.T43 UG6.T44 UG6.V13 UG6.V14 UG6.V15 UG6.V16 UG6.V17 UG6.V18 UG6.V19 UG6.V20 UG6.V21 UG6.V22 UG6.V23 UG6.V24 UG6.V25 UG6.V26 UG6.V27 UG6.V28 UG6.V29 UG6.V30 UG6.V31 UG6.V32 UG6.V33 UG6.V34 UG6.V35 UG6.V36 UG6.V37 UG6.V38 UG6.V39 UG6.V40 UG6.V41 UG6.V42 UG6.V43 UG6.V44 UG6.Y13 UG6.Y14 UG6.Y15 UG6.Y16 UG6.Y17 UG6.Y18 UG6.Y19 UG6.Y20 UG6.Y21 UG6.Y22 UG6.Y23 UG6.Y24 UG6.Y25 UG6.Y26 UG6.Y27 UG6.Y28 UG6.Y29 UG6.Y30 UG6.Y31 UG6.Y32 UG6.Y33 UG6.Y34 UG6.Y35 UG6.Y36 UG6.Y37 UG6.Y38 UG6.Y39 UG6.Y40 UG6.Y41 UG6.Y42 UG6.Y43 UG6.Y44
NVVDD_CORE1: CG525.2 DG3.1(CATHODE) DG4.2 DG5.1(CATHODE) DG6.2 RG83.1 RG177.1 UG8.4
NVVDD_CORE1_EN: CG400.1 DG4.1(CATHODE) PD2.1(CATHODE) PR167.2 RG83.2 RG89.2
NVVDD_EN: RG150.1 UG6.BM3 UG8.2
NVVDD_PG_LOOP_OVT: QG20.2 QG21.3 QG21.6 RG181.2
NVVDD_PGOOD: DG1.1 PR188.2 QG21.2 RG94.1 RG182.2
NVVDD_PSI: PR186.2 UG6.BM1
NVVDD_PWM_GPU: PR183.2 UG6.BP2
NVVDD_SENSE_I: PR69.2 PR479.2
NVVDD_SENSE_V: PR78.2 PR400.1 PR480.2
OUT_DP_TXN0: C861.2 U56.39
OUT_DP_TXN1: C865.2 U56.36
OUT_DP_TXN2: C863.2 U56.34
OUT_DP_TXN3: C866.2 U56.31
OUT_DP_TXP0: C862.2 U56.40
OUT_DP_TXP1: C868.2 U56.37
OUT_DP_TXP2: C864.2 U56.33
OUT_DP_TXP3: C867.2 U56.30
OVERT#: QG19.1(S) RG129.2 UG6.BK7
PANEL_OD: CN2.20 Q128.3 R1229.2 R1230.2
PANEL_OD_R: Q128.2 R1229.1 U49.AJ8
PBLED: Q83.2 R484.1 R731.2
PBLED#: CN1.7 D53.1 Q83.3
PBLED_R: C452.1 R484.2 U23.81
PCBEEP_EC: D26.2 U23.34
PCH_2_CPU_TRIG: R906.1 U42.CT23
PCH_2_CPU_TRIG_R: R906.2 U49.AL4
PCH_AZ_CODEC_RST#_PD: D20.1(CATHODE) Q23.3
PCH_BLON_EC: R718.1 U23.88
PCH_DISP_ON: R571.1 TP20.1 U43.1 U49.V45
PCH_DMIC_CLK: R61.1 R432.1 U17.3
PCH_DMIC_DAT: R59.1 R460.1 R461.1 U19.3
PCH_DPST_PWM: R499.1 U4.7 U49.T35
PCH_LVDS_BLON: QG25.3 R516.1 TP23.1 U45.1 U49.T37
PCH_PWROK: R632.2 U23.78
PCH_SLP_S0IX#: R441.1 R1006.1 U49.BE40
PCH_SPI1_CLK: R1020.1 RS2.2 U49.AN39
PCH_SPI1_CLK_R: R1015.2 R1016.1 R1020.2 R1029.1
PCH_SPI1_SI: R492.2 R508.1 R1024.1 U49.AP35
PCH_SPI1_SI_R: R1014.2 R1024.2 R1042.1 R1043.1
PCH_SPI1_SO: R1111.1 U49.AP37
PCH_SPI1_SO_R: R1110.2 R1111.2 R1131.1 R1132.1
PCH_SPI_CLK_EC: R1016.2 U23.105
PCH_SPI_CS0#: R1086.1 U49.AR42
PCH_SPI_CS0#_R: R1086.2 R1108.1 R1129.1
PCH_SPI_IO2: R562.1 R568.2 R1109.1 U49.AR43
PCH_SPI_IO2_R: R1109.2 R1130.1
PCH_SPI_IO3: R547.2 R558.1 R1030.1 U49.AM42
PCH_SPI_IO3_R: R1030.2 R1047.1
PCH_SPI_SI_EC: R360.1 R1042.2 U23.102
PCH_SPI_SO_EC: R359.1 R1132.2 U23.103
PCH_TBT_PERST#: R550.2 R551.1 R575.1 U28.2
PCIE4_RCOMP_N: R103.2 U42.R26
PCIE4_RCOMP_P: R103.1 U42.T26
PCIE16_RCOMP_N: R106.2 U42.R11
PCIE16_RCOMP_P: R106.1 U42.U11
PCIE_8_PCH_RX_WWAN_TX_C_N: CN7.41 R252.1
PCIE_8_PCH_RX_WWAN_TX_C_P: CN7.43 R260.1
PCIE_8_PCH_TX_WWAN_RX_C_N: C721.1 CN7.47
PCIE_8_PCH_TX_WWAN_RX_C_P: C723.1 CN7.49
PCIE_CLKREQ6#: R346.1 TPS1.1 U49.BA7
PCIE_CLKREQ7#: R369.1 TPS2.1 U49.AR11
PCIE_CLKREQ_LAN#: CN10.13 R1005.1 U49.BC38
PCIE_CLKREQ_SSD1#: CN6.52 R997.1 U49.BE38
PCIE_CLKREQ_SSD#: CN13.52 R994.1 U49.BC37
PCIE_CLKREQ_VGA#: QG9.3 R999.1 U49.BF37
PCIE_CLKREQ_WLAN#: Q43.1(S) R996.1 U49.BD37
PCIE_CLKREQ_WWAN#: CN7.52 R917.1 U49.BB3
PCIE_RXN8_WWAN: R252.2 U49.H24
PCIE_RXN_LAN: CN10.8 U49.J41
PCIE_RXN_WLAN: CN12.43 U49.D45
PCIE_RXP8_WWAN: R260.2 U49.F24
PCIE_RXP_LAN: CN10.9 U49.H42
PCIE_RXP_WLAN: CN12.41 U49.C46
PCIE_TXN8_WWAN: C721.2 U49.A22
PCIE_TXN_LAN: CN10.3 U49.D38
PCIE_TXN_WLAN: C766.2 U49.C39
PCIE_TXN_WLAN_C: C766.1 CN12.37
PCIE_TXP8_WWAN: C723.2 U49.B21
PCIE_TXP_LAN: CN10.2 U49.E38
PCIE_TXP_WLAN: C765.2 U49.D39
PCIE_TXP_WLAN_C: C765.1 CN12.35
PCIE_WAKE#: CN10.12 Q27.3 Q38.3 Q109.3 R1067.1 U49.AD47
PCIECOMP_N: R946.2 U49.A13
PCIECOMP_P: R946.1 U49.B13
PCM_CLK: CN12.8 R1001.1
PCM_IN: CN12.12 R998.1
PD: C6.2 Q6.3 U36.15
PD#: C400.1 D20.2 D21.2 R409.1 R425.2 U20.2
PD_I2C_INT#: Q105.3 R315.1 R844.1 U49.AE6
PD_I2C_INT#_D: Q105.1(S) R844.2 R853.1 TP125.1 U11.F2
PD_I2C_SCL: Q106.6 R848.1 R987.1 U49.BF33
PD_I2C_SDA: Q106.3 R871.1 R983.1 U49.BB30
PD_LDO_1V5: C245.1 R851.1 R852.1 U11.G2 U11.H1
PD_LDO_3V3: C232.1 R175.1 R847.1 R860.1 U11.H3
PDEC_I2C_IRQ#: Q22.3 R193.1 R363.2
PDEC_I2C_IRQ#_R: C377.2 R348.1 R363.1 U23.98
PEG11_RXN0_SSD: R1008.1 U42.M22
PEG11_RXN0_SSD_R: CN13.41 R1008.2
PEG11_RXN1_SSD: R1044.1 U42.K22
PEG11_RXN1_SSD_R: CN13.29 R1044.2
PEG11_RXN2_SSD: R1062.1 U42.L24
PEG11_RXN2_SSD_R: CN13.17 R1062.2
PEG11_RXN3_SSD: R1084.1 U42.J24
PEG11_RXN3_SSD_R: CN13.5 R1084.2
PEG11_RXP0_SSD: R1004.1 U42.N22
PEG11_RXP0_SSD_R: CN13.43 R1004.2
PEG11_RXP1_SSD: R1028.1 U42.J22
PEG11_RXP1_SSD_R: CN13.31 R1028.2
PEG11_RXP2_SSD: R1059.1 U42.M24
PEG11_RXP2_SSD_R: CN13.19 R1059.2
PEG11_RXP3_SSD: R1071.1 U42.H24
PEG11_RXP3_SSD_R: CN13.7 R1071.2
PEG11_SSD_DBG#: R375.1 U25.2 U49.AL9
PEG11_TXN0_SSD: C781.2 U42.D22
PEG11_TXN0_SSD_R: C781.1 CN13.47
PEG11_TXN1_SSD: C791.2 U42.B22
PEG11_TXN1_SSD_R: C791.1 CN13.35
PEG11_TXN2_SSD: C806.2 U42.E23
PEG11_TXN2_SSD_R: C806.1 CN13.23
PEG11_TXN3_SSD: C821.2 U42.C23
PEG11_TXN3_SSD_R: C821.1 CN13.11
PEG11_TXP0_SSD: C777.2 U42.E22
PEG11_TXP0_SSD_R: C777.1 CN13.49
PEG11_TXP1_SSD: C783.2 U42.A22
PEG11_TXP1_SSD_R: C783.1 CN13.37
PEG11_TXP2_SSD: C804.2 U42.F23
PEG11_TXP2_SSD_R: C804.1 CN13.25
PEG11_TXP3_SSD: C818.2 U42.B23
PEG11_TXP3_SSD_R: C818.1 CN13.13
PEG12_RXN0_SSD: R872.1 U42.M26
PEG12_RXN0_SSD_R: CN6.41 R872.2
PEG12_RXN1_SSD: R908.1 U42.K26
PEG12_RXN1_SSD_R: CN6.29 R908.2
PEG12_RXN2_SSD: R919.1 U42.L28
PEG12_RXN2_SSD_R: CN6.17 R919.2
PEG12_RXN3_SSD: R934.1 U42.J28
PEG12_RXN3_SSD_R: CN6.5 R934.2
PEG12_RXP0_SSD: R868.1 U42.N26
PEG12_RXP0_SSD_R: CN6.43 R868.2
PEG12_RXP1_SSD: R892.1 U42.J26
PEG12_RXP1_SSD_R: CN6.31 R892.2
PEG12_RXP2_SSD: R918.1 U42.M28
PEG12_RXP2_SSD_R: CN6.19 R918.2
PEG12_RXP3_SSD: R929.1 U42.H28
PEG12_RXP3_SSD_R: CN6.7 R929.2
PEG12_SSD_DBG#: R328.1 U12.2 U49.AM8
PEG12_TXN0_SSD: C726.2 U42.D25
PEG12_TXN0_SSD_R: C726.1 CN6.47
PEG12_TXN1_SSD: C730.2 U42.B25
PEG12_TXN1_SSD_R: C730.1 CN6.35
PEG12_TXN2_SSD: C733.2 U42.E27
PEG12_TXN2_SSD_R: C733.1 CN6.23
PEG12_TXN3_SSD: C740.2 U42.C27
PEG12_TXN3_SSD_R: C740.1 CN6.11
PEG12_TXP0_SSD: C725.2 U42.E25
PEG12_TXP0_SSD_R: C725.1 CN6.49
PEG12_TXP1_SSD: C727.2 U42.A25
PEG12_TXP1_SSD_R: C727.1 CN6.37
PEG12_TXP2_SSD: C732.2 U42.F27
PEG12_TXP2_SSD_R: C732.1 CN6.25
PEG12_TXP3_SSD: C738.2 U42.B27
PEG12_TXP3_SSD_R: C738.1 CN6.13
PEG_RXN0: CG389.2 U42.M15
PEG_RXN0_C: CG389.1 UG6.BM31
PEG_RXN1: CG376.2 U42.K15
PEG_RXN1_C: CG376.1 UG6.BK32
PEG_RXN2: CG387.2 U42.L17
PEG_RXN2_C: CG387.1 UG6.BM33
PEG_RXN3: CG374.2 U42.J17
PEG_RXN3_C: CG374.1 UG6.BK34
PEG_RXN4: CG385.2 U42.M18
PEG_RXN4_C: CG385.1 UG6.BM35
PEG_RXN5: CG372.2 U42.K18
PEG_RXN5_C: CG372.1 UG6.BK36
PEG_RXN6: CG383.2 U42.L20
PEG_RXN6_C: CG383.1 UG6.BM37
PEG_RXN7: CG370.2 U42.J20
PEG_RXN7_C: CG370.1 UG6.BK38
PEG_RXP0: CG390.2 U42.N15
PEG_RXP0_C: CG390.1 UG6.BL31
PEG_RXP1: CG377.2 U42.J15
PEG_RXP1_C: CG377.1 UG6.BJ32
PEG_RXP2: CG388.2 U42.M17
PEG_RXP2_C: CG388.1 UG6.BL33
PEG_RXP3: CG375.2 U42.H17
PEG_RXP3_C: CG375.1 UG6.BJ34
PEG_RXP4: CG386.2 U42.N18
PEG_RXP4_C: CG386.1 UG6.BL35
PEG_RXP5: CG373.2 U42.J18
PEG_RXP5_C: CG373.1 UG6.BJ36
PEG_RXP6: CG384.2 U42.M20
PEG_RXP6_C: CG384.1 UG6.BL37
PEG_RXP7: CG371.2 U42.H20
PEG_RXP7_C: CG371.1 UG6.BJ38
PEG_TXN0: C682.2 UG6.BT32
PEG_TXN0_C: C682.1 U42.D16
PEG_TXN1: C679.2 UG6.BR33
PEG_TXN1_C: C679.1 U42.B16
PEG_TXN2: C677.2 UG6.BT34
PEG_TXN2_C: C677.1 U42.E17
PEG_TXN3: C675.2 UG6.BR35
PEG_TXN3_C: C675.1 U42.C17
PEG_TXN4: C673.2 UG6.BT36
PEG_TXN4_C: C673.1 U42.D18
PEG_TXN5: C669.2 UG6.BR37
PEG_TXN5_C: C669.1 U42.B18
PEG_TXN6: C667.2 UG6.BT38
PEG_TXN6_C: C667.1 U42.E20
PEG_TXN7: C665.2 UG6.BR39
PEG_TXN7_C: C665.1 U42.C20
PEG_TXP0: C681.2 UG6.BR32
PEG_TXP0_C: C681.1 U42.E16
PEG_TXP1: C680.2 UG6.BP33
PEG_TXP1_C: C680.1 U42.A16
PEG_TXP2: C678.2 UG6.BR34
PEG_TXP2_C: C678.1 U42.F17
PEG_TXP3: C676.2 UG6.BP35
PEG_TXP3_C: C676.1 U42.B17
PEG_TXP4: C674.2 UG6.BR36
PEG_TXP4_C: C674.1 U42.E18
PEG_TXP5: C670.2 UG6.BP37
PEG_TXP5_C: C670.1 U42.A18
PEG_TXP6: C668.2 UG6.BR38
PEG_TXP6_C: C668.1 U42.F20
PEG_TXP7: C666.2 UG6.BP39
PEG_TXP7_C: C666.1 U42.B20
PEGX_RST#: QG19.2 RG68.2 RG85.2 RG101.2 RG103.2 RG181.1 UG6.BT30
PEX_CLKREQ: QG9.1(S) RG76.1 UG6.BP31
PEX_TERMP: RG137.2 UG6.BT50
PEXVDD_EN_U: CG528.1 DG3.2 RG177.2 RG179.2 UG9.2
PLTRST#: CN10.11 D18.1(CATHODE) R197.2 R495.2 R536.2 R548.1 R951.2 U12.1 U18.17 U25.1 U28.1 U49.BD39 UG1.2
PLTRST#_EC: C470.2 R509.2 R514.2 U23.22
PM_SYNC: R879.1 U42.CR23
PM_SYNC_R: C731.1 R879.2 TP138.1 U49.AH4
PM_THRMTRIP#: D50.2 D56.2 Q19.3 Q33.3 Q97.1(EMITTER) R811.2 R886.1 U42.F34
PM_THRMTRIP#_P: R886.2 TP137.1 U49.AD3
PMON: PC260.2 PR325.2 PR328.1 PR363.1
PP: T1.1 U18.4
PROCHOT_EC: C456.1 Q46.2 R489.2 U23.17
PS1_I2C_IRQ: R1050.1 R1056.1 U50.A2
PS1_I2C_SCL: R1034.1 R1035.1 U50.B1
PS1_I2C_SDA: R1032.1 R1033.1 U50.A1
PS1_MBCLK: Q51.3 R566.2 R1035.2
PS1_MBDATA: Q51.6 R567.2 R1032.2
PS1_SENS_CS1: J2.1 U50.B3
PS2_I2C_IRQ: R1055.1 R1058.1 U51.A2
PS2_I2C_SCL: R1040.1 R1041.1 U51.B1
PS2_I2C_SDA: R1038.1 R1039.1 U51.A1
PS2_MBCLK: Q49.4 R506.2 R1040.2
PS2_MBDATA: Q49.1(S) R507.2 R1039.2
PS2_SENS_CS1: J3.1 U51.B3
PS8811_MBCLK: Q47.3 R485.2 U24.33
PS8811_MBDATA: Q47.6 R494.2 U24.32
PS8817_MBCLK: CN10.33 Q40.1(S) R396.1
PS8817_MBDATA: CN10.34 Q40.4 R395.1
PS_FBVDD_PGOOD: DG1.2 PR388.2 Q68.2 UG3.1
PTP_PWR_EN#: C551.1 Q60.2 R593.1
PULSAR_38P4M_REFCLK: CN12.64 TP146.1
PWM_OUT_EN: R83.2 R597.1 TP80.1 U49.Y48
PWM_OUT_EN_EC: R85.2 R86.1
PWM_OUT_EN_EC_R: R84.2 R86.2 U23.125
PWM_SW_SELECT: RG166.1 RG172.1 TP21.1 UG6.BJ4
PWM_SW_SELECT_Q: R80.1 TP5.1 TP6.1 UG10.4(Y)
PWR_LEVEL: DG2.2 QG24.1(S) RG168.2 RG174.1 UG6.BK2
PWRLED#: CN1.21 D3.1 R528.2
R_CTL: Q2.2 Q34.5 Q65.5 Q73.5 Q78.6 R10.1 R340.1 R651.1 R687.1 R721.2
R_CTL_LOGO: Q126.5 R1215.1 U1.32
R_CTL_LOGO_C: CN1.17 R1212.1
R_CTL_MCU: Q78.2 R717.2 R721.1 U1.21
R_CTL_TURBO: Q81.5 R726.1
R_CTL_TURBO_C: CN1.15 R730.1 U1.27
R_CTRL_LEFT: CN14.2 R289.1
R_CTRL_RIGHT: CN22.2 R649.1
R_SPK+: R1148.1 U20.45
R_SPK+_C: C842.2 CN20.4 R1148.2
R_SPK-: R1147.1 U20.44
R_SPK-_C: C841.2 CN20.3 R1147.2
RCOMP_1P8: R936.2 U49.BF8
REGN6V: PC264.1 PR313.1 PU18.24
RESETB: C460.1 R497.2 U24.16
REXT: R515.1 U24.29
RF_EN: C507.1 CN12.56 R574.1 R922.1 R926.1 R926.2 R933.1
RF_EN_PCH: R501.1 R922.2 U49.AU34
RINRVP: C467.2 R531.2 TP70.1 U21.25
RIP: L9.2 R531.1 U21.24
ROM_CS: RG121.1 UG6.BP7
ROM_CS_R: RG116.2 RG121.2 TPG52.1 UG7.1
ROM_SCLK: RG135.1 RG142.2 RG143.1 UG6.BT7
ROM_SCLK_R: RG135.2 TPG53.1 UG7.6
ROM_SI: RG134.1 RG136.1 RG138.2 UG6.BR7
ROM_SI_R: RG136.2 TPG54.1 UG7.5
ROM_SO: RG117.1 RG123.2 TPG50.1 UG6.BT8 UG7.2
RSMRST#: C523.1 R617.2 TP81.1 U23.112 U49.AA45
RSVD_TP_15: TP15.1 U42.R24
RT_I2C_INT: Q25.1(S) R206.1 R217.1 R443.1 U9.A10 U16.A10
RT_I2C_INT#_D: Q25.3 R206.2 R214.1 TP38.1 U11.B1
RT_I2C_SCL: Q29.1(S) R254.1 R866.1 R961.1 U9.C9 U16.C9
RT_I2C_SCL_D: Q29.6 R230.1 R254.2 TP43.1 U11.A2 U14.6
RT_I2C_SDA: Q29.4 R255.1 R867.1 R962.1 U9.E7 U16.E7
RT_I2C_SDA_D: Q29.3 R231.1 R255.2 TP41.1 U11.A1 U11.B2 U14.5
RT_PWR_EN_P1: R121.1 R842.1 U5.C2
RT_PWR_EN_P1_C: R842.2 U11.G6
RT_PWR_EN_P2: R256.1 R881.1 U13.C2
RT_PWR_EN_P2_C: R881.2 U11.B6
RT_RESET_P1: R153.2 R882.1
RT_RESET_P1_C: R882.2 U11.B3
RT_RESET_P2: R324.2 R870.1
RT_RESET_P2_C: R870.2 U11.C2
RTC_RST#: C825.1 J4.1 Q112.3 R1103.2 U49.AM45
RTC_X1: R1070.2 U49.AM46
RTC_X1_C: C829.2 R1070.1 R1083.1 Y4.1
RTC_X2: R1069.2 U49.AM48
RTC_X2_C: C828.2 R1069.1 R1083.2 Y4.2
RVN: C462.2 L10.2 TP68.1 U21.26
S5_ON: PQ26.2 PR252.2 PR258.2 PR262.2 PR306.1 PR618.2 PU16.1 R361.1 U23.100
S5_ON_R: PC206.1 PC226.1 PC227.1 PR262.1 PR306.2 PU13.3 PU13.5 PU17.3 PU17.5
SATA_LED#: CN1.22 D5.1 EC1.2 R582.1 R930.2 R1072.2 U49.L47
SATA_RXN0_CN: C848.1 CN18.16
SATA_RXN0_HDD: C831.2 U49.H38
SATA_RXN_IN: C831.1 U55.4
SATA_RXN_OUT: C848.2 U55.12
SATA_RXP0_CN: C849.1 CN18.15
SATA_RXP0_HDD: C832.2 U49.G39
SATA_RXP_IN: C832.1 U55.5
SATA_RXP_OUT: C849.2 U55.11
SATA_TXN0_CN: C847.1 CN18.18
SATA_TXN0_HDD: C833.2 U49.C38
SATA_TXN_IN: C833.1 U55.2
SATA_TXN_OUT: C847.2 U55.14
SATA_TXP0_CN: C846.1 CN18.19
SATA_TXP0_HDD: C835.2 U49.B37
SATA_TXP_IN: C835.1 U55.1
SATA_TXP_OUT: C846.2 U55.15
SIM_DET: QG16.3 R250.1 R258.1 R430.1 R585.1
SIO_EXT_SCI#: R975.1 TP61.1 U49.BB26
SKTOCC_N: TP112.1 U42.CR3
SLP_A#: R1081.1 U49.AF46
SLP_S5#: R1106.1 TP167.1 U49.AJ47
SLP_SUS#_EC: C822.1 PU16.2 R576.2 R1068.1 U23.35 U49.AD46
SLP_WLAN#_R: Q55.2 R1107.1 TP176.1 U49.AJ46
SLP_WLAN_PWR#: Q55.3 R588.1 R611.1 R614.2
SM_INTRUDER#: R1105.1 U49.AE47
SM_RCOMP_2: R815.2 U42.D2
SMB1_CLK_D: Q106.1(S) R848.2 R858.1 TP129.1 U11.E2
SMB1_DAT_D: Q106.4 R862.1 R871.2 TP134.1 U11.D2
SMB_PCH_CLK: Q108.6 R970.1 U49.BE26
SMB_PCH_DAT: Q108.3 R969.1 U49.BD25
SMB_RUN_CLK: JDIM1.253 JDIM2.253 Q108.1(S) R912.1
SMB_RUN_DAT: JDIM1.254 JDIM2.254 Q108.4 R923.1
SMB_SML0_CLK: R986.1 R1222.2 R1224.2 U49.BE32
SMB_SML0_CLK_R1: R219.1 R1222.1 U9.A7
SMB_SML0_CLK_R2: R445.1 R1224.1 U16.A7
SMB_SML0_DAT: R989.1 R1223.2 R1225.2 U49.BC33
SMB_SML0_DAT_R1: R220.1 R1223.1 U9.B7
SMB_SML0_DAT_R2: R446.1 R1225.1 U16.B7
SML0ALERT#: R980.1 R982.2 U49.BD27
SML1ALERT#_R: R1017.2 R1019.1 U49.BD42
SML2ALERT#: R924.1 R927.2 U49.BG5
SML3ALERT#: R937.1 R941.2 U49.BA11
SMLALERT#: R974.1 R976.2 R979.2 U49.BD26
SNDW_RCOMP: R965.2 U49.BF21
SNN_FBA_RFU_G5: TPG31.1 VRAM6.G5
SNN_FBA_RFU_G5_1: TPG48.1 VRAM8.G5
SNN_FBA_RFU_M5: TPG35.1 VRAM6.M5
SNN_FBA_RFU_M5_1: TPG47.1 VRAM8.M5
SNN_FBA_TCK0: TPG34.1 VRAM6.N5
SNN_FBA_TCK1: TPG46.1 VRAM8.N5
SNN_FBA_TDI0: TPG41.1 VRAM6.F10
SNN_FBA_TDI1: TPG44.1 VRAM8.F10
SNN_FBA_TDO0: TPG39.1 VRAM6.N10
SNN_FBA_TDO1: TPG43.1 VRAM8.N10
SNN_FBA_TMS0: TPG33.1 VRAM6.F5
SNN_FBA_TMS1: TPG45.1 VRAM8.F5
SNN_FBB_RFU_G5: TPG7.1 VRAM1.G5
SNN_FBB_RFU_G5_1: TPG23.1 VRAM4.G5
SNN_FBB_RFU_M5: TPG11.1 VRAM1.M5
SNN_FBB_RFU_M5_1: TPG26.1 VRAM4.M5
SNN_FBB_TCK1: TPG27.1 VRAM4.N5
SNN_FBB_TDI1: TPG19.1 VRAM4.F10
SNN_FBB_TDO1: TPG20.1 VRAM4.N10
SNN_FBB_TMS1: TPG24.1 VRAM4.F5
SNN_FBC_RFU_G5: TPG8.1 VRAM3.G5
SNN_FBC_RFU_G5_1: TPG14.1 VRAM2.G5
SNN_FBC_RFU_M5: TPG13.1 VRAM3.M5
SNN_FBC_RFU_M5_1: TPG6.1 VRAM2.M5
SNN_FBC_TCK0: TPG12.1 VRAM3.N5
SNN_FBC_TCK1: TPG2.1 VRAM2.N5
SNN_FBC_TDI0: TPG5.1 VRAM3.F10
SNN_FBC_TDI1: TPG18.1 VRAM2.F10
SNN_FBC_TDO0: TPG10.1 VRAM3.N10
SNN_FBC_TDO1: TPG9.1 VRAM2.N10
SNN_FBC_TMS0: TPG4.1 VRAM3.F5
SNN_FBC_TMS1: TPG16.1 VRAM2.F5
SNN_FBD_RFU_G5: TPG42.1 VRAM7.G5
SNN_FBD_RFU_G5_1: TPG21.1 VRAM5.G5
SNN_FBD_RFU_M5: TPG40.1 VRAM7.M5
SNN_FBD_RFU_M5_1: TPG28.1 VRAM5.M5
SNN_FBD_TCK0: TPG38.1 VRAM7.N5
SNN_FBD_TCK1: TPG25.1 VRAM5.N5
SNN_FBD_TDI0: TPG36.1 VRAM7.F10
SNN_FBD_TDI1: TPG29.1 VRAM5.F10
SNN_FBD_TDO0: TPG32.1 VRAM7.N10
SNN_FBD_TDO1: TPG30.1 VRAM5.N10
SNN_FBD_TMS0: TPG37.1 VRAM7.F5
SNN_FBD_TMS1: TPG22.1 VRAM5.F5
SPI1_CLK_R: C795.1 R1029.2 U53.6
SPI1_SI_R: R1043.2 U53.5
SPI1_SO_R: R1131.2 U53.2
SPI_CS0#_R: R1129.2 U53.1
SPI_CS0#_UR_ME: R1108.2 U23.101
SPI_IO2_R: R1130.2 U53.3(W\P\(IO2))
SPI_IO3_R: R1047.2 U53.7
SPI_TPM_CS#: R385.1 R545.1
SPI_TPM_CS#_R: R545.2 U49.AP41
SPK_LED_ON_OFF: Q114.2 R390.1
SPKLN_L: L18.1 U21.39
SPKLP_L: L17.1 U21.40
SPKRN_L: L9.1 U21.46
SPKRP_L: L10.1 U21.45
SRCCLKREQ5#: R1000.1 TP75.1 U49.BD38
SRTC_RST#: C834.1 J5.1 Q113.3 R1116.2 U49.AM47
SSD1_DET: R1128.1 TP171.1 U49.P47
STRAP0: RG77.1 RG82.2 UG6.BM5
STRAP1: RG72.1 RG81.2 UG6.BN5
STRAP2: RG71.1 RG80.2 UG6.BP4
STRAP3: RG153.1 RG162.2 UG6.BP3
STRAP4: RG152.1 RG161.2 UG6.BR3
STRAP5: RG151.1 RG160.2 UG6.BR4
STRP1: R39.2 U1.6
STRP2: R38.2 U1.7
SUSB#: PU3.2 R69.1 R587.1 R1099.1 TP159.1 U41.2 U49.AF47
SUSC#: R583.1 R1087.1 TP174.1 U49.AE46
SUSCLK: R595.2 U49.AJ45
SUSCLK_32K: CN12.50 R595.1
SUSD: PC221.1 PQ29.2 PQ33.3 PR304.2
SUSON: PQ34.2 PR46.1 PR347.1 PR540.1 PR632.1 R355.1 U23.120
SX9310_GND1: C805.2 C810.2 J2.2 J2.3 J2.4(GND_3) R1065.2 U50.A3 U50.B2
SX9310_GND2: C809.2 C813.2 J3.2 J3.3 J3.4(GND_3) R1066.2 U51.A3 U51.B2
SYS_HWPG: D43.1(CATHODE) PR289.2 U23.124
SYS_PWROK: R624.1 R627.1 R633.1 R876.1 R1085.2 TP82.1 TP136.1 U30.4
SYS_PWROK_R: R622.1 R876.2 R877.1 U49.AN5
SYS_RESET#: R910.1 TP140.1 U49.AP3
SYS_SHDN#: PR275.2 PR294.1 PR512.2 PU15.6 Q97.3 U23.85
SYSTEM_AGND: PR274.1 PR277.2 PR278.2 PR279.2 PR283.1
TBT1_CC1: C230.2 CN5.B5 D58.2 U11.G5
TBT1_CC2: C237.2 CN5.A5 D58.1 U11.H5
TBT2_CC1: C294.2 CN9.B5 D60.2 U11.B5
TBT2_CC2: C293.2 CN9.A5 D60.1 U11.A5
TBT_FORCE_PWR: R216.2 R240.1 R442.2 R467.1 R859.1 U9.B10 U16.B10 U49.W46
TBT_FORCE_PWR_C: R859.2 U11.F6
TBT_LSX0_RXD: R146.1 R411.2 R415.1 U49.AU19
TBT_LSX0_RXD_C: R146.2 R156.1 U9.L7
TBT_LSX0_TXD: R145.1 U49.AW18
TBT_LSX0_TXD_C: R145.2 R155.1 U9.M7
TBT_LSX2_RXD: R306.1 R954.2 R955.1 U49.BC17
TBT_LSX2_RXD_C: R306.2 R327.1 U16.L7
TBT_LSX2_TXD: R305.1 U49.BE18
TBT_LSX2_TXD_C: R305.2 R326.1 U16.M7
TBT_RST_EC#: R84.1 R152.2 R323.2
TBT_SBU1_P1_CON: CN5.B8 D10.1 R160.1 R1218.2
TBT_SBU1_P1_CON_S: R1218.1 U9.M10
TBT_SBU1_P2_CON: CN9.B8 D22.2 R300.1 R1220.2
TBT_SBU1_P2_CON_S: R1220.1 U16.M10
TBT_SBU2_P1_CON: CN5.A8 D10.2 R154.1 R1219.1
TBT_SBU2_P1_CON_S: R1219.2 U9.L10(PB_SBU2)
TBT_SBU2_P2_CON: CN9.A8 D22.1 R285.1 R1221.1
TBT_SBU2_P2_CON_S: R1221.2 U16.L10(PB_SBU2)
TBTA_HPD: R184.1 R185.1
TBTA_HPD_C: R184.2 U11.G1
TBTA_RX1_N: C227.2 CN5.A10 R834.2
TBTA_RX1_P: C219.2 CN5.A11 R829.2
TBTA_RX2_N: C270.2 CN5.B10 R183.2
TBTA_RX2_P: C281.2 CN5.B11 R194.2
TBTA_SSRX1_N: R170.1 U9.J11
TBTA_SSRX1_N_C: C227.1 D11.1 R170.2
TBTA_SSRX1_P: R161.1 U9.J12
TBTA_SSRX1_P_C: C219.1 D9.1 R161.2
TBTA_SSRX2_N: R201.1 U9.C11
TBTA_SSRX2_N_C: C270.1 D17.1 R201.2
TBTA_SSRX2_P: R205.1 U9.C12
TBTA_SSRX2_P_C: C281.1 D19.1 R205.2
TBTA_SSTX1_N: R179.1 U9.G11
TBTA_SSTX1_N_C: C243.1 D13.1 R179.2
TBTA_SSTX1_P: R176.1 U9.G12
TBTA_SSTX1_P_C: C235.1 D12.1 R176.2
TBTA_SSTX2_N: R186.1 U9.E11
TBTA_SSTX2_N_C: C252.1 D14.1 R186.2
TBTA_SSTX2_P: R195.1 U9.E12
TBTA_SSTX2_P_C: C259.1 D16.1 R195.2
TBTA_TX1_N: C243.2 CN5.B3 R150.2
TBTA_TX1_P: C235.2 CN5.B2 R138.2
TBTA_TX2_N: C252.2 CN5.A3 R849.2
TBTA_TX2_P: C259.2 CN5.A2 R856.2
TBTB_HPD: R208.1 R209.1
TBTB_HPD_C: R208.2 U11.C1
TBTB_RX1_N: C370.2 CN9.A10 R915.2
TBTB_RX1_P: C360.2 CN9.A11 R898.2
TBTB_RX2_N: C414.2 CN9.B10 R350.2
TBTB_RX2_P: C430.2 CN9.B11 R370.2
TBTB_SSRX1_N: R351.1 U16.J11
TBTB_SSRX1_N_C: C370.1 D28.1 R351.2
TBTB_SSRX1_P: R347.1 U16.J12
TBTB_SSRX1_P_C: C360.1 D27.1 R347.2
TBTB_SSRX2_N: R428.1 U16.C11
TBTB_SSRX2_N_C: C414.1 D35.1 R428.2
TBTB_SSRX2_P: R439.1 U16.C12
TBTB_SSRX2_P_C: C430.1 D38.1 R439.2
TBTB_SSTX1_N: R389.1 U16.G11
TBTB_SSTX1_N_C: C388.1 D30.1 R389.2
TBTB_SSTX1_P: R380.1 U16.G12
TBTB_SSTX1_P_C: C383.1 D29.1 R380.2
TBTB_SSTX2_N: R397.1 U16.E11
TBTB_SSTX2_N_C: C396.1 D32.1 R397.2
TBTB_SSTX2_P: R410.1 U16.E12
TBTB_SSTX2_P_C: C403.1 D33.1 R410.2
TBTB_TX1_N: C388.2 CN9.B3 R266.2
TBTB_TX1_P: C383.2 CN9.B2 R253.2
TBTB_TX2_N: C396.2 CN9.A3 R939.2
TBTB_TX2_P: C403.2 CN9.A2 R945.2
TCP0_AN_RBIAS: R840.1 U9.L4
TCP0_AN_RSENSE: R840.2 U9.L5
TCP0_AUX_DN: R143.1 U42.BN38
TCP0_AUX_DN_R: R143.2 U9.M8
TCP0_AUX_DP: R144.1 U42.BN37
TCP0_AUX_DP_R: R144.2 U9.L8
TCP0_FLASH_BUSY#: R243.1 R244.1 U9.A9
TCP0_FLASH_CLK: R165.2 U9.C7 U10.6
TCP0_FLASH_CS#: R232.2 R233.2 U9.B6 U10.1
TCP0_FLASH_DI: R166.2 U9.C6 U10.5
TCP0_FLASH_DO: R234.2 R235.2 U9.B4 U10.2
TCP0_FLASH_HOLD#: R164.2 U10.7
TCP0_FLASH_MSTR_SLV: R222.2 R242.1 R248.1 U9.A5
TCP0_FLASH_SHARE_EN: R224.2 R241.1 U9.A4
TCP0_FLASH_WP#: R236.2 U10.3(W\P\(IO2))
TCP0_GPIO_5: R218.1 U9.B9
TCP0_GPIO_6: R245.1 R246.2 U9.A8
TCP0_GPIO_7: R874.1 R875.1 R1226.1 U9.B8
TCP0_GPIO_12: R221.2 R247.1 U9.A6
TCP0_JTAG_TCK: R223.2 R249.2 TP35.1 U9.B5
TCP0_JTAG_TDI: R225.2 TP36.1 U9.A3
TCP0_JTAG_TDO: R864.2 TP130.1 U9.C5
TCP0_JTAG_TMS: R227.2 TP37.1 U9.C3
TCP0_RESET#: R141.2 R148.1 R149.1 R152.1 R153.1 U9.L11
TCP0_TEST_PWRGD: R226.1 U9.B3
TCP0_THERMDA: TP28.1 U9.M11
TCP0_TX_N0: C228.1 U42.BP38
TCP0_TX_N0_C: C228.2 U9.J2
TCP0_TX_N1: C264.1 U42.BL37
TCP0_TX_N1_C: C264.2 U9.C2
TCP0_TX_P0: C233.1 U42.BP37
TCP0_TX_P0_C: C233.2 U9.J1
TCP0_TX_P1: C274.1 U42.BL38
TCP0_TX_P1_C: C274.2 U9.C1
TCP0_TXRX_N0: C239.1 U42.BL40
TCP0_TXRX_N0_C: C239.2 U9.G2
TCP0_TXRX_N1: C254.1 U42.BK41
TCP0_TXRX_N1_C: C254.2 U9.E2
TCP0_TXRX_P0: C246.1 U42.BL41
TCP0_TXRX_P0_C: C246.2 U9.G1
TCP0_TXRX_P1: C260.1 U42.BK40
TCP0_TXRX_P1_C: C260.2 U9.E1
TCP1_AN_RBIAS: R942.1 U16.L4
TCP1_AN_RSENSE: R942.2 U16.L5
TCP1_FLASH_BUSY#: R261.1 R468.1 U16.A9
TCP01_FLASH_BUSY#: R243.2 R261.2
TCP1_FLASH_CLK: R165.1 U16.C7
TCP1_FLASH_CS#: R232.1 U16.B6
TCP1_FLASH_DI: R166.1 U16.C6
TCP1_FLASH_DO: R235.1 U16.B4
TCP1_FLASH_MSTR_SLV: R448.2 R470.1 R473.1 U16.A5
TCP1_FLASH_SHARE_EN: R450.2 R471.1 U16.A4
TCP1_GPIO_5: R444.1 U16.B9
TCP1_GPIO_6: R469.1 R475.2 U16.A8
TCP1_GPIO_7: R972.1 R973.1 R1227.1 U16.B8
TCP1_GPIO_12: R447.2 R476.1 U16.A6
TCP1_JTAG_TCK: R449.2 R466.2 TP56.1 U16.B5
TCP1_JTAG_TDI: R451.2 TP57.1 U16.A3
TCP1_JTAG_TDO: R963.2 TP149.1 U16.C5
TCP1_JTAG_TMS: R453.2 TP58.1 U16.C3
TCP1_RESET#: R299.2 R313.1 R314.1 R323.1 R324.1 U16.L11
TCP1_TEST_PWRGD: R452.1 U16.B3
TCP1_THERMDA: TP49.1 U16.M11
TCP2_AUX_DN: R303.1 U42.BU37
TCP2_AUX_DN_R: R303.2 U16.M8
TCP2_AUX_DP: R304.1 U42.BU38
TCP2_AUX_DP_R: R304.2 U16.L8
TCP2_TX_N0: C371.1 U42.BT37
TCP2_TX_N0_C: C371.2 U16.J2
TCP2_TX_N1: C410.1 U42.BW38
TCP2_TX_N1_C: C410.2 U16.C2
TCP2_TX_P0: C382.1 U42.BT38
TCP2_TX_P0_C: C382.2 U16.J1
TCP2_TX_P1: C416.1 U42.BW37
TCP2_TX_P1_C: C416.2 U16.C1
TCP2_TXRX_N0: C387.1 U42.BU41
TCP2_TXRX_N0_C: C387.2 U16.G2
TCP2_TXRX_N1: C398.1 U42.BW40
TCP2_TXRX_N1_C: C398.2 U16.E2
TCP2_TXRX_P0: C390.1 U42.BU40
TCP2_TXRX_P0_C: C390.2 U16.G1
TCP2_TXRX_P1: C404.1 U42.BW41
TCP2_TXRX_P1_C: C404.2 U16.E1
TCP_RCOMP: R784.2 U42.BP41
TCP_RETIMER_PERST#: R536.1 R537.2 R550.1 R875.2 R973.2 U28.4
TCRCOMP_DN: R782.1 U42.BR40
TCRCOMP_DP: R782.2 U42.BR41
TEMP_MBAT#: PR326.1 PR332.2 PR340.1 U23.73
TEMP_MBAT#_CONN: PJ19.6 PR332.1
THER_ALERT#: QG18.1(S) RG128.1 UG6.BK5
THERMDN: TPG55.1 UG6.BR8
THERMDP: TPG57.1 UG6.BP8
TP_CLK: CN17.2 R1140.1 U23.89
TP_DAT: CN17.3 R1139.1 U23.90
TP_EN: CN17.8 R406.1
TP_I2C_SCL: Q62.3 R639.1 R958.1 U49.BD21
TP_I2C_SDA: Q62.6 R647.1 R964.1 U49.BC22
TP_INT#_C: CN17.7 Q63.1(S) R636.2 R637.1
TP_LED_ON: Q115.2 R399.1 R1101.1 U1.1
TP_LED_ONOFF_C: CN17.10 Q115.3
TPD_INT#: Q63.3 R343.1 R353.1 R636.1 R991.1 U49.BA39
TPM_MISO: R379.2 R388.2 U18.24
TPM_PIRQ#: R382.1 U49.BD33
TPM_PIRQ#_C: R368.2 R382.2 U18.18
TPM_SCS#: R367.2 R385.2 U18.20
TPM_SPI1_CLK: R386.1 R1015.1
TPM_SPI1_SI: R384.1 R1014.1
TPM_SPI1_SO: R388.1 R1110.1
TPM_VDD: C379.1 C385.1 C457.1 C458.1 C459.1 R349.2 R490.2 U18.8 U18.22
TPS65994A_ADCIN1: R846.1 R847.2 R852.2 U11.G4
TPS65994A_ADCIN2: R851.2 R860.2 R863.1 U11.G3
TRI_EN: Q7.2 R41.1 R586.1
TURBO_KEY: CN1.16 R46.2 U1.10
TX0_HDMI+: CN23.7 R601.2 U32.1 U32.10(NC#4)
TX0_HDMI-: CN23.9 R600.2 U32.2 U32.9
TX1_HDMI+: CN23.4 R603.2 U33.4 U33.7
TX1_HDMI-: CN23.6 R602.2 U33.5 U33.6
TX2_HDMI+: CN23.1 R605.2 U33.1 U33.10(NC#4)
TX2_HDMI-: CN23.3 R604.2 U33.2 U33.9
TXC_HDMI+: CN23.10 R599.2 U32.4 U32.7
TXC_HDMI-: CN23.12 R598.2 U32.5 U32.6
TYPEC1_USB0: C206.2 C207.2 C236.1 C241.2 C242.2 CN5.A4 CN5.A9 CN5.B4 CN5.B9(VBUS_4) D55.1 R187.2 U11.F8 U11.G8 U11.H8
TYPEC2_USB0: C318.2 C319.2 C325.1 C354.2 C355.2 CN9.A4 CN9.A9 CN9.B4 CN9.B9(VBUS_4) D62.1 R196.2 U11.A8 U11.B8 U11.C8
U64009_A0: R331.1 R332.2 U14.1
U64009_A1: R311.1 R312.2 U14.2
U64009_A2: R286.1 R287.2 U14.3
U64009_WP: R307.1 U14.7(WP)
UART2_RXD: TP62.1 U49.AY26
UART2_TXD: TP63.1 U49.AW26
UART_WAKE_N: CN12.20 R979.1
ULT_EDP_HPD: CG333.1 R691.1 RG49.2
ULT_EDP_HPD_R: R691.2 U37.3
USB2_COMP: R903.2 U49.E2
USB2_ID: R904.2 U49.F3
USB2_VBUSSENSE: R902.2 U49.E1
USB3_PCH_RX_WWAN_TX_C_N: CN7.29 R204.1
USB3_PCH_RX_WWAN_TX_C_P: CN7.31 R210.1
USB3_PCH_TX_WWAN_RX_C_N: C288.1 CN7.35
USB3_PCH_TX_WWAN_RX_C_P: C296.1 CN7.37
USB30_RX+_DB1: CN10.28 U49.E11
USB30_RX+_DB2: CN10.19 U49.D12
USB30_RX+_MB1: C415.1 U49.C10
USB30_RX+_MB1_C: L16.4 R544.1
USB30_RX+_MB1_C_R: CN15.6 D48.1 L16.3(OUT-)
USB30_RX+_MB1_RTI: R544.2 U24.21
USB30_RX+_MB1_RTO: C415.2 U24.8
USB30_RX+_WWAN: R210.2 U49.J15
USB30_RX-_DB1: CN10.27 U49.G11
USB30_RX-_DB2: CN10.18 U49.E12
USB30_RX-_MB1: C429.1 U49.D10
USB30_RX-_MB1_C: L16.1 R543.1
USB30_RX-_MB1_C_R: CN15.5 D49.1 L16.2
USB30_RX-_MB1_RTI: R543.2 U24.20
USB30_RX-_MB1_RTO: C429.2 U24.9
USB30_RX-_WWAN: R204.2 U49.L16
USB30_TX+_DB1: CN10.31 U49.F6
USB30_TX+_DB2: CN10.22 U49.M13
USB30_TX+_MB1: C435.1 U49.C3
USB30_TX+_MB1_C: C496.2 L15.4
USB30_TX+_MB1_C_R: CN15.9 D47.1 L15.3(OUT-)
USB30_TX+_MB1_RTI: C435.2 U24.2
USB30_TX+_MB1_RTO: C496.1 U24.27
USB30_TX+_WWAN: C296.2 U49.C17
USB30_TX-_DB1: CN10.30 U49.D5
USB30_TX-_DB2: CN10.21 U49.M15
USB30_TX-_MB1: C428.1 U49.D4
USB30_TX-_MB1_C: C495.2 L15.1
USB30_TX-_MB1_C_R: CN15.8 D46.1 L15.2
USB30_TX-_MB1_RTI: C428.2 U24.3
USB30_TX-_MB1_RTO: C495.1 U24.26
USB30_TX-_WWAN: C288.2 U49.B17
USB_BC_ON: U6.4 U7.4 U23.97 U52.4
USB_CHARGE_ON: R169.2 R171.2 R1115.1 U6.5 U7.5 U23.96 U52.5
USB_CLT1: U6.6 U7.6 U23.79 U52.6
USB_DB1_OC#: R329.1 U7.13 U49.AK11
USB_DB2_OC#: R345.1 U6.13 U49.AP13
USB_OC_MB_TYPEA#: R1053.1 U49.AM13 U52.13
USBP+_CCD: R65.1 U49.L9
USBP+_CCD_R: CN2.28 D6.2 R65.2
USBP+_DB1: U7.3 U49.L8
USBP+_DB1_C: CN10.15 U7.10
USBP+_DB2: U6.3 U49.L5
USBP+_DB2_C: CN10.24 U6.10
USBP+_KB: R1144.1 U49.L3
USBP+_MB: U49.K4 U52.3
USBP+_MB_C: R1138.1 U52.10
USBP+_MB_C_R: CN15.3 D72.2 R1138.2
USBP+_TC1: CN5.A6 CN5.B6 D57.2 U8.2 U8.7 U49.G5
USBP+_TC2: CN9.A6 CN9.B6 D59.2 U15.2 U15.7 U49.R11
USBP+_WLAN: CN12.3 U49.P13
USBP+_WWAN: R841.2 U49.H7
USBP+_WWAN_R: CN7.7 R841.1
USBP-_CCD: R66.1 U49.N11
USBP-_CCD_R: CN2.29 D6.1 R66.2
USBP-_DB1: U7.2 U49.K7
USBP-_DB1_C: CN10.16 U7.11
USBP-_DB2: U6.2 U49.L4
USBP-_DB2_C: CN10.25 U6.11
USBP-_KB: R1143.1 U49.M4
USBP-_MB: U49.K3 U52.2
USBP-_MB_C: R1137.1 U52.11
USBP-_MB_C_R: CN15.2 D72.1 R1137.2
USBP-_TC1: CN5.A7 CN5.B7 D57.1 U8.1 U8.8 U49.H5
USBP-_TC2: CN9.A7 CN9.B7 D59.1 U15.1 U15.8 U49.P9
USBP-_WLAN: CN12.5 U49.P15
USBP-_WWAN: R845.2 U49.G7
USBP-_WWAN_R: CN7.9 R845.1
VCORE_CSN1: PC329.1 PR420.1 PR494.2 PR6041.1 PU20.22
VCORE_CSN2: PC328.1 PR421.1 PR495.1 PR6040.1 PU20.20
VCORE_CSN3: PC326.1 PR422.1 PR496.1 PR6039.1 PU20.18
VCORE_CSN4: PC327.1 PR423.1 PR497.1 PR6038.1 PU20.16
VCORE_CSN5: PC325.1 PR424.1 PR498.1 PR6037.1 PU20.14
VCORE_CSN6: PC323.1 PR425.1 PR499.1 PR6036.1 PU20.12
VCORE_CSP1: PR403.1 PR414.1 PR488.1
VCORE_CSP2: PR404.1 PR415.1 PR489.1
VCORE_CSP3: PR405.1 PR416.1 PR490.1
VCORE_CSP4: PR406.1 PR417.1 PR491.1
VCORE_CSP5: PR407.1 PR418.1 PR492.1
VCORE_CSP6: PR408.1 PR419.1 PR493.1
VCORE_PWM1: PR389.1 PR445.1 PU20.25
VCORE_PWM2: PR385.1 PR447.1 PU20.26
VCORE_PWM3: PR449.1 PU20.27
VCORE_PWM4: PR451.1 PU20.28
VCORE_PWM5: PR455.1 PU20.29
VCORE_PWM6: PR453.1 PU20.30
VGA_XTALIN: CG520.1 UG6.BT5 YG1.1
VGA_XTALOUT: RG148.1 YG1.3
VGA_XTALOUT_R: RG145.2 UG6.BR5
VGPU_CORE_SENSE: PR212.2 RG140.2 UG6.BT48
VGPU_ICMNT: PR103.1 U23.70
VL: PC220.1 PU15.13(VREG5)
VMA_CLK0: UG6.AP48 VRAM6.J10
VMA_CLK0#: UG6.AP47 VRAM6.K10
VMA_CLK1: UG6.AR48 VRAM8.J10
VMA_CLK1#: UG6.AR47 VRAM8.K10
VMA_DQ0: UG6.AC51 VRAM6.P2
VMA_DQ1: UG6.AB48 VRAM6.M2
VMA_DQ2: UG6.AC52 VRAM6.V3
VMA_DQ3: UG6.AC49 VRAM6.N2
VMA_DQ4: UG6.AF52 VRAM6.U4
VMA_DQ5: UG6.AC54 VRAM6.U2
VMA_DQ6: UG6.AE51 VRAM6.U3
VMA_DQ7: UG6.AF51 VRAM6.P3
VMA_DQ8: UG6.W51 VRAM6.A3
VMA_DQ9: UG6.W50 VRAM6.B4
VMA_DQ10: UG6.W53 VRAM6.B2
VMA_DQ11: UG6.Y54 VRAM6.E2
VMA_DQ12: UG6.Y52 VRAM6.G2
VMA_DQ13: UG6.Y51 VRAM6.B3
VMA_DQ14: UG6.Y49 VRAM6.E3
VMA_DQ15: UG6.AB51 VRAM6.F2
VMA_DQ16: UG6.AM54 VRAM6.U12
VMA_DQ17: UG6.AL51 VRAM6.U11
VMA_DQ18: UG6.AM52 VRAM6.U13
VMA_DQ19: UG6.AJ54 VRAM6.P12
VMA_DQ20: UG6.AM47 VRAM6.P13
VMA_DQ21: UG6.AM51 VRAM6.V12
VMA_DQ22: UG6.AP50 VRAM6.N13
VMA_DQ23: UG6.AM49 VRAM6.M13
VMA_DQ24: UG6.AF54 VRAM6.B11
VMA_DQ25: UG6.AF49 VRAM6.B12
VMA_DQ26: UG6.AH51 VRAM6.E12
VMA_DQ27: UG6.AF47 VRAM6.A12
VMA_DQ28: UG6.AJ52 VRAM6.F13
VMA_DQ29: UG6.AJ51 VRAM6.G13
VMA_DQ30: UG6.AH48 VRAM6.B13
VMA_DQ31: UG6.AJ49 VRAM6.E13
VMA_DQ32: UG6.BA49 VRAM8.U4
VMA_DQ33: UG6.BD47 VRAM8.V3
VMA_DQ34: UG6.BD54 VRAM8.P3
VMA_DQ35: UG6.BD52 VRAM8.N2
VMA_DQ36: UG6.BC51 VRAM8.U3
VMA_DQ37: UG6.BD51 VRAM8.M2
VMA_DQ38: UG6.BF51 VRAM8.P2
VMA_DQ39: UG6.BD49 VRAM8.U2
VMA_DQ40: UG6.BG52 VRAM8.A3
VMA_DQ41: UG6.BG51 VRAM8.B4
VMA_DQ42: UG6.BG54 VRAM8.B3
VMA_DQ43: UG6.BF49 VRAM8.F2
VMA_DQ44: UG6.BJ54 VRAM8.B2
VMA_DQ45: UG6.BG50 VRAM8.G2
VMA_DQ46: UG6.BJ52 VRAM8.E2
VMA_DQ47: UG6.BK53 VRAM8.E3
VMA_DQ48: UG6.AP51 VRAM8.V12
VMA_DQ49: UG6.AP53 VRAM8.U13
VMA_DQ50: UG6.AR52 VRAM8.M13
VMA_DQ51: UG6.AR54 VRAM8.P13
VMA_DQ52: UG6.AU51 VRAM8.N13
VMA_DQ53: UG6.AR51 VRAM8.U12
VMA_DQ54: UG6.AV51 VRAM8.P12
VMA_DQ55: UG6.AR49 VRAM8.U11
VMA_DQ56: UG6.AV49 VRAM8.G13
VMA_DQ57: UG6.AV54 VRAM8.F13
VMA_DQ58: UG6.AY51 VRAM8.B13
VMA_DQ59: UG6.AV52 VRAM8.E13
VMA_DQ60: UG6.AY48 VRAM8.B11
VMA_DQ61: UG6.BA54 VRAM8.A12
VMA_DQ62: UG6.BA52 VRAM8.B12
VMA_DQ63: UG6.BA51 VRAM8.E12
VMA_WCK01: UG6.AE48 VRAM6.R4
VMA_WCK01#: UG6.AE47 VRAM6.R5
VMA_WCK23: UG6.AL48 VRAM6.R11
VMA_WCK23#: UG6.AL47 VRAM6.R10
VMA_WCK45: UG6.BA47 VRAM8.R4
VMA_WCK45#: UG6.BA48 VRAM8.R5
VMA_WCK67: UG6.AU48 VRAM8.R11
VMA_WCK67#: UG6.AU47 VRAM8.R10
VMA_WCKB01: UG6.AC48 VRAM6.D4
VMA_WCKB01#: UG6.AC47 VRAM6.D5
VMA_WCKB23: UG6.AJ48 VRAM6.D11
VMA_WCKB23#: UG6.AJ47 VRAM6.D10
VMA_WCKB45: UG6.BC48 VRAM8.D4
VMA_WCKB45#: UG6.BC47 VRAM8.D5
VMA_WCKB67: UG6.AV48 VRAM8.D11
VMA_WCKB67#: UG6.AV47 VRAM8.D10
VMB_CLK0: UG6.K44 VRAM1.J10
VMB_CLK0#: UG6.J44 VRAM1.K10
VMB_CLK1: UG6.J46 VRAM4.J10
VMB_CLK1#: UG6.K46 VRAM4.K10
VMB_DQ0: UG6.D37 VRAM1.P2
VMB_DQ1: UG6.J37 VRAM1.U4
VMB_DQ2: UG6.G37 VRAM1.M2
VMB_DQ3: UG6.F37 VRAM1.N2
VMB_DQ4: UG6.H38 VRAM1.P3
VMB_DQ5: UG6.E38 VRAM1.U2
VMB_DQ6: UG6.F40 VRAM1.U3
VMB_DQ7: UG6.D40 VRAM1.V3
VMB_DQ8: UG6.F34 VRAM1.E2
VMB_DQ9: UG6.J34 VRAM1.A3
VMB_DQ10: UG6.D34 VRAM1.B3
VMB_DQ11: UG6.G34 VRAM1.B2
VMB_DQ12: UG6.E35 VRAM1.G2
VMB_DQ13: UG6.K34 VRAM1.E3
VMB_DQ14: UG6.H35 VRAM1.F2
VMB_DQ15: UG6.K35 VRAM1.B4
VMB_DQ16: UG6.G47 VRAM1.M13
VMB_DQ17: UG6.E44 VRAM1.N13
VMB_DQ18: UG6.F46 VRAM1.U11
VMB_DQ19: UG6.F44 VRAM1.P12
VMB_DQ20: UG6.E46 VRAM1.U12
VMB_DQ21: UG6.C47 VRAM1.V12
VMB_DQ22: UG6.E47 VRAM1.U13
VMB_DQ23: UG6.C49 VRAM1.P13
VMB_DQ24: UG6.G40 VRAM1.B13
VMB_DQ25: UG6.C41 VRAM1.B11
VMB_DQ26: UG6.E41 VRAM1.A12
VMB_DQ27: UG6.F41 VRAM1.B12
VMB_DQ28: UG6.F43 VRAM1.F13
VMB_DQ29: UG6.C44 VRAM1.E12
VMB_DQ30: UG6.H41 VRAM1.G13
VMB_DQ31: UG6.H44 VRAM1.E13
VMB_DQ32: UG6.L51 VRAM4.U4
VMB_DQ33: UG6.L52 VRAM4.U3
VMB_DQ34: UG6.N51 VRAM4.N2
VMB_DQ35: UG6.L49 VRAM4.V3
VMB_DQ36: UG6.L54 VRAM4.P3
VMB_DQ37: UG6.N47 VRAM4.M2
VMB_DQ38: UG6.P51 VRAM4.P2
VMB_DQ39: UG6.P49 VRAM4.U2
VMB_DQ40: UG6.T51 VRAM4.B3
VMB_DQ41: UG6.P52 VRAM4.A3
VMB_DQ42: UG6.P54 VRAM4.B4
VMB_DQ43: UG6.U47 VRAM4.F2
VMB_DQ44: UG6.U51 VRAM4.E2
VMB_DQ45: UG6.U52 VRAM4.B2
VMB_DQ46: UG6.U54 VRAM4.E3
VMB_DQ47: UG6.U49 VRAM4.G2
VMB_DQ48: UG6.D52 VRAM4.U13
VMB_DQ49: UG6.C53 VRAM4.V12
VMB_DQ50: UG6.C54 VRAM4.M13
VMB_DQ51: UG6.C55 VRAM4.P13
VMB_DQ52: UG6.D55 VRAM4.P12
VMB_DQ53: UG6.D54 VRAM4.N13
VMB_DQ54: UG6.F56 VRAM4.U12
VMB_DQ55: UG6.F49 VRAM4.U11
VMB_DQ56: UG6.G53 VRAM4.E13
VMB_DQ57: UG6.H49 VRAM4.F13
VMB_DQ58: UG6.H51 VRAM4.B12
VMB_DQ59: UG6.G51 VRAM4.G13
VMB_DQ60: UG6.H52 VRAM4.B13
VMB_DQ61: UG6.H54 VRAM4.A12
VMB_DQ62: UG6.K48 VRAM4.E12
VMB_DQ63: UG6.K51 VRAM4.B11
VMB_WCK01: UG6.J40 VRAM1.R4
VMB_WCK01#: UG6.K40 VRAM1.R5
VMB_WCK23: UG6.J43 VRAM1.R11
VMB_WCK23#: UG6.K43 VRAM1.R10
VMB_WCK45: UG6.P47 VRAM4.R4
VMB_WCK45#: UG6.P48 VRAM4.R5
VMB_WCK67: UG6.K47 VRAM4.R11
VMB_WCK67#: UG6.J47 VRAM4.R10
VMB_WCKB01: UG6.K38 VRAM1.D4
VMB_WCKB01#: UG6.J38 VRAM1.D5
VMB_WCKB23: UG6.K41 VRAM1.D11
VMB_WCKB23#: UG6.J41 VRAM1.D10
VMB_WCKB45: UG6.T48 VRAM4.D4
VMB_WCKB45#: UG6.T47 VRAM4.D5
VMB_WCKB67: UG6.L47 VRAM4.D11
VMB_WCKB67#: UG6.L48 VRAM4.D10
VMC_CLK0: UG6.K22 VRAM3.J10
VMC_CLK0#: UG6.J22 VRAM3.K10
VMC_CLK1: UG6.K23 VRAM2.J10
VMC_CLK1#: UG6.J23 VRAM2.K10
VMC_DQ0: UG6.F7 VRAM3.U2
VMC_DQ1: UG6.H5 VRAM3.M2
VMC_DQ2: UG6.F8 VRAM3.U3
VMC_DQ3: UG6.G5 VRAM3.N2
VMC_DQ4: UG6.H8 VRAM3.P3
VMC_DQ5: UG6.E8 VRAM3.U4
VMC_DQ6: UG6.C8 VRAM3.V3
VMC_DQ7: UG6.D10 VRAM3.P2
VMC_DQ8: UG6.D2 VRAM3.A3
VMC_DQ9: UG6.E1 VRAM3.B4
VMC_DQ10: UG6.C2 VRAM3.B2
VMC_DQ11: UG6.D3 VRAM3.G2
VMC_DQ12: UG6.C3 VRAM3.E2
VMC_DQ13: UG6.B4 VRAM3.E3
VMC_DQ14: UG6.E4 VRAM3.F2
VMC_DQ15: UG6.D5 VRAM3.B3
VMC_DQ16: UG6.F17 VRAM3.N13
VMC_DQ17: UG6.E14 VRAM3.U12
VMC_DQ18: UG6.C14 VRAM3.V12
VMC_DQ19: UG6.H14 VRAM3.U11
VMC_DQ20: UG6.E17 VRAM3.P13
VMC_DQ21: UG6.F16 VRAM3.U13
VMC_DQ22: UG6.C17 VRAM3.P12
VMC_DQ23: UG6.H17 VRAM3.M13
VMC_DQ24: UG6.F10 VRAM3.B12
VMC_DQ25: UG6.G10 VRAM3.B11
VMC_DQ26: UG6.C11 VRAM3.F13
VMC_DQ27: UG6.E11 VRAM3.E12
VMC_DQ28: UG6.F11 VRAM3.G13
VMC_DQ29: UG6.F13 VRAM3.E13
VMC_DQ30: UG6.F14 VRAM3.B13
VMC_DQ31: UG6.H11 VRAM3.A12
VMC_DQ32: UG6.F26 VRAM2.V3
VMC_DQ33: UG6.E26 VRAM2.U4
VMC_DQ34: UG6.H26 VRAM2.U2
VMC_DQ35: UG6.D28 VRAM2.N2
VMC_DQ36: UG6.C26 VRAM2.U3
VMC_DQ37: UG6.E29 VRAM2.P2
VMC_DQ38: UG6.F28 VRAM2.M2
VMC_DQ39: UG6.G28 VRAM2.P3
VMC_DQ40: UG6.F31 VRAM2.B3
VMC_DQ41: UG6.K29 VRAM2.E2
VMC_DQ42: UG6.H29 VRAM2.E3
VMC_DQ43: UG6.J28 VRAM2.F2
VMC_DQ44: UG6.D31 VRAM2.A3
VMC_DQ45: UG6.G31 VRAM2.B4
VMC_DQ46: UG6.E32 VRAM2.B2
VMC_DQ47: UG6.H31 VRAM2.G2
VMC_DQ48: UG6.F19 VRAM2.U12
VMC_DQ49: UG6.K17 VRAM2.U11
VMC_DQ50: UG6.C20 VRAM2.M13
VMC_DQ51: UG6.J19 VRAM2.V12
VMC_DQ52: UG6.E20 VRAM2.P13
VMC_DQ53: UG6.F20 VRAM2.N13
VMC_DQ54: UG6.K20 VRAM2.U13
VMC_DQ55: UG6.H20 VRAM2.P12
VMC_DQ56: UG6.G22 VRAM2.G13
VMC_DQ57: UG6.F22 VRAM2.E13
VMC_DQ58: UG6.C23 VRAM2.B13
VMC_DQ59: UG6.D22 VRAM2.F13
VMC_DQ60: UG6.E23 VRAM2.A12
VMC_DQ61: UG6.F23 VRAM2.B12
VMC_DQ62: UG6.F25 VRAM2.B11
VMC_DQ63: UG6.H23 VRAM2.E12
VMC_WCK01: UG6.K13 VRAM3.R4
VMC_WCK01#: UG6.J13 VRAM3.R5
VMC_WCK23: UG6.J16 VRAM3.R11
VMC_WCK23#: UG6.K16 VRAM3.R10
VMC_WCK45: UG6.K31 VRAM2.R4
VMC_WCK45#: UG6.J31 VRAM2.R5
VMC_WCK67: UG6.K25 VRAM2.R11
VMC_WCK67#: UG6.J25 VRAM2.R10
VMC_WCKB01: UG6.K11 VRAM3.D4
VMC_WCKB01#: UG6.J11 VRAM3.D5
VMC_WCKB23: UG6.J14 VRAM3.D11
VMC_WCKB23#: UG6.K14 VRAM3.D10
VMC_WCKB45: UG6.K32 VRAM2.D4
VMC_WCKB45#: UG6.J32 VRAM2.D5
VMC_WCKB67: UG6.J26 VRAM2.D11
VMC_WCKB67#: UG6.K26 VRAM2.D10
VMD_CLK0: UG6.AC10 VRAM7.J10
VMD_CLK0#: UG6.AC9 VRAM7.K10
VMD_CLK1: UG6.AB10 VRAM5.J10
VMD_CLK1#: UG6.AB9 VRAM5.K10
VMD_DQ0: UG6.AR4 VRAM7.P2
VMD_DQ1: UG6.AP8 VRAM7.M2
VMD_DQ2: UG6.AP6 VRAM7.N2
VMD_DQ3: UG6.AR6 VRAM7.P3
VMD_DQ4: UG6.AM6 VRAM7.U3
VMD_DQ5: UG6.AP3 VRAM7.U2
VMD_DQ6: UG6.AP5 VRAM7.V3
VMD_DQ7: UG6.AM9 VRAM7.U4
VMD_DQ8: UG6.AU5 VRAM7.E2
VMD_DQ9: UG6.AV6 VRAM7.B2
VMD_DQ10: UG6.AV9 VRAM7.A3
VMD_DQ11: UG6.AU3 VRAM7.G2
VMD_DQ12: UG6.AU6 VRAM7.F2
VMD_DQ13: UG6.AU8 VRAM7.E3
VMD_DQ14: UG6.AU10 VRAM7.B4
VMD_DQ15: UG6.AR7 VRAM7.B3
VMD_DQ16: UG6.AF6 VRAM7.U11
VMD_DQ17: UG6.AH5 VRAM7.N13
VMD_DQ18: UG6.AH3 VRAM7.P12
VMD_DQ19: UG6.AF9 VRAM7.M13
VMD_DQ20: UG6.AE6 VRAM7.U12
VMD_DQ21: UG6.AE8 VRAM7.U13
VMD_DQ22: UG6.AE5 VRAM7.V12
VMD_DQ23: UG6.AE10 VRAM7.P13
VMD_DQ24: UG6.AL6 VRAM7.B12
VMD_DQ25: UG6.AL3 VRAM7.A12
VMD_DQ26: UG6.AL5 VRAM7.B11
VMD_DQ27: UG6.AL8 VRAM7.B13
VMD_DQ28: UG6.AJ6 VRAM7.E12
VMD_DQ29: UG6.AL10 VRAM7.G13
VMD_DQ30: UG6.AH6 VRAM7.F13
VMD_DQ31: UG6.AH8 VRAM7.E13
VMD_DQ32: UG6.T5 VRAM5.U2
VMD_DQ33: UG6.T6 VRAM5.V3
VMD_DQ34: UG6.P6 VRAM5.P3
VMD_DQ35: UG6.T8 VRAM5.U3
VMD_DQ36: UG6.T3 VRAM5.U4
VMD_DQ37: UG6.N5 VRAM5.M2
VMD_DQ38: UG6.N3 VRAM5.N2
VMD_DQ39: UG6.N6 VRAM5.P2
VMD_DQ40: UG6.L6 VRAM5.B3
VMD_DQ41: UG6.N8 VRAM5.F2
VMD_DQ42: UG6.K6 VRAM5.B4
VMD_DQ43: UG6.L9 VRAM5.E3
VMD_DQ44: UG6.K3 VRAM5.B2
VMD_DQ45: UG6.K5 VRAM5.A3
VMD_DQ46: UG6.J2 VRAM5.E2
VMD_DQ47: UG6.K8 VRAM5.G2
VMD_DQ48: UG6.AC7 VRAM5.V12
VMD_DQ49: UG6.AE3 VRAM5.U11
VMD_DQ50: UG6.AC6 VRAM5.U12
VMD_DQ51: UG6.AC4 VRAM5.U13
VMD_DQ52: UG6.AB3 VRAM5.P13
VMD_DQ53: UG6.AB5 VRAM5.M13
VMD_DQ54: UG6.AB6 VRAM5.N13
VMD_DQ55: UG6.AB8 VRAM5.P12
VMD_DQ56: UG6.W6 VRAM5.A12
VMD_DQ57: UG6.W8 VRAM5.G13
VMD_DQ58: UG6.W5 VRAM5.B13
VMD_DQ59: UG6.Y6 VRAM5.F13
VMD_DQ60: UG6.W3 VRAM5.E13
VMD_DQ61: UG6.U9 VRAM5.B11
VMD_DQ62: UG6.U6 VRAM5.B12
VMD_DQ63: UG6.T10 VRAM5.E12
VMD_WCK01: UG6.AP9 VRAM7.R4
VMD_WCK01#: UG6.AP10 VRAM7.R5
VMD_WCK23: UG6.AH10 VRAM7.R11
VMD_WCK23#: UG6.AH9 VRAM7.R10
VMD_WCK45: UG6.P10 VRAM5.R4
VMD_WCK45#: UG6.P9 VRAM5.R5
VMD_WCK67: UG6.Y10 VRAM5.R11
VMD_WCK67#: UG6.Y9 VRAM5.R10
VMD_WCKB01: UG6.AR9 VRAM7.D4
VMD_WCKB01#: UG6.AR10 VRAM7.D5
VMD_WCKB23: UG6.AJ10 VRAM7.D11
VMD_WCKB23#: UG6.AJ9 VRAM7.D10
VMD_WCKB45: UG6.N10 VRAM5.D4
VMD_WCKB45#: UG6.N9 VRAM5.D5
VMD_WCKB67: UG6.W9 VRAM5.D11
VMD_WCKB67#: UG6.W10 VRAM5.D10
VR_SVID_ALERT#: PR358.2 PR372.1 R790.2 R791.1
VR_SVID_CLK: PR359.2 PR370.1 R788.2 R789.2
VR_SVID_CLK_R: R788.1 U42.E32
VR_SVID_DATA: PR357.2 PR371.1 R792.2
VRALERT#: Q48.3 R510.1 U49.AY35
VRON: PR362.1 PU3.1 R534.1 U23.69
VSTBY_FSPI: C376.2 R319.2 R338.2 U23.106
WIGIG_LED: CN12.6 TP153.1
WLAN_CLKREQ#: CN12.53 Q43.3 R392.2
WLAN_RST#: CN12.52 R951.1
WLAN_WAKE_R#: CN12.55 Q38.1(S) R365.2
WLANPWR#: R403.1 U23.83
WRST#: C448.1 D34.2 Q53.6 R458.1 U23.14(WRST#)
WWAN_ANTCTL0: CN7.59 TP143.1
WWAN_ANTCTL1: CN7.61 TP144.1
WWAN_ANTCTL2: CN7.63 TP145.1
WWAN_ANTCTL3: CN7.65 TP48.1
WWAN_CLK_C_N: CN7.53 R890.1
WWAN_CLK_C_P: CN7.55 R900.1
WWAN_CONFIG0: CN7.21 R857.1
WWAN_CONFIG1: CN7.69 R940.1
WWAN_CONFIG2: CN7.75 R944.1
WWAN_CONFIG3: CN7.1 R838.1
WWAN_DPR_SAR_ODL: CN7.25 D45.2 D70.2 Q107.1(S) R559.2 R1231.1
WWAN_PCIE_WAKE_ODL_R: CN7.54 Q27.1(S) R262.1
WWAN_PST_L_EC: D15.1(CATHODE) R585.2 R1189.2 U23.36
WWAN_RESET#: Q26.3 R202.1 R362.2
WWAN_RESET#_C: C308.2 CN7.67 Q26.1(S) R239.1
WWAN_SAR#: Q107.3 R488.2 R880.1
WWAN_SIM1_CLK: CN7.32 D68.1 R1025.2
WWAN_SIM1_CLK_C: J1.3 LG7.2
WWAN_SIM1_DATA: CN7.34 D69.1 R1026.2
WWAN_SIM1_DATA_C: J1.7 LG8.2
WWAN_SIM1_DET_OD: CN7.66 D61.1 QG16.1(S) R251.1 R258.2 R259.1
WWAN_SIM1_PWR: C789.1 C793.1 CN7.36 J1.1 R1018.1
WWAN_SIM1_RST: CN7.30 D67.1 R1022.2
WWAN_SIM1_RST_C: J1.2 LG6.2
WWAN_SIM2_DETECT_M: CN7.40 R896.2
WWAN_WAKE#: CN7.23 Q102.1(S) Q109.1(S) R861.1
WWAN_WAKE#_EC: R488.1 R826.1 U23.18
WWAN_WAKE#_PCH: R824.1 U49.AU29
WWAN_WLAN_COEX1: CN7.64 R928.2
WWAN_WLAN_COEX2: CN7.62 R925.2
WWAN_WLAN_COEX3: CN7.60 R920.2
XCLK_RBIAS: R891.2 U49.P3
XDP_BPM0: R101.1 TP12.1 U42.H37
XDP_BPM1: R98.1 TP10.1 U42.G38
XDP_BPM2: R772.1 TP102.1 U42.H40
XDP_BPM3: R774.1 TP104.1 U42.H39
XDP_PRDY#: R100.1 TP11.1 U42.G36 U49.AF3
XDP_PREQ#: R767.1 TP40.1 U42.H34 U49.AF4
XDP_TRST#: R775.1 TP34.1 U42.E40 U49.AE4
XTAL38P4_IN: L3.2 R281.1 U49.AC8
XTAL38P4_IN_L: C310.2 L3.1 R269.1 R281.2 Y2.1
XTAL38P4_OUT: L3.3 R282.1 U49.AC6
XTAL38P4_OUT_L: C312.2 L3.4 R257.1 R269.2 R282.2
XTAL_OUT: R257.2 Y2.3
XTAL_TCP0_25MHZ_IN: C192.2 U9.L9 Y1.1
XTAL_TCP0_25MHZ_OUT: C191.2 U9.M9 Y1.3
XTAL_TCP1_25MHZ_IN: C336.2 U16.L9 Y3.1
XTAL_TCP1_25MHZ_OUT: C335.2 U16.M9 Y3.3
XTALOUT_RC: CG519.1 RG145.1 RG148.2
XTALOUTBUFF: RG141.1 UG6.BP5(XTAL_OUTBUFF)
XTALSSIN: RG146.1 UG6.BK8
N84238: PC483.1 PC485.1 PJ6.1 PL3.2 PR616.2
N87154: PR280.1 PR629.2
N17127874: RG68.1 RG69.2 UG1.4
N17127875: CG396.2 RG75.1 UG1.5(VCC)
N19106637: PC342.1 PR439.1 PU22.3
N19106671: PR458.2 PU21.31
N19106721: PL7.1 PR105.1 PR488.2 PU21.16(VSW) PU21.24
N19106779: PR448.2 PU22.2
N19106815: PC343.1 PR440.1 PU23.3
N19106957: PR430.1 PU21.5
N19106959: PC335.2 PU21.7
N19106961: PC335.1 PR430.2
N19107009: PL8.1 PR107.1 PR489.2 PU22.16(VSW) PU22.24
N19107047: PC336.2 PU22.7
N19107049: PC336.1 PR431.2
N19107109: PC56.1 PR107.2
N19107173: PR431.1 PU22.5
N19107223: PC345.1 PR443.1 PU25.3
N19107283: PR456.2 PU25.2
N19107293: PL11.1 PR109.1 PR492.2 PU25.16(VSW) PU25.24
N19107323: PC340.2 PU25.7
N19107325: PC340.1 PR436.2
N19107371: PC58.1 PR109.2
N19107403: PR436.1 PU25.5
N19107405: PR462.2 PU25.31
N19107409: PR455.2 PU25.1
N19107568: PR459.2 PU22.31
N19107627: PR450.2 PU23.2
N19107637: PL9.1 PR106.1 PR490.2 PU23.16(VSW) PU23.24
N19107667: PC338.2 PU23.7
N19107669: PC338.1 PR433.2
N19107785: PC57.1 PR106.2
N19107833: PR433.1 PU23.5
N19107835: PR460.2 PU23.31
N19107839: PR449.2 PU23.1
N19108009: PC341.1 PR438.1 PU21.3
N19108304: PC346.1 PR442.1 PU26.3
N19108364: PR445.2 PU21.1
N19108398: PR454.2 PU26.2
N19108408: PL12.1 PR110.1 PR493.2 PU26.16(VSW) PU26.24
N19108454: PC337.2 PU26.7
N19108456: PC337.1 PR432.2
N19108516: PC59.1 PR110.2
N19108570: PR432.1 PU26.5
N19108572: PR463.2 PU26.31
N19108576: PR453.2 PU26.1
N19108632: PR447.2 PU22.1
N19109090: PR446.2 PU21.2
N19109132: PC55.1 PR105.2
N19109186: PC344.1 PR441.1 PU24.3
N19109234: PR452.2 PU24.2
N19109248: PL10.1 PR108.1 PR491.2 PU24.16(VSW) PU24.24
N19109278: PC339.2 PU24.7
N19109280: PC339.1 PR434.2
N19109324: PC60.1 PR108.2
N19109356: PR434.1 PU24.5
N19109358: PR461.2 PU24.31
N19109362: PR451.2 PU24.1
N19174209: PQ39.3 PR9.2
N19174211: PQ3.3 PQ39.2 PR31.1 PR33.2
N19201693: PC287.2 PC288.1 PC295.1 PR2.2 PR12.2 PR364.2
