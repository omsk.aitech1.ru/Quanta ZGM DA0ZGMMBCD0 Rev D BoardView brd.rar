# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EC_PECI_PCH: length 5.6
  BOTTOM w0.102: R893.1 215.49,83.45 215.25,83.2 R911.2 215.25,82.75 214.96,82.46 214.96,82.06 215.1,81.92 215.1,79 215.01,78.91 215.01,78.62 214.8,78.41 U49.AH3
EC_PECI_R: length 2.3
  TOP w0.14: U23.117 173.91,73.84 173.47,74.28 173.47,74.95 R364.2
EC_PWROK: length 56.7
  TOP w0.14: v1(206.61,47.28) 207.14,47.82 207.62,47.82 207.8,47.64 R622.2 207.8,47.03 208.03,46.8 208.44,46.8 208.9,46.34 208.9,45.8 R626.2 R623.2 R624.2 210.37,46.09 210.61,46.33 U30.1 ; v1(173.72,62) 173.17,61.45 173.17,60.55 172.52,59.9 172.52,59.3 171.97,58.75 169.83,58.75 169.51,58.43 U23.33
  IN2 w0.089: v1(173.72,62) 173.95,61.77 181.13,61.77 181.77,61.13 182.16,61.13 182.8,60.49 182.8,59.45 185.4,56.85 186.06,56.85 187.41,55.49 189.59,55.49 190.03,55.06 190.03,53.35 192.7,50.68 192.7,50.22 195.4,47.52 200.99,47.52 201.6,46.91 204.36,46.91 205.16,47.71 206.17,47.71 v1(206.61,47.28)
EC_PWROK_R: length 17.1
  TOP w0.14: R632.1 208.12,44 207.86,44.26 v1(207.86,44.5) 207.78,44.59 207.78,45.02 C538.1 208.33,45.03 208.41,44.95 R626.1
  BOTTOM w0.102: U49.AB47 211.71,56.18 211.91,55.97 211.91,54.82 211.33,54.23 211.33,53.68 210.83,53.18 210.58,53.18 210.23,52.84 210.23,52.04 209.74,51.55 R1085.1
  BOTTOM w0.14: v1(207.86,44.5) 207.97,44.61 207.97,47.43 209.3,48.76 R1133.2 209.58,49.18 209.89,49.49 TP173.1 209.89,49.75 209.55,50.09 209.55,50.95 209.74,51.13 R1085.1
ECAGND: length 11.4
  TOP w0.14: 184.84,62.9 U23.75
  TOP w0.305: v1(185.69,63.72) 185.69,63.74 L13.2 186.18,64.16 186.93,63.41 C465.1 186.92,63.18 C464.2 185.73,63.18 185.45,62.9 184.84,62.9 ; C504.2 185.83,58.84 v1(185.63,59.04)
  BOTTOM w0.305: v1(185.63,59.04) 186.02,59.43 186.02,61.02 185.78,61.26 185.78,62.91 185.69,63 v1(185.69,63.72)
EDP_AUX#_C: length 31.2
  TOP w0.14: v1(279.22,202.84) 279.19,202.82 278.55,202.82 R52.1 278.02,202.73 277.46,202.73 R53.2 277.07,202.67 276.87,202.67 275.67,201.47 272.07,201.47 271.44,200.85 CN2.6
  IN3 w0.089: v1(279.22,202.84) 279.05,203.01 278.61,203.01 277.98,203.64 277.98,206.73 278.4,207.15 278.4,208.08 277.74,208.74 275.53,208.74 275.39,208.88 273.47,208.88 273.41,208.82 270.32,208.82 270.13,208.62 270.13,208.48 270.25,208.36 v1(270.39,208.36)
  BOTTOM w0.14: C594.2 266.35,207.51 266.56,207.31 266.56,207 266.95,206.6 268.92,206.6 270.13,207.81 270.13,208.1 v1(270.39,208.36)
EDP_AUX#_C_R: length 5.3
  BOTTOM w0.14: C594.1 266.36,208.04 265.84,208.55 265.34,208.55 264.94,208.55 264.42,209.07 U37.9
EDP_AUX_C: length 31.2
  TOP w0.14: v1(279.17,203.72) 278.69,203.24 278.46,203.24 R50.1 277.94,203.15 277.53,203.15 R51.2 276.9,203.13 276.73,203.13 275.49,201.89 271.89,201.89 271.27,201.27 270.67,201.27 270.59,201.35 CN2.5
  IN3 w0.089: v1(279.17,203.72) 279.23,203.67 279.23,203.42 279.1,203.29 278.73,203.29 278.26,203.76 278.26,206.62 278.68,207.04 278.68,208.2 277.86,209.02 275.64,209.02 275.51,209.16 273.36,209.16 273.29,209.1 270.21,209.1 269.85,208.74 269.85,208.45 269.76,208.36 v1(269.39,208.36)
  BOTTOM w0.14: v1(269.39,208.36) 269.57,208.36 269.71,208.22 269.71,207.98 268.75,207.02 267.12,207.02 266.97,207.17 266.97,207.37 C595.1
EDP_AUX_C_R: length 5.3
  BOTTOM w0.14: U37.7 265.18,209.7 264.97,209.49 264.97,209.11 265.11,208.97 266.02,208.97 267.03,207.96 C595.2
EDP_HPD_PANEL: length 54.2
  TOP w0.14: R42.2 278.44,207.82 278.39,207.87 Q6.2 278.16,208.67 R37.1 276.79,208.67 276.46,208.99 272.19,208.99 270.63,210.55 270.63,211.28 269.24,212.67 267,212.67 v1(265.88,211.55)
  IN2 w0.089: v1(265.88,211.55) 265.88,210.99 265.54,210.65 265.54,209.91 266.21,209.24 266.21,207.32 270.44,203.09 270.44,202.71 273.82,199.33 273.82,198.24 275.64,196.41 278.12,196.41 278.72,195.82 278.72,194.79 277.81,193.88 276.35,193.88 275.72,193.25 274.99,193.25 274.5,192.76 273.68,192.76 273.12,192.19 273.12,189.16 275.34,186.94 v1(275.34,186.92)
  BOTTOM w0.14: U37.4 265.93,211.61 v1(265.88,211.55)
EDP_HPD_R: length 12.7
  TOP w0.14: CN2.30 271.69,188.85 272.94,187.6 272.94,186.46 273.36,186.04 276.13,186.04 276.99,186.91 v1(277.12,186.91) 277.24,186.91 277.66,186.49 278.34,186.49 278.67,186.82 279.73,186.82 279.87,186.96 R71.2
EDP_I2C_CLK: length 106.1
  TOP w0.14: R55.1 278.31,195.16 v1(278.17,195.02) ; QG10.3 255.66,115.89 254.94,116.61 v1(254.88,116.61)
  IN1 w0.086: v1(282.81,174.32) 282.78,174.3 282.78,174.27 282.78,174.27 282.78,157.02 279.99,154.23 279.99,139.11 278.96,138.08 277.74,138.08 276.78,137.12 276.78,134.76 275.98,133.96 275.98,127.65 276.39,127.25 276.39,125.84 274.7,124.15 272.79,124.15 269.46,120.82 268.14,120.82 266.21,118.89 265.25,118.89 263.67,117.31 259.43,117.31 259.07,117.67 257.06,117.67 256.75,117.36 255.22,117.36 254.88,117.03 v1(254.88,116.61)
  IN3 w0.089: v1(282.81,174.32) 282.81,174.35 283.36,174.89 283.36,180.23 283.74,180.62 283.74,186.78 281.4,189.12 281.4,194.97 280.73,195.65 279.18,195.65 278.56,195.02 v1(278.17,195.02)
EDP_I2C_CLK_C: length 15
  TOP w0.14: R56.2 280.6,195.06 280.19,195.06 279.99,194.86 v1(279.99,194.53) 279.64,194.53 279.12,195.05 R55.2 279.12,195.83 278.77,196.18 v1(277.12,196.18) 277.12,195.34 276.02,194.25 273.84,194.25 272.24,192.65 270.91,192.65 270.71,192.85 CN2.22
  BOTTOM w0.14: R727.2 v1(279.99,194.53)
EDP_I2C_DATA: length 112.9
  TOP w0.14: QG10.6 257.31,114.54 v1(257.31,114.57) ; v1(278.23,193.75) 278.25,193.76 278.53,193.76 278.67,193.91 R57.1
  IN1 w0.086: v1(282.82,175.32) 282.01,174.52 282.01,156.91 279.52,154.42 279.52,139.31 278.76,138.55 277.54,138.55 276.31,137.32 276.31,135.03 275.47,134.19 275.47,127.5 275.92,127.06 275.92,126.03 274.51,124.62 272.6,124.62 269.26,121.28 267.94,121.28 266.02,119.36 265.06,119.36 263.48,117.78 259.63,117.78 259.27,118.14 256.87,118.14 256.56,117.83 254.76,117.83 253,116.06 253,114.6 253.61,113.98 256.72,113.98 v1(257.31,114.57)
  IN3 w0.089: v1(278.23,193.75) 278.23,193.8 279.61,195.17 280.54,195.17 280.82,194.9 280.82,189.04 283.27,186.59 283.27,181.21 282.53,180.46 282.53,176.63 282.82,176.34 v1(282.82,175.32)
EDP_I2C_DATA_C: length 12.4
  TOP w0.14: R58.2 280.54,193.98 279.28,193.98 R57.2 279.12,194.42 278.98,194.56 v1(277.72,194.56) ; CN2.23 270.56,192.35 270.79,192.11 272.44,192.11 273.54,193.21 274.14,193.21 v1(274.2,193.16)
  BOTTOM w0.14: v1(274.2,193.16) 274.39,193.35 274.67,193.35 v1(274.96,193.64) 275.42,194.1 277.03,194.1 277.49,194.56 v1(277.72,194.56)
EDP_RCOMP: length 5.1
  BOTTOM w0.254: R785.1 148.68,156.43 148.94,156.17 148.94,152.36 U42.BC38
EDP_TXN0_C: length 20.4
  TOP w0.102: v1(272.17,198.84) 272.17,199.04 271.98,199.23 271.64,199.23 271.51,199.36 270.96,199.36 270.95,199.35 CN2.9
  IN3 w0.089: v1(272.17,198.84) 272.52,199.2 272.88,199.2 273.13,199.45 273.13,199.92 273.71,200.5 273.71,201.1 273.25,201.56 272.71,201.56 272.06,200.92 271.94,200.92 271.56,201.29 271.56,201.42 271.92,201.77 271.92,202.31 271.04,203.18 270.25,203.18 270.13,203.29 270.13,203.66 270.25,203.78 270.87,203.78 271.12,204.03 271.12,204.68 270.87,204.93 270.32,204.93 270.18,205.07 270.18,205.39 270.32,205.53 271.45,205.53 271.78,205.87 271.78,207.95 v1(271.97,208.14)
  BOTTOM w0.14: C585.2 271.77,208.71 271.77,208.34 v1(271.97,208.14)
EDP_TXN1_C: length 20.4
  TOP w0.102: CN2.12 270.95,197.85 270.98,197.88 271.45,197.88 v1(271.78,197.55)
  IN3 w0.089: v1(273.49,208.17) 273.23,207.91 273.23,207.3 273.71,206.81 273.71,206.19 273.46,205.94 272.99,205.94 272.9,205.85 272.9,205.43 272.99,205.35 273.58,205.35 273.83,205.09 273.83,204.42 273.6,204.19 273.29,204.19 273.21,204.1 273.21,203.68 273.29,203.59 273.49,203.59 273.74,203.34 273.74,202.31 273.83,202.22 274.35,202.22 274.88,201.7 274.88,201.02 274.59,200.73 274.59,199.96 274.33,199.71 274.16,199.71 274.01,199.55 274.01,199.26 274.16,199.11 274.33,199.11 274.59,198.86 274.59,197.89 274.33,197.64 273.81,197.64 273.44,198.01 272.72,198.01 272.39,197.68 271.91,197.68 v1(271.78,197.55)
  BOTTOM w0.14: v1(273.49,208.17) 273.26,208.4 273.26,208.72 C583.2
EDP_TXN2_C: length 20.2
  TOP w0.102: CN2.15 270.66,196.35 270.74,196.43 272.6,196.43 272.83,196.66 273.13,196.66 v1(273.41,196.38)
  IN3 w0.089: v1(276.15,208.11) 275.9,207.86 275.9,207.74 275.9,207.71 275.9,207.27 276.51,206.65 276.51,205.59 275.99,205.07 274.92,205.07 274.7,204.85 274.7,203.11 275.75,202.06 275.75,200.65 275.46,200.37 275.46,197.17 274.85,196.55 273.58,196.55 v1(273.41,196.38)
  BOTTOM w0.14: v1(276.15,208.11) 275.95,208.31 275.95,208.71 C587.2
EDP_TXN3_C: length 20.3
  TOP w0.102: v1(271.96,194.58) 271.67,194.87 270.97,194.87 270.95,194.85 CN2.18
  IN3 w0.089: v1(271.96,194.58) 272.1,194.72 274.46,194.72 275.24,195.49 275.24,195.7 276.63,197.09 276.63,202.27 277.39,203.02 277.39,207.9 v1(277.63,208.14)
  BOTTOM w0.14: v1(277.63,208.14) 277.43,208.34 277.43,208.71 C589.2
EDP_TXP0_C: length 20.3
  TOP w0.102: CN2.8 270.65,199.85 270.94,199.56 271.59,199.56 271.72,199.44 272.11,199.44 272.21,199.54 v1(272.21,199.75)
  IN3 w0.089: v1(272.21,199.75) 272.16,199.7 272.16,199.57 272.26,199.48 272.76,199.48 272.85,199.56 272.85,200.03 273.43,200.61 273.43,200.99 273.13,201.28 272.82,201.28 272.18,200.64 271.82,200.64 271.28,201.17 271.28,201.53 271.64,201.89 271.64,202.19 270.93,202.9 270.13,202.9 269.85,203.18 269.85,203.78 270.13,204.06 270.75,204.06 270.84,204.15 270.84,204.56 270.75,204.65 270.21,204.65 269.9,204.96 269.9,205.51 270.21,205.81 271.33,205.81 271.5,205.98 271.5,208.05 271.41,208.14 v1(271.18,208.14)
  BOTTOM w0.14: C584.2 271.35,208.73 271.35,208.31 v1(271.18,208.14)
EDP_TXP1_C: length 20.4
  TOP w0.102: CN2.11 270.76,198.35 271.03,198.08 271.55,198.08 v1(271.76,198.29)
  IN3 w0.089: v1(271.76,198.29) 271.7,198.23 271.7,198.04 271.79,197.96 272.27,197.96 272.6,198.29 273.55,198.29 273.92,197.92 274.22,197.92 274.31,198.01 274.31,198.74 274.22,198.83 274.04,198.83 273.73,199.15 273.73,199.67 274.04,199.99 274.22,199.99 274.31,200.08 274.31,200.84 274.6,201.13 274.6,201.59 274.24,201.94 273.71,201.94 273.46,202.2 273.46,203.22 273.37,203.31 273.18,203.31 272.93,203.57 272.93,204.22 273.18,204.47 273.48,204.47 273.55,204.54 273.55,204.98 273.46,205.07 272.87,205.07 272.62,205.32 272.62,205.97 272.87,206.22 273.35,206.22 273.43,206.31 273.43,206.69 272.95,207.18 272.95,208.04 272.83,208.16 v1(272.66,208.16)
  BOTTOM w0.14: v1(272.66,208.16) 272.84,208.34 272.84,208.73 C582.2
EDP_TXP2_C: length 20.2
  TOP w0.102: v1(273.43,197.16) 273.43,197.03 273.26,196.86 272.75,196.86 272.52,196.63 270.95,196.63 270.73,196.85 CN2.14
  IN3 w0.089: v1(275.31,208.11) 275.62,207.81 275.62,207.71 275.62,207.15 276.23,206.54 276.23,205.71 275.87,205.35 274.81,205.35 274.42,204.97 274.42,203 275.47,201.95 275.47,200.77 275.18,200.48 275.18,197.28 274.73,196.83 273.47,196.83 273.38,196.92 273.38,197.12 v1(273.43,197.16)
  BOTTOM w0.14: C586.2 275.53,208.68 275.53,208.34 v1(275.31,208.11)
EDP_TXP3_C: length 20.3
  TOP w0.102: v1(271.92,195.29) 271.69,195.07 270.99,195.07 270.71,195.35 CN2.17
  IN3 w0.089: v1(271.92,195.29) 271.87,195.24 271.87,195.09 271.95,195 274.35,195 274.96,195.61 274.96,195.82 276.35,197.21 276.35,202.38 277.11,203.14 277.11,208.05 277.02,208.14 v1(276.85,208.14)
  BOTTOM w0.14: v1(276.85,208.14) 277.01,208.3 277.01,208.68 C588.2
EN: length 3.9
  BOTTOM w0.14: R1145.1 277.73,47.74 277.52,47.94 276.51,47.94 276.26,47.69 C839.2 275.95,47.46 275.56,47.07 U55.7
EN_U3: length 2.8
  TOP w0.178: U24.11 16.18,65.7 v1(15.75,66.13) 15.42,66.46 15.04,66.46 14.86,66.64 R462.1
ESPI_0: length 64.4
  TOP w0.14: U23.10 168.6,67.7 170.55,65.75 170.55,63.88 v1(170.8,63.63)
  IN4 w0.086: v1(170.8,63.63) 170.71,63.54 170.71,62.36 171.51,61.55 172.89,61.55 173.26,61.18 180.6,61.18 181.85,59.92 182.91,59.92 184.13,58.71 184.13,57.74 185.37,56.5 186.3,56.5 186.87,55.93 186.87,54.16 189,52.02 191.05,52.02 192.21,50.86 200.38,50.86 200.47,50.77 202.45,50.77 202.69,51.01 206.87,51.01 207.16,50.71 211.77,50.71 212.22,50.27 212.22,49.28 212.34,49.16 212.34,48.18 212.58,47.94 213.32,47.94 v1(213.74,48.36)
  BOTTOM w0.14: R1161.2 216,45.61 213.74,47.87 v1(213.74,48.36)
ESPI_0_R: length 14.8
  BOTTOM w0.102: 219.95,52.87 219.67,53.15 219.67,53.21 217.75,55.12 217.75,55.81 217.6,55.97 217.6,56.75 U49.AN46
  BOTTOM w0.14: v1(216.67,46.32) 216.93,46.06 R1161.1 217.55,46.45 217.92,46.82 219.17,46.82 219.56,47.2 219.56,47.97 219.92,48.34 219.92,50.05 220.1,50.23 220.1,51.66 220.27,51.83 220.27,52.55 219.95,52.87
ESPI_1: length 66.3
  TOP w0.14: U23.9 168.61,68.1 170.83,65.88 170.83,64.26 171.27,63.82 171.27,63.44 171.11,63.28 v1(171.11,63)
  IN4 w0.086: v1(171.11,63) 171.53,63.43 171.95,63.43 172.14,63.24 174.5,63.24 175.76,61.97 179.05,61.97 179.38,62.31 182.94,62.31 185.2,60.05 185.2,58.7 188.59,55.31 188.59,54.52 190.34,52.78 192.39,52.78 193.74,51.43 199.95,51.43 200.51,51.98 202.57,51.98 202.91,52.33 207.5,52.33 208.54,51.28 212.67,51.28 213.34,51.95 220.24,51.95 221.09,51.09 v1(221.57,51.09)
  BOTTOM w0.14: v1(221.57,51.09) 221.57,51.48 R1075.2
ESPI_1_R: length 9.3
  BOTTOM w0.102: U49.AN45 217.37,57.98 217.74,58.35 218.07,58.35 218.26,58.16 218.26,56.17 218.36,56.06 218.36,55.37 220.28,53.46 220.55,53.46
  BOTTOM w0.14: R1075.1 221.8,52.21 220.55,53.46
ESPI_2: length 65.1
  TOP w0.14: U23.8 168.61,68.5 171.11,66 171.11,64.37 171.55,63.94 171.55,63.24 v1(171.75,63.03)
  IN4 w0.086: v1(220.63,50.99) 219.86,51.76 213.42,51.76 212.75,51.09 208.46,51.09 207.42,52.14 203.29,52.14 202.3,51.14 200.63,51.14 200.53,51.24 192.37,51.24 191.21,52.4 190.18,52.4 188.22,54.37 188.22,55.15 186.5,56.87 185.53,56.87 184.5,57.9 184.5,59.69 182.87,61.32 180.99,61.32 180.75,61.56 173.42,61.56 171.94,63.03 v1(171.75,63.03)
  BOTTOM w0.14: v1(220.63,50.99) 220.8,51.16 R1074.2
ESPI_2_R: length 5.5
  BOTTOM w0.102: U49.AP47 217.83,56.02 217.96,55.89 217.96,55.2 220.16,53 220.22,53 220.34,52.87
  BOTTOM w0.14: 220.34,52.87 220.8,52.41 R1074.1
ESPI_3: length 66.6
  TOP w0.14: U23.7 168.6,68.9 171.39,66.11 171.39,64.49 171.83,64.06 171.83,63.61 172.22,63.22 172.22,62.84 171.87,62.49 v1(171.87,61.95)
  IN4 w0.086: v1(213.09,48.38) 213.09,48.68 212.41,49.36 212.41,50.38 211.88,50.9 208.39,50.9 207.34,51.95 203.37,51.95 202.37,50.96 200.55,50.96 200.45,51.05 192.29,51.05 191.13,52.21 189.08,52.21 187.06,54.24 187.06,56.01 186.38,56.69 185.45,56.69 184.31,57.82 184.31,59.61 182.79,61.13 180.92,61.13 180.67,61.37 173.34,61.37 172.76,61.95 v1(171.87,61.95)
  BOTTOM w0.14: v1(213.09,48.38) 213.09,48.12 215.91,45.3 218,45.3 R1162.2
ESPI_3_R: length 13.8
  BOTTOM w0.102: U49.AP46 217.98,56.62 218.06,56.54 218.06,56.08 218.16,55.98 218.16,55.29 220.22,53.23 220.38,53.23 220.74,52.87
  BOTTOM w0.14: R1162.1 218.79,46.54 219.29,46.54 219.84,47.09 219.84,47.86 220.2,48.22 220.2,49.94 220.82,50.55 220.84,50.55 221.09,50.8 221.09,51.4 221.2,51.51 221.2,52.41 220.74,52.87
ESPI_ALERT0#: length 8.9
  BOTTOM w0.102: U49.AU46 219.8,56.75 219.8,56.22 221.37,54.65 222.41,54.65 223.61,53.45 223.65,53.45
  BOTTOM w0.14: R1078.1 224.78,51.69 TP163.1 225.02,52.42 223.98,53.45 223.65,53.45
ESPI_ALERT1#: length 11.3
  BOTTOM w0.102: U49.AU45 219.91,57.74 220.6,57.74 220.91,57.43 220.91,55.9 220.91,55.89 220.91,55.4 221.43,54.88 222.47,54.88 223.63,53.71 224.12,53.71 224.6,53.23
  BOTTOM w0.14: TP170.1 225.53,50.84 225.53,52.3 224.6,53.23
ESPI_CLK: length 79.7
  TOP w0.14: v1(169.91,63.67) 170.03,63.79 170.03,65.53 169.06,66.5 U23.13 166.77,66.5 166.63,66.64 166.12,66.64 165.5,67.26 164.74,67.26 163.95,68.06 163.95,68.23 163.76,68.42 R440.2
  IN4 w0.086: v1(169.91,63.67) 170.9,64.66 174.58,64.66 175.25,63.98 183.45,63.98 184.58,62.86 186.38,62.86 186.81,62.43 186.81,60.36 187.19,59.98 187.19,57.88 188.88,56.19 189.32,56.19 191.81,53.7 192.4,53.7 194.01,52.08 199.68,52.08 200.24,52.64 202.3,52.64 202.64,52.98 207.77,52.98 208.5,52.25 210.11,52.25 210.46,52.6 220.51,52.6 221.12,51.99 222.45,51.99 222.97,51.46 222.97,50.68 220.35,48.06 v1(220.35,46.52)
  BOTTOM w0.14: R1163.2 219.49,45.61 219.89,46.01 C840.1 220.12,46.01 220.35,46.24 v1(220.35,46.52)
ESPI_CLK_R: length 14.2
  BOTTOM w0.102: U49.AR47 218.57,56.23 218.57,55.46 219.62,54.41 220.75,54.41 221.08,54.07 221.08,53.46 221.67,52.87
  BOTTOM w0.14: 221.67,52.87 222.22,52.32 222.22,51.54 222.03,51.35 v1(222.03,50.64) 221.66,50.27 220.93,50.27 220.48,49.82 220.48,48.11 220.12,47.74 220.12,46.97 219.33,46.19 219.23,46.19 R1163.1
ESPI_CS1#: length 8.5
  BOTTOM w0.102: U49.AT46 219.42,56.88 219.42,56.74 219.59,56.58 219.59,56.14 221.54,54.19 221.54,53.84 222.51,52.87
  BOTTOM w0.14: TP169.1 223.53,51.08 R1077.1 223.18,51.7 223.04,51.84 223.04,52.34 222.51,52.87
ESPI_CS#: length 68
  TOP w0.14: U23.6 168.6,69.3 171.67,66.23 171.67,64.61 172.1,64.17 172.1,64.03 v1(172.48,63.66)
  IN4 w0.086: v1(172.48,63.66) 172.49,63.66 172.49,63.67 173.01,64.19 174.38,64.19 175.06,63.52 178.77,63.52 179.79,62.5 183.49,62.5 183.6,62.39 185.38,62.39 186.34,61.43 186.34,60.17 186.73,59.78 186.73,57.68 188.78,55.63 188.78,54.6 190.42,52.96 192.47,52.96 193.82,51.61 199.88,51.61 200.43,52.17 202.49,52.17 202.83,52.51 207.57,52.51 208.31,51.78 210.31,51.78 210.66,52.13 220.32,52.13 220.92,51.52 222.25,51.52 222.51,51.27 v1(222.51,51.09)
  BOTTOM w0.14: R1076.2 222.63,51.22 v1(222.51,51.09)
ESPI_CS#_R: length 7
  BOTTOM w0.102: U49.AR46 218.77,56.53 218.77,55.54 219.7,54.61 220.83,54.61 221.34,54.1 221.34,53.61 222.07,52.87
  BOTTOM w0.14: 222.07,52.87 222.63,52.31 R1076.1
ESPI_RESET#: length 69.1
  TOP w0.14: R565.2 220.15,57.76 v1(220.54,58.15) ; v1(163.23,62.2) 163.47,61.97 R509.1
  IN3 w0.089: v1(163.23,62.2) 163.46,62.42 168.19,62.42 168.56,62.05 169.25,62.05 170.14,61.16 170.86,61.16 171.06,61.36 172.59,61.36 172.83,61.6 175.22,61.6 176.98,59.84 179.71,59.84 180.36,59.18 181.67,59.18 181.76,59.1 183.57,59.1 185.41,57.25 186.93,57.25 187.52,56.66 189.99,56.66 190.36,57.03 192.31,57.03 193.65,55.69 193.65,55.22 194.07,54.8 197.44,54.8 198.27,53.97 198.57,53.67 200.15,53.67 201.57,55.1 205.52,55.1 205.96,54.67 206.66,54.67 207.15,55.16 207.15,55.54 209.42,57.82 213.7,57.82 213.84,57.69 214.6,57.69 215.17,58.26 215.17,59.62 215.55,60 216.01,60 216.69,59.32 216.69,58.92 217.17,58.43 218.39,58.43 218.97,57.85 219.36,57.85 219.66,58.15 v1(220.54,58.15)
ESPI_RESET#_R: length 1.4
  TOP w0.14: v1(219.13,58.25) 219.18,58.21 R565.1
  BOTTOM w0.102: v1(219.13,58.25) 219.13,57.88 U49.AT45
FAN1_PWM: length 128.9
  TOP w0.14: v1(169.75,60.17) 169.75,60.05 168.6,58.9 U23.32
  IN2 w0.089: v1(169.75,60.17) 169.13,60.17 167.59,61.71 164.45,61.71 164.38,61.79 164.21,61.79 163.4,62.6 161.38,62.6 161.28,62.7 161.16,62.7 159.77,64.09 158.74,64.09 158.27,64.56 148.78,64.56 147.67,63.45 143.93,63.45 143.38,62.9 132.56,62.9 v1(131.96,62.29)
  BOTTOM w0.14: v1(131.96,62.29) 131.96,59.06 130.08,57.18 128.06,57.18 125.34,59.91 125.34,60.46 120.06,65.74 109.19,65.74 108.32,66.61 107.72,66.61 106.89,67.44 106.89,75.58 107.94,76.63 107.94,78.98 108.62,79.66 108.62,91.14 106.79,92.97 106.79,95.35 105.2,96.94 103.14,96.94 101.09,98.99 101.09,102.61 105.78,107.3 105.78,108.96 Q99.1
FAN1_PWM_Q: length 8.5
  BOTTOM w0.14: CN3.3 107.25,104.3 106.89,104.66 C690.1 106.41,104.66 106.17,104.89 v1(106.17,106.19) 106.17,107.75 106.5,108.08 R818.2 106.84,108.97 Q99.3
FAN1_RPM: length 122.2
  TOP w0.14: v1(175.2,58.41) 175.11,58.31 U23.47
  IN2 w0.089: v1(128.67,79.24) 128.67,79.92 127.21,81.39 120.9,81.39 118.31,83.99 118.31,94.61 115.9,97.02 115.9,101.76 115.01,102.65 115.01,111.1 113.59,112.52 v1(113.31,112.52) ; v1(131.24,62.29) 132.19,63.24 143.18,63.24 143.74,63.79 147.53,63.79 148.64,64.9 158.42,64.9 158.89,64.43 159.91,64.43 161.3,63.04 161.42,63.04 161.52,62.94 163.54,62.94 164.36,62.13 164.52,62.13 164.6,62.05 167.73,62.05 168.53,61.26 169.18,61.26 169.89,60.55 171.56,60.55 173.69,58.41 v1(175.2,58.41)
  BOTTOM w0.14: v1(128.67,79.24) 126.04,79.24 125.4,78.6 125.4,67.57 130.68,62.29 v1(131.24,62.29) ; R820.1 R817.2 109.92,109.55 Q100.1 111.93,112.09 112.35,112.52 v1(113.31,112.52)
FAN2_PWM: length 166.8
  TOP w0.14: v1(175.93,53.95) 177.23,52.66 177.23,51.91 176.49,51.17 170.31,51.17 v1(167.78,53.7) 166.79,54.69 166.64,54.69 166.25,55.08 166.25,57.25 165.97,57.53 165.97,58.39 166.88,59.3 U23.31 ; v1(276.94,78.27) 278.33,78.27 279.25,79.2 279.25,79.65 280.29,80.69 282.57,80.69 283.85,79.41 283.85,78.42 284.9,77.37 Q35.1
  IN3 w0.089: v1(175.93,53.95) 176.37,54.39 176.74,54.39 177.1,54.03 177.43,54.03 179.58,51.88 182.34,51.88 182.5,51.72 184.04,51.72 184.69,51.06 184.69,50.17 184.94,49.92 185.74,49.92 186.2,50.38 187.09,50.38 187.42,50.05 187.84,50.05 191.43,46.46 194.56,46.46 195.22,45.81 198.05,45.81 198.26,45.6 205.4,45.6 205.42,45.59 208.69,45.59 209.78,46.68 212.02,46.68 212.28,46.42 218.29,46.42 218.43,46.55 219.3,46.55 220.14,47.39 220.14,47.64 220.87,48.37 222.14,48.37 223.17,49.39 223.38,49.39 224.53,50.54 229.45,50.54 229.87,50.95 232.47,50.95 232.63,51.1 236.6,51.1 237.48,51.98 238.5,51.98 239.27,52.75 241.69,52.75 242.95,54.01 246.49,54.01 247.14,54.67 250.06,54.67 251.07,53.66 251.56,53.66 252.1,54.2 257.17,54.2 257.48,53.89 260.27,53.89 262.73,56.35 264.08,56.35 265.43,57.7 271.16,57.7 271.94,56.92 273.32,56.92 274.19,57.8 275.73,57.8 276.57,58.63 276.57,59.37 276.06,59.88 276.06,73.96 276.4,74.3 276.4,75.87 276.94,76.41 v1(276.94,78.27)
FAN2_PWM_Q:
  vias: v1(291.67,78.91)
FAN2_RPM: length 158.6
  TOP w0.14: Q31.1 291.33,82.75 290.8,82.22 290.8,81.44 290.22,80.86 288.36,80.86 R274.1 287.34,81.4 287.24,81.5 R272.2 286.98,80.37 v1(287.12,80.23) ; v1(175.92,58.4) 175.91,58.4 175.51,58 U23.48
  IN3 w0.089: v1(176.58,53.99) 176.88,53.69 177.29,53.69 179.44,51.54 182.19,51.54 182.36,51.38 183.84,51.38 184.35,50.87 184.35,50.03 184.8,49.58 185.88,49.58 186.34,50.04 186.95,50.04 187.27,49.71 187.69,49.71 191.28,46.12 194.42,46.12 195.07,45.46 197.91,45.46 198.11,45.26 205.26,45.26 205.28,45.24 208.83,45.24 209.93,46.34 211.87,46.34 212.14,46.07 218.43,46.07 218.57,46.21 219.45,46.21 220.48,47.25 220.48,47.5 221.01,48.03 222.29,48.03 223.31,49.05 223.53,49.05 224.67,50.19 229.6,50.19 230.01,50.6 232.61,50.6 232.77,50.76 236.75,50.76 237.62,51.64 238.64,51.64 239.41,52.41 241.84,52.41 243.09,53.66 246.63,53.66 247.29,54.32 249.92,54.32 250.92,53.32 251.71,53.32 252.24,53.86 257.03,53.86 257.34,53.55 260.41,53.55 262.87,56 264.22,56 265.57,57.36 271.02,57.36 271.8,56.58 273.46,56.58 274.33,57.45 275.87,57.45 276.45,58.03 277.42,58.03 277.77,58.38 277.77,59.06 277.59,59.24 277.33,59.24 276.4,60.16 276.4,73.82 276.74,74.16 276.74,75.12 279.31,77.69 281.99,77.69 283.96,79.66 284.7,79.66 284.86,79.82 284.86,80.35 285.37,80.86 286.9,80.86 287.12,80.63 v1(287.12,80.23)
  IN4 w0.086: v1(175.92,58.4) 176.84,57.48 176.84,54.25 v1(176.58,53.99)
FB_CAL_PD_VDDQ: length 2.3
  TOP w0.203: RG34.2 224.93,152.31 225.49,152.87 v2(225.59,152.87)
  BOTTOM w0.102: v2(225.59,152.87) 225.59,152.87 225.44,152.87 225.43,152.87 225.12,152.87 224.77,153.22 UG6.W47
FB_CAL_PU_GND: length 2.7
  TOP w0.203: v2(225.79,151.72) 225.96,151.88 226.26,151.88 226.36,151.78 RG35.2
  BOTTOM w0.125: UG6.Y47 224.55,152.3 224.9,151.96 224.9,151.87 225.22,151.54 225.61,151.54 v2(225.79,151.72)
FB_CAL_TERM_GND: length 3.1
  TOP w0.203: RG31.2 225.75,152.3 225.49,152.04 v2(225.29,152.04)
  BOTTOM w0.125: UG6.W48 224.21,152.86 224.7,152.86 224.9,152.66 224.9,152.42 v2(225.29,152.04)
FB_VREF_PROBE: length 0.5
  BOTTOM w0.129: UG6.W49 223.15,153.2 v2(223.49,152.87)
FBA_CMD0: length 23.9
  IN4 w0.102: v2(206.5,149.3) 206.48,149.3 206.09,149.69 205.31,149.69 204.66,150.34 204.66,151.01 204.06,151.6 204.06,152.75 205.7,154.38 208.34,154.38 208.72,154.76 214.32,154.76 216.19,152.89 v2(216.19,152.83)
  BOTTOM w0.102: VRAM6.J4 206.88,149.68 v2(206.5,149.3) ; UG6.Y53 220.35,152.5 220.04,152.19 216.82,152.19 v2(216.19,152.83)
FBA_CMD1: length 19
  IN4 w0.102: v2(217.34,151.8) 216.82,152.33 216.09,152.33 215.68,152.74 215.68,152.99 214.25,154.42 208.9,154.42 208.51,154.02 205.9,154.02 204.92,153.04 204.92,152.17 205.36,151.72 205.36,150.48 205.74,150.11 v2(205.74,150.07)
  BOTTOM w0.102: v2(217.34,151.8) 217.36,151.82 UG6.AA56
  BOTTOM w0.254: v2(205.74,150.07) 206.12,150.45 VRAM6.H3
FBA_CMD2: length 17.4
  IN4 w0.102: v2(206.51,150.84) 206.5,150.84 206.49,150.84 206.08,151.25 206.08,151.93 206.34,152.19 206.34,152.82 207.2,153.68 208.82,153.68 209.22,154.08 214.2,154.08 215.39,152.89 215.39,152.64 216.18,151.85 v2(216.18,151.79)
  BOTTOM w0.102: v2(206.51,150.84) 206.51,150.82 206.88,150.46 VRAM6.J3
  BOTTOM w0.129: UG6.AB55 218.57,151.5 217.68,151.5 217.59,151.41 216.57,151.41 v2(216.18,151.79)
FBA_CMD3: length 16.2
  TOP w0.165: RG28.1 206.34,153.15 v2(206.94,152.56)
  BOTTOM w0.129: 215.71,151.72 215.86,151.57 215.86,151.38 216.1,151.14 217.73,151.14 217.79,151.21 218.16,151.21 UG6.AB56
  BOTTOM w0.165: 215.71,151.72 215.71,153.39 214.83,154.28 209.73,154.28 208.62,153.17 207.52,153.17 206.94,152.58 v2(206.94,152.56) 206.88,152.49 VRAM6.J1
FBA_CMD4: length 16.5
  IN4 w0.102: v2(217.84,150.73) 217.44,151.13 216.17,151.13 215.67,151.63 215.67,152.02 215.16,152.52 215.16,152.63 214.14,153.66 209.25,153.66 208.97,153.37 207.19,153.37 206.55,152.72 206.55,152.09 206.89,151.75 206.89,151.2 207.24,150.85 v2(207.24,150.84)
  BOTTOM w0.102: UG6.AC56 218.15,150.42 v2(217.84,150.73)
  BOTTOM w0.129: VRAM6.K3 207.63,150.47 207.27,150.82 207.26,150.82 v2(207.24,150.84)
FBA_CMD5: length 17.8
  IN4 w0.102: v2(207.99,150.83) 207.98,150.85 207.35,151.48 207.35,152.72 207.75,153.11 209.29,153.11 209.46,153.28 214.03,153.28 214.85,152.46 214.85,152.41 215.21,152.05 215.21,151.5 215.98,150.73 v2(216.53,150.73)
  BOTTOM w0.102: UG6.AC53 220.04,150.11 217.87,150.11 217.73,150.25 216.96,150.25 216.53,150.68 v2(216.53,150.73) ; v2(207.99,150.83) 207.99,150.82 208.37,150.45 VRAM6.L3
FBA_CMD6: length 14.9
  IN4 w0.102: v2(217.77,149.72) 217.77,149.75 217.23,150.29 216.02,150.29 214.88,151.43 214.88,151.91 214.41,152.38 214.41,152.54 214.06,152.89 210.25,152.89 209.55,152.19 209.05,152.19 208.39,151.53 208.39,150.57 208.26,150.45 207.67,150.45 207.3,150.07 207.28,150.07 v2(207.28,150.07)
  BOTTOM w0.165: UG6.AD56 v2(217.77,149.72)
  BOTTOM w0.254: VRAM6.K4 207.63,149.72 207.28,150.07 v2(207.28,150.07)
FBA_CMD7: length 14.1
  IN4 w0.102: v2(208.74,150.07) 208.74,151.59 209.13,151.98 213.87,151.98 213.97,152.08 214.31,152.08 214.56,151.83 214.56,151.34 216.19,149.71 v2(216.6,149.71)
  BOTTOM w0.165: v2(216.6,149.71) 217,149.31 218.01,149.31 218.06,149.36 218.61,149.36 UG6.AE55
  BOTTOM w0.254: v2(208.74,150.07) 209.11,149.7 VRAM6.M4
FBA_CMD8: length 12
  BOTTOM w0.129: 218.23,149.04 UG6.AE56
  BOTTOM w0.165: 218.23,149.04 216.56,149.04 216.09,149.52 215.26,149.52 214.53,148.78 214.53,148.24 214.16,147.88 208.63,147.88 208.38,148.13 VRAM6.L5
FBA_CMD9: length 13.4
  IN4 w0.102: v2(217.42,148.59) 217.42,148.95 217.06,149.32 216.1,149.32 214.95,150.47 214.95,150.66 214.4,151.22 210.11,151.22 209.88,150.99 209.88,150.52 209.05,149.69 208.38,149.69 v2(207.99,149.3)
  BOTTOM w0.102: VRAM6.K5 207.63,148.96 207.97,149.3 v2(207.99,149.3)
  BOTTOM w0.129: v2(217.42,148.59) 217.69,148.32 UG6.AF56
FBA_CMD10: length 15.8
  IN4 w0.102: v2(216.6,148.58) 216.55,148.58 216.09,149.04 215.67,149.04 214.26,150.45 210.11,150.45 209.34,149.69 209.33,149.69 208.5,148.86 207.6,148.86 v2(207.2,148.46)
  BOTTOM w0.102: VRAM6.J5 206.88,148.78 v2(207.2,148.46)
  BOTTOM w0.165: UG6.AF53 220.24,148.32 219.91,147.98 217.2,147.98 v2(216.6,148.58)
FBA_CMD11: length 15.1
  BOTTOM w0.165: UG6.AG56 216.7,147.62 216.03,148.29 216.03,148.86 215.7,149.19 215.47,149.19 215.17,148.89 215.17,148.15 214.63,147.61 206.88,147.61 206.14,148.35 206.14,148.93 VRAM6.H5
FBA_CMD12: length 17.8
  IN4 w0.102: v2(215.62,148.65) 215.61,148.65 214.57,149.69 210.04,149.69 209.87,149.51 209.87,149.13 209.26,148.52 209.26,148.13 209.1,147.97 207.02,147.97 206.1,148.89 205.4,148.89 v2(204.99,149.3)
  BOTTOM w0.129: UG6.AH55 218.6,147.27 216.26,147.27 ; VRAM6.G4 204.99,149.31 v2(204.99,149.3)
  BOTTOM w0.165: 216.26,147.27 215.62,147.91 v2(215.62,148.65)
FBA_CMD13: length 15.3
  IN4 w0.102: v2(217.66,146.56) 217.17,146.07 215.24,146.07 214.37,146.93 210.8,146.93 210.23,146.36 206.2,146.36 205.94,146.09 205.94,145.04 205.75,144.86 v2(205.75,144.84)
  BOTTOM w0.102: VRAM6.G11 205.38,144.47 v2(205.75,144.84)
  BOTTOM w0.129: v2(217.66,146.56) 218.02,146.92 UG6.AH56
FBA_CMD14: length 15.9
  TOP w0.165: RG37.2 204.9,146.02 205.13,145.79 v2(205.25,145.79)
  BOTTOM w0.165: UG6.AJ56 217.99,146.22 217.89,146.12 216.8,146.12 215.57,147.34 206.11,147.34 205.42,146.66 205.42,145.96 v2(205.25,145.79) 205.38,145.66 VRAM6.G10
FBA_CMD15: length 16.5
  BOTTOM w0.165: UG6.AJ53 220.01,145.88 218.07,145.88 217.97,145.78 216.47,145.78 215.25,147 208.96,147 208.49,146.52 206.29,146.52 205.9,146.13 205.9,145.42 VRAM6.H10
FBA_CMD16: length 11.4
  BOTTOM w0.165: UG6.AK56 218.12,145.52 218.02,145.42 216.18,145.42 214.87,146.73 209.36,146.73 208.69,146.06 208.69,145.51 VRAM6.L10
FBA_CMD17: length 12.2
  TOP w0.165: RG39.2 209.56,145.64 209.3,145.9 v2(209.19,145.9)
  BOTTOM w0.165: UG6.AL55 218.61,145.16 218.11,145.16 218.02,145.07 215.9,145.07 214.51,146.46 209.75,146.46 v2(209.19,145.9) 209.13,145.83 VRAM6.M10
FBA_CMD18: length 10.8
  IN4 w0.102: v2(208.75,144.84) 209.12,144.47 214.23,144.47 214.51,144.19 216.41,144.19 216.63,143.98 217.02,143.98 v2(217.43,144.38)
  BOTTOM w0.102: VRAM6.M11 209.13,144.47 v2(208.75,144.84)
  BOTTOM w0.129: v2(217.43,144.38) 217.78,144.73 218.16,144.73 UG6.AL56
FBA_CMD19: length 15.7
  IN2 w0.102: v2(209.43,141.66) 209.1,141.33 208.32,141.33 208.26,141.4
  IN2 w0.114: v2(208,144.08) 208,141.66 208.26,141.4
  BOTTOM w0.12: VRAM6.K11 207.64,144.45 208,144.09 v2(208,144.08)
  BOTTOM w0.165: UG6.AM56 217.79,144.12 217.62,143.95 216.63,143.95 216.41,144.17 215.88,144.17 215.34,143.63 215.34,142.45 214.13,141.24 210.11,141.24 209.69,141.66 v2(209.43,141.66)
FBA_CMD20: length 12.6
  IN4 w0.102: v2(216.25,143.57) 216.18,143.5 214.54,143.5 214.34,143.69 212.35,143.69 212.34,143.7 209.14,143.7 v2(208.75,143.31)
  BOTTOM w0.102: 218.4,143.78 218.42,143.8 219.97,143.8 220.29,144.12 UG6.AM53 ; VRAM6.L12 208.38,143.69 v2(208.75,143.31)
  BOTTOM w0.129: v2(216.25,143.57) 216.29,143.61 217.81,143.61 217.98,143.78 218.39,143.78 218.4,143.78
FBA_CMD21: length 14.1
  BOTTOM w0.165: UG6.AN56 218.18,143.35 216.63,143.35 216.22,142.94 216.22,142.41 214.6,140.79 209.88,140.79 209.45,141.22 208.64,141.22 207.99,141.87 207.99,143.33 VRAM6.K12
FBA_CMD22: length 17.2
  BOTTOM w0.165: UG6.AP55 218.61,143.06 216.9,143.06 216.54,142.7 216.54,141.97 215.99,141.42 214.98,140.41 209.78,140.41 209.32,140.87 208.36,140.87 208.19,141.05 206.73,141.05 206.33,141.45 206.33,141.79 206.51,141.97 206.51,143.19 206.88,143.55 VRAM6.J12
FBA_CMD23: length 18.1
  IN2 w0.114: v2(205.99,141.17) 206.41,141.59 206.41,141.75 206.5,141.84 206.5,144.05 v2(206.52,144.07)
  BOTTOM w0.102: v2(206.52,144.07) 206.88,144.43 VRAM6.J11
  BOTTOM w0.165: v2(205.99,141.17) 206.63,140.52 209.07,140.52 209.57,140.02 215.36,140.02 216.82,141.48 216.82,142.48 217.12,142.77 218.2,142.77 UG6.AP56
FBA_CMD24: length 14
  IN4 w0.102: v2(205.76,143.31) 205.76,143.29 206.12,142.93 214.55,142.93 215.58,141.9 217.43,141.9 v2(217.89,142.36)
  BOTTOM w0.102: v2(205.76,143.31) 206.13,143.68 VRAM6.H12
  BOTTOM w0.129: v2(217.89,142.36) 218.22,142.02 UG6.AR56
FBA_CMD28: length 15.8
  IN4 w0.102: v2(206.5,129.59) 206.89,129.2 206.89,127.67 207.79,126.77 214.23,126.77 216.59,129.12 217.31,129.12 v2(217.76,129.57)
  BOTTOM w0.102: v2(217.76,129.57) 217.76,129.63 UG6.BM56 ; VRAM8.K4 206.86,129.95 v2(206.5,129.59)
FBA_CMD29: length 18.2
  IN4 w0.102: v2(205.75,128.81) 205.75,128.8 206.06,128.5 206.06,126.97 206.19,126.84 207.27,126.84 207.9,126.21 214.44,126.21 216.85,128.62 217.62,128.62 218.6,129.59 v2(218.6,130.48)
  BOTTOM w0.102: UG6.BM55 218.95,130.13 v2(218.6,130.48)
  BOTTOM w0.129: v2(205.75,128.81) 206.13,129.18 VRAM8.L3
FBA_CMD30: length 13.5
  IN4 w0.102: v2(217.14,130.49) 217.14,130.41 214.36,127.64 208.42,127.64 207.27,128.78 v2(207.27,128.82)
  BOTTOM w0.102: VRAM8.K3 206.9,129.2 v2(207.27,128.82) ; UG6.BL56 218.15,130.92 217.52,130.92 217.14,130.54 v2(217.14,130.49)
FBA_CMD31: length 19.8
  BOTTOM w0.129: 216.32,126.63 216.32,130.49 217.01,131.18 218.61,131.18 UG6.BK55 ; VRAM8.J1 207.53,127.6 207.53,126.18 208.02,125.69 208.02,125.57
  BOTTOM w0.165: 208.02,125.57 RG132.1 208.02,124.88 208.18,124.72 215.47,124.72 216.32,125.57 216.32,126.63
FBA_CMD32: length 12.5
  IN4 w0.102: v2(217.81,131.86) 214.38,128.43 208.37,128.43 v2(207.99,128.82)
  BOTTOM w0.102: UG6.BK56 218.14,131.52 v2(217.81,131.86)
  BOTTOM w0.129: VRAM8.J3 207.63,129.18 v2(207.99,128.82)
FBA_CMD33: length 12.1
  IN4 w0.102: v2(208.74,128.81) 209.12,129.2 211.16,129.2 211.25,129.28 211.98,129.28 212.07,129.2 214.53,129.2 216.23,130.91 v2(216.23,131.77)
  BOTTOM w0.129: VRAM8.H3 208.38,129.18 v2(208.74,128.81)
  BOTTOM w0.165: UG6.BJ56 218.15,132.32 216.79,132.32 v2(216.23,131.77)
FBA_CMD34: length 14.2
  IN4 w0.102: v2(218.59,131.87) 218.21,132.25 216.16,132.25 215.85,131.93 215.85,131.17 214.65,129.97 211.45,129.97 211.29,130.13 210.69,130.13 210.53,129.96 207.6,129.96 v2(207.24,130.32)
  BOTTOM w0.102: v2(207.24,130.32) 207.25,130.32 VRAM8.J4 ; v2(218.59,131.87) 218.94,132.22 UG6.BJ55
FBA_CMD35: length 10.6
  IN4 w0.102: v2(217.71,132.9) 217.28,132.47 216.05,132.47 215.52,131.94 215.52,131.53 214.77,130.79 209.93,130.79 209.5,130.37 v2(209.5,130.34)
  BOTTOM w0.102: v2(209.5,130.34) 209.13,129.96 VRAM8.G4
  BOTTOM w0.129: v2(217.71,132.9) 217.73,132.92 UG6.BH56
FBA_CMD36: length 13.5
  BOTTOM w0.165: VRAM8.H5 209.38,131.7 210.33,131.7 210.4,131.63 215.51,131.63 216.43,132.55 216.43,132.93 216.82,133.32 217.94,133.32 217.99,133.27 220,133.27 UG6.BG53
FBA_CMD37: length 12.4
  IN4 w0.102: v2(216.4,134.06) 216.4,133.91 214.57,132.08 210.69,132.08 210.3,131.69 209.44,131.69 208.96,131.21 v2(208.03,131.21)
  BOTTOM w0.129: v2(208.03,131.21) 207.63,130.8 VRAM8.J5
  BOTTOM w0.165: UG6.BG56 218.22,133.59 216.87,133.59 v2(216.4,134.06)
FBA_CMD38: length 13.7
  IN4 w0.102: v2(207.23,131.23) 207.67,131.68 209.01,131.68 209.67,132.34 214.51,132.34 215.9,133.72 215.9,134.19 216.25,134.54 217.24,134.54 v2(217.77,134.01)
  BOTTOM w0.102: VRAM8.K5 206.88,130.88 v2(207.23,131.23)
  BOTTOM w0.129: UG6.BF56 217.94,134.01 v2(217.77,134.01)
FBA_CMD39: length 16.1
  BOTTOM w0.165: UG6.BF55 218.61,134.66 217.98,134.66 217.93,134.61 216.31,134.61 215.98,134.28 215.98,132.8 215.16,131.98 206.52,131.98 205.99,131.45 205.99,130.84 VRAM8.L5
FBA_CMD40: length 15.6
  IN4 w0.102: v2(205.75,130.34) 206.24,130.34 206.84,130.94 206.84,131.41 207.36,131.93 208.72,131.93 209.36,132.57 214.39,132.57 215.44,133.62 215.44,134.12 216.35,135.02 v2(217.72,135.02)
  BOTTOM w0.102: v2(205.75,130.34) 205.38,129.96 VRAM8.M4
  BOTTOM w0.129: UG6.BE56 v2(217.72,135.02)
FBA_CMD41: length 19.2
  TOP w0.165: v2(205.42,133.91) RG51.2
  BOTTOM w0.165: UG6.BD53 220.01,135.38 218.01,135.38 217.9,135.49 216.71,135.49 215.6,134.38 215.6,133.03 214.94,132.37 206.58,132.37 205.42,133.53 v2(205.42,133.91) 205.42,134.4 VRAM8.M10
FBA_CMD42: length 15.9
  BOTTOM w0.165: UG6.BD56 218.01,135.96 216.58,135.96 215.24,134.62 215.24,133.31 214.68,132.75 206.75,132.75 205.86,133.63 205.86,134.18 VRAM8.L10
FBA_CMD43: length 12.7
  BOTTOM w0.165: VRAM8.H10 208.72,134.1 208.72,133.66 209.24,133.14 214.29,133.14 214.81,133.65 214.81,134.8 216.43,136.42 UG6.BC56
FBA_CMD44: length 13.3
  TOP w0.203: v2(209.63,133.8) RG50.2
  BOTTOM w0.129: VRAM8.G10 209.13,134.37 209.63,133.86 v2(209.63,133.8)
  BOTTOM w0.165: v2(209.63,133.8) 209.99,133.44 214.05,133.44 214.43,133.82 214.43,135.01 215.99,136.57 216.19,136.76 218.61,136.76 UG6.BC55
FBA_CMD45: length 10.5
  IN4 w0.102: v2(209.51,134.8) 209.71,134.8 210.09,135.18 213.51,135.18 213.72,135.39 213.72,135.71 213.95,135.93 214.46,135.93 215.13,136.61 217.16,136.61 v2(217.75,137.2)
  BOTTOM w0.102: v2(217.75,137.2) 217.83,137.12 UG6.BB56
  BOTTOM w0.129: v2(209.51,134.8) 209.13,135.18 VRAM8.G11
FBA_CMD46: length 14.4
  IN4 w0.102: v2(216.18,137.2) 215.97,136.99 214.56,136.99 214.28,136.71 208.52,136.71 208.32,136.51 208.32,135.99 v2(208.74,135.56)
  BOTTOM w0.129: v2(208.74,135.56) 208.38,135.93 VRAM8.H12
  BOTTOM w0.165: v2(216.18,137.2) 216.63,137.65 217.93,137.65 218.09,137.48 220.01,137.48 UG6.BA53
FBA_CMD47: length 14.5
  IN2 w0.102: v2(208.67,137.97) 208.64,137.94 208.39,137.94 208.26,137.81
  IN2 w0.114: v2(207.25,134.8) 207.27,134.8 207.84,135.37 207.84,137.39 208.26,137.81
  BOTTOM w0.102: VRAM8.J11 207.63,135.17 v2(207.25,134.8)
  BOTTOM w0.165: UG6.BA56 218.1,137.97 215.59,137.97 215.26,138.3 214.33,138.3 214.2,138.43 209.42,138.43 208.95,137.97 v2(208.67,137.97)
FBA_CMD48: length 13.2
  BOTTOM w0.165: UG6.AY56 218.08,138.35 216.13,138.35 215.69,138.8 208.6,138.8 207.99,138.18 207.99,136.31 VRAM8.J12
FBA_CMD49: length 15.9
  BOTTOM w0.165: VRAM8.K12 206.51,136.32 206.51,137.88 206.82,138.2 206.82,138.62 207.58,139.38 209.79,139.38 209.99,139.18 216.31,139.18 216.76,138.73 217.86,138.73 218,138.87 218.6,138.87 UG6.AY55
FBA_CMD50: length 17.1
  IN4 w0.102: v2(216.36,139.85) 208.9,139.85 208.79,139.73 207.76,139.73 207.36,140.13 206.75,140.13 205.37,138.75 205.37,136.71 v2(205.74,136.33)
  BOTTOM w0.102: v2(205.74,136.33) 206.13,135.95 VRAM8.L12 ; v2(216.36,139.85) 216.81,139.39 218.08,139.39 UG6.AW56
FBA_CMD51: length 19.5
  IN2 w0.114: v2(207.24,135.56) 206.62,136.18 206.62,137.96 v2(206.24,138.34)
  BOTTOM w0.102: v2(207.24,135.56) 207.23,135.56 206.88,135.21 VRAM8.K11
  BOTTOM w0.165: UG6.AV53 220,139.57 218.77,139.57 218.6,139.74 218.6,140.15 218.48,140.27 217.94,140.27 217.93,140.27 216.16,140.27 215.5,139.61 210.06,139.61 209.98,139.68 207.42,139.68 206.51,138.77 206.51,138.61 v2(206.24,138.34)
FBA_CMD52: length 18.5
  IN4 w0.102: v2(205.01,135.57) 204.62,135.95 204.62,136.67 204.76,136.81 204.76,137.34 204.48,137.62 204.48,138.15 206.82,140.49 208.48,140.49 208.74,140.23 217.08,140.23 217.46,139.86 v2(217.49,139.86)
  BOTTOM w0.102: v2(217.49,139.86) 218.19,139.86 UG6.AV56 ; v2(205.01,135.57) 205.38,135.2 VRAM8.M11
FBA_DBI0: length 14
  IN2 w0.102: v2(211.75,151.6) 212.12,151.23 212.12,150.22 213.43,148.92 214.5,148.92 214.64,149.05 222.3,149.05 222.72,149.47 v2(222.72,149.48)
  BOTTOM w0.102: v2(211.75,151.6) 211.75,151.6 211.38,151.22 VRAM6.R2
  BOTTOM w0.161: UG6.AE50 222.45,149.12 222.72,149.39 v2(222.72,149.48)
FBA_DBI1: length 25
  IN1 w0.102: v2(222.68,151.61) 222.41,151.61 220.91,150.1 215.93,150.1 214.61,148.78 214.61,148.38 214.04,147.81 204.48,147.81 204.28,148.01 204.28,148.33 203.84,148.78 203.51,148.78 202.9,149.39 202.9,150.66 v2(202.76,150.81)
  BOTTOM w0.102: v2(202.76,150.81) 203.13,151.17 VRAM6.D2
  BOTTOM w0.161: v2(222.68,151.61) 222.68,151.35 UG6.AB50
FBA_DBI2: length 19.8
  IN2 w0.102: v2(222.67,145.46) 222.67,146.03 221.51,147.19 219.42,147.19 219.24,147.37 215.93,147.37 215.57,147 210.61,147 209.87,146.26 209.87,145.76 210.68,144.95 210.68,144.68 210.29,144.29 210.29,143.34 v2(210.26,143.31)
  BOTTOM w0.102: UG6.AL50 222.67,145.04 v2(222.67,145.46) ; v2(210.26,143.31) 210.29,143.28 211.04,143.28 VRAM6.R13
FBA_DBI3: length 22.9
  IN1 w0.102: v2(222.79,146.57) 222.42,146.57 222.03,146.96 216.83,146.96 214.34,144.46 204.13,144.46 203.86,144.19 203.86,143.85 203.7,143.69 203.14,143.69 v2(202.76,143.31)
  BOTTOM w0.102: VRAM6.D13 203.13,142.95 v2(202.76,143.31)
  BOTTOM w0.161: v2(222.79,146.57) 222.45,146.91 UG6.AH50
FBA_DBI4: length 27
  IN1 w0.102: v2(202.76,128.82) 202.76,128.85 202.86,128.95 203.13,129.22 203.13,129.84 202.72,130.24 202.72,131.74 202.94,131.96 203.33,131.96 203.64,131.66 214.94,131.66 216,132.73 216,134.21 216.6,134.81 216.69,134.81 218.48,136.6 218.85,136.6 219,136.44 219.74,136.44 219.79,136.49 221.81,136.49 v2(222.12,136.8)
  BOTTOM w0.102: v2(222.12,136.8) 222.12,136.75 UG6.BC50 ; VRAM8.R2 203.12,128.45 202.76,128.81 v2(202.76,128.82)
FBA_DBI5: length 15.6
  IN2 w0.102: v2(211.77,128.83) 212.59,128.83 212.95,129.19 214.72,129.19 215.89,130.36 215.89,130.75 216.63,131.49 216.63,132.06 216.83,132.26 218.06,132.26 218.53,132.73 218.81,132.73 219.27,133.19 221.15,133.19 221.42,133.46 222.13,133.46 222.71,134.04 v2(222.71,134.82)
  BOTTOM w0.161: VRAM8.D2 211.39,128.45 v2(211.77,128.83) ; UG6.BF50 222.71,134.58 v2(222.71,134.82)
FBA_DBI6: length 25.9
  IN1 w0.102: v2(222.81,140.26) 222.14,139.6 219.05,139.6 218.26,138.81 216.65,138.81 215.22,137.37 215.22,136.14 214.43,135.35 214.43,134.63 214.19,134.4 203.91,134.4 203.13,135.18 203.13,135.95 202.78,136.3 v2(202.74,136.3)
  BOTTOM w0.102: v2(202.74,136.3) 203.13,136.69 VRAM8.R13
  BOTTOM w0.161: UG6.AU50 v2(222.81,140.26)
FBA_DBI7: length 13.3
  IN2 w0.102: v2(222.17,138.94) 221.49,139.62 218.24,139.62 217.3,138.68 212.59,138.68 212.13,138.22 212.13,137.49 211.75,137.11 v2(211.75,137.09)
  BOTTOM w0.102: v2(222.17,138.94) 222.45,138.66 UG6.AY50 ; VRAM8.D13 211.38,136.72 v2(211.75,137.09)
FBA_EDC0: length 9.6
  IN2 w0.102: v2(212.51,150.83) 212.51,150.26 213.09,149.69 214.35,149.69 214.53,149.51 216.05,149.51 216.23,149.33 219.83,149.33 v2(219.94,149.45)
  BOTTOM w0.102: v2(212.51,150.83) 212.15,151.2 VRAM6.T2 ; v2(219.94,149.45) 219.96,149.43 219.96,149.41 UG6.AE53
FBA_EDC1: length 20.1
  IN1 w0.102: v2(202.01,151.56) 202.37,151.21 204.52,151.21 205.27,150.45 214.55,150.45 215.51,151.41 217.55,151.41 217.71,151.57 218.96,151.57 219.14,151.39 219.84,151.39 v2(219.95,151.5)
  BOTTOM w0.102: v2(219.95,151.5) 220.34,151.12 UG6.AB53
  BOTTOM w0.161: VRAM6.C2 v2(202.01,151.56)
FBA_EDC2: length 11.7
  IN2 w0.102: v2(212.5,142.54) 212.49,142.55 212.49,143.4 212.11,143.79 212.11,144.28 212.29,144.46 214.47,144.46 215.76,145.76 219.44,145.76 v2(219.96,145.24)
  BOTTOM w0.102: v2(219.96,145.24) 220.35,144.85 UG6.AL53 ; VRAM6.T13 212.13,142.92 v2(212.5,142.54)
FBA_EDC3: length 23.6
  IN1 w0.102: v2(202.02,142.57) 202.38,142.93 202.38,144.31 201.96,144.73 201.96,145.95 202.32,146.32 215.11,146.32 216.36,147.57 v2(219.81,147.57)
  BOTTOM w0.102: VRAM6.C13 202.38,142.92 v2(202.02,142.57)
  BOTTOM w0.161: UG6.AH53 220.35,147.01 219.81,147.55 v2(219.81,147.57)
FBA_EDC4: length 25.9
  IN1 w0.102: v2(202,128.07) 202.37,128.44 202.37,130 202.48,130.11 202.48,131.86 202.79,132.18 203.65,132.18 203.79,132.04 214.68,132.04 215.7,133.06 215.7,134.43 218.48,137.21 219.6,137.21 v2(219.92,136.89)
  BOTTOM w0.102: UG6.BC53 220.35,136.46 v2(219.92,136.89) ; v2(202,128.07) 202.37,128.45 VRAM8.T2
FBA_EDC5: length 15.2
  IN2 w0.102: v2(219.93,134.77) 219.58,135.12 218.37,135.12 217.76,134.51 216.13,134.51 212.83,131.21 212.83,131.05 212.56,130.78 211.63,130.78 211.37,130.52 211.37,130.11 211.39,130.09 211.39,128.55 211.51,128.43 212.12,128.43 v2(212.51,128.04)
  BOTTOM w0.102: VRAM8.C2 212.13,128.43 v2(212.51,128.04)
  BOTTOM w0.161: v2(219.93,134.77) 219.93,134.74 UG6.BF53
FBA_EDC6: length 21.5
  IN1 w0.102: v2(202.03,137.07) 202.38,136.71 210.69,136.71 211.51,137.53 212.67,137.53 212.95,137.82 212.95,138.18 213.16,138.4 214.37,138.4 216.54,140.56 217.56,140.56 218.38,141.39 219.45,141.39 v2(219.48,141.36)
  BOTTOM w0.102: VRAM8.T13 202.38,136.72 v2(202.03,137.07)
  BOTTOM w0.161: v2(219.48,141.36) 219.52,141.36 220.26,140.62 UG6.AU53
FBA_EDC7: length 10.4
  IN2 w0.102: v2(219.96,138.93) 219.57,139.32 218.57,139.32 217.43,138.18 215.12,138.18 214.52,137.59 213.05,137.59 212.52,137.05 v2(212.52,136.32)
  BOTTOM w0.102: v2(219.96,138.93) 220.35,138.54 UG6.AY53 ; VRAM8.C13 212.15,136.7 v2(212.52,136.32)
FBA_VREFC: length 1.5
  TOP w0.203: RG29.1 207.78,152.59 v2(207.81,152.56)
  BOTTOM w0.3: VRAM6.K1 207.63,152.37 v2(207.81,152.56)
FBA_VREFC_H: length 2.9
  BOTTOM w0.102: 206.88,125.57 206.88,125.57 206.57,125.88 206.57,126.72 206.96,127.11 206.96,127.61 VRAM8.K1
  BOTTOM w0.14: RG131.1 206.88,125.57
FBA_ZQ_1_A: length 1.4
  TOP w0.14: v2(206.8,141.59) 206.8,141.88 206.61,142.07 RG40.1
  BOTTOM w0.102: VRAM6.J14 206.88,141.67 v2(206.8,141.59)
FBA_ZQ_1_B: length 1.6
  TOP w0.14: RG41.1 207.89,141.22 v2(207.53,141.58)
  BOTTOM w0.12: v2(207.53,141.58) 207.63,141.68 VRAM6.K14
FBA_ZQ_2_A: length 1.9
  TOP w0.14: RG43.1 207.3,138.73 v2(207.3,138.49)
  BOTTOM w0.102: VRAM8.J14 207.63,138 207.3,138.33 v2(207.3,138.49)
FBA_ZQ_2_B: length 1.6
  TOP w0.14: v2(207.19,137.9) 207.85,137.24 RG46.1
  BOTTOM w0.102: v2(207.19,137.9) 206.88,137.58 VRAM8.K14
FBB_CMD0: length 19.4
  IN4 w0.102: v2(231.19,168.37) 231.19,168.65 230.48,169.36 230.48,177 229.8,177.68 228.65,177.68 228.38,177.95 227.77,177.95 227.03,178.69 226.33,178.69 226.11,178.46 226.11,177.97 225.76,177.62 225.76,177.61 v2(225.73,177.58)
  BOTTOM w0.102: VRAM1.J4 225.74,177.58 v2(225.73,177.58)
  BOTTOM w0.129: UG6.B37 231.9,165.47 231.9,165.97 231.7,166.17 231.7,167.54 231.37,167.87 231.19,168.05 v2(231.19,168.37)
FBB_CMD1: length 15.8
  IN4 w0.102: v2(231.19,166.24) 231.08,166.24 230.49,166.82 230.49,168.41 229.77,169.13 229.77,174.46 229.4,174.83 228.79,174.83 228.41,175.21 228.41,176.25 228.25,176.41 228.25,176.41 227.47,177.19 227.06,177.19 226.49,177.75 v2(226.49,178.3)
  BOTTOM w0.102: VRAM1.H3 226.85,177.95 v2(226.49,178.3) ; v2(231.19,166.24) 231.19,166.18 UG6.A37
FBB_CMD2: length 15
  IN4 w0.102: v2(231.18,167.36) 230.79,167.75 230.79,168.58 230.13,169.24 230.13,175.25 229.47,175.9 229.47,176.79 229.05,177.21 228.28,177.21 228.23,177.15 227.87,177.15 227.44,177.57 v2(227.26,177.57)
  BOTTOM w0.102: VRAM1.J3 226.88,177.2 v2(227.26,177.57)
  BOTTOM w0.129: v2(231.18,167.36) 231.11,167.36 230.77,167.03 230.77,165.9 UG6.A38
FBB_CMD3: length 15.8
  TOP w0.165: RG11.1 228.72,177 v2(228.89,176.83)
  BOTTOM w0.129: UG6.D38 230.53,164.04 230.53,166.13 230.53,168.46 230.81,168.75 230.81,174.74 229.44,176.11 229.44,176.28 228.91,176.82 228.89,176.82 v2(228.89,176.83) 228.53,177.2 VRAM1.J1
FBB_CMD4: length 13.3
  IN4 w0.102: v2(226.49,176.82) 226.49,176.63 226.88,176.24 226.88,175.12 227.05,174.94 227.48,174.94 228.47,173.95 228.47,169.67 228.87,169.26 228.87,169.03 229.66,168.24 229.66,166.77 v2(230.11,166.31)
  BOTTOM w0.102: UG6.A39 230.15,166.27 v2(230.11,166.31)
  BOTTOM w0.129: VRAM1.K3 226.86,176.45 226.49,176.82 v2(226.49,176.82)
FBB_CMD5: length 13.3
  IN4 w0.102: v2(227.26,176.07) 227.26,175.98 227.75,175.49 227.75,175.22 228.56,174.41 229.05,174.41 229.38,174.09 229.38,169 230.04,168.33 v2(230.04,167.47)
  BOTTOM w0.129: v2(227.26,176.07) 227.26,176.07 226.89,175.7 VRAM1.L3 ; UG6.B40 229.79,165.46 229.79,165.98 229.68,166.08 229.68,167.21 229.95,167.47 v2(230.04,167.47)
FBB_CMD6: length 12.6
  IN4 w0.102: v2(225.73,176.07) 225.73,176.06 225.73,176.04 226.11,175.67 226.11,174.73 226.88,173.96 226.88,169.83 227.13,169.59 227.31,169.59 229.01,167.89 v2(229.01,167.62)
  BOTTOM w0.102: v2(225.73,176.07) 226.11,176.45 VRAM1.K4
  BOTTOM w0.129: v2(229.01,167.62) 229.28,167.62 229.45,167.45 229.45,165.82 UG6.A40
FBB_CMD7: length 11.5
  IN4 w0.102: v2(226.49,175.31) 226.49,174.78 227.64,173.64 227.64,173.23 227.64,173.23 227.64,171.03 227.64,171.03 227.64,170.2 227.65,170.19 227.65,169.87 227.64,169.86 227.64,169.81 228.26,169.18 228.26,169.11 229.43,167.94 229.43,166.83 v2(229.05,166.45)
  BOTTOM w0.102: v2(226.49,175.31) 226.49,175.31 VRAM1.M4 ; UG6.A41 229.05,166.12 v2(229.05,166.45)
FBB_CMD8: length 15.9
  BOTTOM w0.129: UG6.D41 228.38,164.09 228.38,166.03 228.59,166.25 228.59,167.87 227.18,169.28 225.02,169.28 224.44,169.87 224.44,175.25 224.88,175.7 VRAM1.L5
FBB_CMD9: length 12.8
  IN4 w0.102: v2(224.89,176.12) 225.28,175.73 225.28,174.08 226.11,173.25 226.11,169.79 226.29,169.6 226.8,169.6 228.41,167.99 228.41,167.13 v2(228.05,166.77)
  BOTTOM w0.102: UG6.A42 228.05,166.37 v2(228.05,166.77)
  BOTTOM w0.129: VRAM1.K5 225.21,176.45 v2(224.89,176.12)
FBB_CMD10: length 15.2
  IN4 w0.102: v2(224.89,176.87) 224.18,176.16 224.18,174.39 224.58,173.98 225.02,173.98 225.33,173.68 225.33,171.2 225.31,171.18 225.31,169.86 225.53,169.64 225.94,169.64 227.86,167.73 v2(228.02,167.73)
  BOTTOM w0.129: v2(224.89,176.87) 225.21,177.2 VRAM1.J5 ; v2(228.02,167.73) 228.02,167.64 227.64,167.26 227.64,166.16 227.71,166.09 227.71,165.48 UG6.B43
FBB_CMD11: length 15.1
  BOTTOM w0.129: UG6.A43 227.41,165.88 227.41,167.64 226.35,168.7 225.12,168.7 224.16,169.66 224.16,177.37 224.67,177.89 225.32,177.89 VRAM1.H5
FBB_CMD12: length 17.1
  IN4 w0.102: v2(226.97,167.36) 226.97,167.49 225.6,168.86 225.31,168.86 225.09,169.08 224.63,169.08 223.91,169.8 223.91,178.15 v2(224.55,178.79)
  BOTTOM w0.129: v2(226.97,167.36) 226.49,166.88 226.49,166.42 226.65,166.26 UG6.A44 ; VRAM1.G4 226.12,178.7 225.74,179.08 225,179.08 224.71,178.79 v2(224.55,178.79)
FBB_CMD13: length 18.3
  IN4 w0.102: v2(221.27,178.31) 221.49,178.1 222.56,178.1 223.23,177.44 223.23,169.5 224.36,168.37 224.73,168.37 225.38,167.72 225.38,167.06 225.84,166.6 v2(225.97,166.6)
  BOTTOM w0.102: VRAM1.G11 220.89,178.7 v2(221.27,178.31)
  BOTTOM w0.129: v2(225.97,166.6) 226.29,166.28 226.29,164.08 UG6.D44
FBB_CMD14: length 16.5
  TOP w0.102: RG3.2 221.82,178.87 v2(222.2,178.5)
  BOTTOM w0.102: VRAM1.G10 221.82,178.5 v2(222.2,178.5)
  BOTTOM w0.129: v2(222.2,178.5) 222.66,178.5 223.88,177.28 223.88,169.43 225.33,167.98 225.33,166.64 225.95,166.01 UG6.A45
FBB_CMD15: length 15.3
  BOTTOM w0.129: VRAM1.H10 221.78,178.1 222.53,178.1 223.6,177.03 223.6,169.21 225.02,167.79 225.02,166.54 225.57,165.99 225.57,165.6 225.25,165.28 UG6.B46
FBB_CMD16: length 11.8
  BOTTOM w0.129: VRAM1.L10 221.81,175.51 222.57,175.51 223.24,174.83 223.24,168.97 224.64,167.57 224.64,166.45 225.25,165.84 UG6.A46
FBB_CMD17: length 13.7
  TOP w0.165: v2(222.47,175.01) 222.52,174.96 RG17.2
  BOTTOM w0.129: 222.81,174.67 v2(222.47,175.01) 221.69,175.01 VRAM1.M10 ; UG6.A47 224.55,166.06 224.36,166.25 224.36,167.12
  BOTTOM w0.165: 222.81,174.67 222.81,169.85 222.65,169.68 221.68,169.68 221.52,169.52 221.52,169.2 221.69,169.02 222.65,169.02 222.81,168.86 222.81,168.67 224.36,167.12
FBB_CMD18: length 13.8
  IN4 w0.102: v2(223.85,166.43) 223.21,166.43 223.02,166.62 222.6,166.62 220.89,168.33 220.89,171.52 221.01,171.64 221.01,173.43 220.89,173.55 220.89,174.18 221.27,174.56 v2(221.27,174.57)
  BOTTOM w0.102: VRAM1.M11 220.9,174.95 v2(221.27,174.57)
  BOTTOM w0.129: v2(223.85,166.43) 223.85,166.33 224.19,165.98 224.19,164.28 224.55,163.93 UG6.D47
