# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEG12_TXN0_SSD: length 152.5
  IN1 w0.086: v2(174.03,144.1) 173.81,143.88 173.81,143.76 173.9,143.68 174.42,143.68 174.73,143.37 174.73,143.09 175.06,142.76 176.95,142.76 177.13,142.67 177.4,142.43 178.64,140.6 179.11,139.46 179.73,136.34 179.64,135.78 179.81,134.93 179.63,133.65 179.87,132.26 179.61,130.8 179.87,129.33 179.68,128.32 179.92,126.98 179.92,126.94 180.42,125.72 181.85,123.59 182.48,122.96 183.33,121.67 183.44,121.43 183.56,120.24 183.49,119.84 183.8,118.11 183.63,117.17 183.76,115.72 183.76,115.3 183.94,114.86 184.45,113.62 185.32,112.75 185.46,112.65 186.19,111.62 187.03,111.03 187.76,109.99 189,109.12 189.47,108.44 189.71,108.11 189.72,108.09 190.39,107.62 190.99,106.18 190.99,91.45 190.8,91 190.52,90.72 190.38,90.37 190.38,89.52 190.53,89.15 190.84,88.84 190.99,88.48 190.99,84.96 190.8,84.51 187.65,81.36 186.72,80.74 186.19,80.52 160.74,80.52 160.47,80.4 150.81,80.4 148.76,81.26 139.51,81.26 139.1,81.08 138.69,80.68 138.25,80.5 136.99,80.5 135.3,81.2 118.87,81.2 117.94,81.38 117.63,81.51 117.07,81.89 116.25,82.71 116.25,83.06 v1(115.96,83.35)
  BOTTOM w0.079: U42.D25 174.03,144.03 v2(174.03,144.1)
  BOTTOM w0.14: C726.2 113.56,87.76 114.01,87.76 114.8,86.97 114.8,86.12 116.29,84.63 116.29,83.67 v1(115.96,83.35)
PEG12_TXN0_SSD_R: length 3.7
  BOTTOM w0.14: CN6.47 110.61,86.73 110.73,86.85 111.21,86.85 112.06,87.7 112.57,87.7 C726.1
PEG12_TXN1_SSD: length 154.9
  IN1 w0.086: v2(176,144.11) 176.08,144.18 176.22,144.18 176.3,144.1 176.3,143.74 176.54,143.5 177.18,143.5 178.04,142.65 179.31,140.83 179.78,139.68 180.41,136.11 180.31,135.55 180.44,135.08 180.24,133.69 180.53,132.05 180.3,130.76 180.52,129.55 180.31,128.32 180.54,126.99 180.95,126 182.25,124.05 182.89,123.41 183.89,122.19 184.23,121.36 184.32,120.58 184.14,119.58 184.4,118.12 184.28,117.45 184.28,116.96 184.39,115.89 184.49,115.41 184.57,114.99 184.94,114.09 185.75,113.28 185.95,113.14 186.67,112.11 187.47,111.55 188.2,110.51 189.48,109.61 190.19,108.59 190.21,108.57 190.96,108.05 191.58,106.41 191.58,91.14 191.4,90.7 191.1,90.4 191,90.17 191,89.74 191.12,89.45 191.4,89.17 191.58,88.72 191.58,84.84 191.31,84.17 188,80.86 187.02,80.21 186.33,79.92 169.15,79.92 168.82,79.6 163.31,79.6 162.79,79.81 150.69,79.81 148.64,80.66 139.97,80.66 139.6,80.51 139.2,80.11 138.71,79.9 136.71,79.9 135.01,80.6 118.43,80.6 117.86,80.66 117.04,80.82 116.26,81.46 115.7,82.03 115.06,82.46 114,82.89 113.72,83.08 113.4,83.4 113.32,83.59 113.32,83.59 113.24,83.79 113.24,84.13 113.34,84.36 113.53,84.56 113.8,84.67 114.68,84.67 114.85,84.5 114.85,83.82 114.77,83.73 114.49,83.73 114.4,83.82 v1(114.4,84.06)
  BOTTOM w0.079: v2(176,144.11) 175.66,143.76 U42.B25
  BOTTOM w0.14: v1(114.4,84.06) 114.63,84.06 114.77,84.2 114.77,84.48 114.55,84.71 113.39,84.71 113.26,84.58 C730.2
PEG12_TXN1_SSD_R: length 3.7
  BOTTOM w0.14: C730.1 112.56,84.67 112.11,84.67 111.29,83.85 110.73,83.85 110.61,83.73 CN6.35
PEG12_TXN2_SSD: length 163.8
  IN1 w0.086: v2(174.03,145.07) 173.88,145.07 173.72,145.22 173.72,145.43 174.32,146.04 177.99,146.04 181.82,142.2 182.44,141.03 183.07,137.4 182.76,135.6 182.92,134.64 182.72,133.5 182.72,133.48 182.98,132.01 182.71,130.48 182.95,129.11 182.81,128.31 183.01,127.27 183.67,126.05 186.15,123.56 186.63,122.41 186.63,121.58 186.79,120.68 186.58,119.49 186.73,118.63 186.77,117.7 186.84,116.32 186.95,116.04 187.24,115.35 187.26,115.34 187.95,114.43 187.95,114.41 188.28,113.97 189.03,113.44 189.97,112.11 191.15,111.28 191.86,110.26 191.88,110.24 192.48,109.81 193.13,109.17 193.86,107.39 193.86,84 193.5,83.12 191.75,81.38 191.46,80.66 189.42,78.63 188.05,77.25 187.46,77.01 185.23,77.01 184.65,76.77 183.1,76.77 182.11,77.18 164.53,77.18 163.84,76.89 161,76.89 159.55,77.18 155.83,77.18 155.8,77.17 155.44,77.12 145.52,77.12 144.3,77.62 137.99,77.62 136.1,77.25 134.67,76.66 133.44,76.87 132.19,76.65 131.58,76.76 130.19,76.76 129.58,76.65 128.33,76.87 127.08,76.65 125.83,76.87 124.58,76.65 123.33,76.87 122.61,76.75 122.06,76.84 121.57,77.18 120.55,77.36 119.88,77.36 119.32,77.36 119.13,77.17 119.13,76.61 119.04,76.52 118.79,76.52 118.7,76.6 v1(118.7,76.68)
  BOTTOM w0.079: U42.E27 174.03,144.92 v2(174.03,145.07)
  BOTTOM w0.14: v1(118.7,76.68) 118.94,76.68 119.12,76.87 119.12,77.22 118.75,77.6 117.6,77.6 116.72,78.47 116.72,80.78 115.89,81.62 113.4,81.62 113.26,81.48 C733.2
PEG12_TXN2_SSD_R: length 3.7
  BOTTOM w0.14: C733.1 112.56,81.62 112.02,81.62 111.25,80.85 110.73,80.85 110.61,80.73 CN6.23
PEG12_TXN3_SSD: length 157.7
  IN1 w0.086: v1(115.96,79.3) 115.69,79.57 115.69,79.72 115.73,79.83 115.79,79.88 115.93,79.94 116.09,79.94 116.22,79.88 116.46,79.64 116.57,79.38 116.57,78.87 116.69,78.59 117.18,78.1 117.47,77.98 120.47,77.98 121.08,78.09 122.33,77.87 123.58,78.09 124.55,77.92 125,78 125.39,78.38 125.95,78.62 127.59,78.62 128.16,78.38 128.45,78.09 129.26,77.67 129.73,77.59 130.67,77.75 131.92,77.53 133.17,77.75 134.86,77.46 135.93,77.9 137.52,78.22 139.76,78.22 140.28,78.43 140.65,78.81 140.95,78.93 148.07,78.93 148.9,78.59 149.47,78.2 150.51,77.77 152.36,77.77 153.8,78.03 155.27,77.77 156.66,78.01 157.76,77.82 157.94,77.79 159,77.98 160.12,77.78 161.09,77.95 163.64,77.5 164.3,77.77 177.03,77.77 178.28,77.99 179.45,77.79 180.46,77.96 181.36,77.8 181.86,78.01 182.62,78.01 183.56,77.61 183.99,77.61 187.32,77.6 187.72,77.84 187.99,78.05 189.2,79.57 189.21,79.58 189.39,79.87 192.89,83.36 193.27,84.28 193.27,106.88 192.34,109.11 192.15,109.3 191.44,109.8 191.42,109.82 190.71,110.84 189.52,111.68 189.47,111.74 188.64,112.92 187.79,113.52 187.51,113.89 187.44,114.1 186.9,114.78 186.52,115.19 186.35,115.56 186.09,116.8 186.13,118.53 186.13,118.55 185.94,119.65 186.12,120.65 186.12,120.68 186.04,121.16 185.76,122.54 185.64,122.84 185.02,123.76 183.36,125.42 182.42,126.91 182.16,128.6 182.29,129.32 182.09,130.47 182.32,131.97 182.06,133.4 182.3,134.75 182.11,135.61 182.31,136.79 181.8,140.42 181.35,141.5 180.72,142.44 177.47,145.7 175.85,145.7 175.63,145.47 175.63,145.25 175.45,145.07 v2(175.34,145.07)
  BOTTOM w0.079: v2(175.34,145.07) 175.34,144.92 U42.C27
  BOTTOM w0.14: v1(115.96,79.3) 115.76,79.1 115.76,78.87 115.38,78.49 113.43,78.49 C740.2
PEG12_TXN3_SSD_R: length 3.7
  BOTTOM w0.14: C740.1 112.56,78.57 111.95,78.57 111.23,77.85 110.73,77.85 110.61,77.73 CN6.11
PEG12_TXP0_SSD: length 152.5
  IN1 w0.086: v1(116.81,83.35) 116.61,83.35 116.41,83.15 116.41,82.78 117.17,82.01 117.7,81.66 117.98,81.54 118.89,81.36 135.33,81.36 137.02,80.66 138.22,80.66 138.6,80.82 139,81.22 139.48,81.42 148.79,81.42 150.84,80.57 160.44,80.57 160.71,80.68 186.16,80.68 186.64,80.88 187.55,81.49 190.66,84.61 190.82,84.99 190.82,88.45 190.7,88.75 190.39,89.06 190.21,89.49 190.21,90.41 190.38,90.81 190.66,91.09 190.82,91.48 190.82,106.14 190.26,107.51 189.6,107.97 188.88,109.01 187.64,109.87 186.91,110.91 186.07,111.5 185.35,112.54 185.22,112.62 184.72,113.12 184.31,113.53 183.81,114.74 183.59,115.26 183.59,115.72 183.47,117.18 183.63,118.11 183.32,119.84 183.4,120.25 183.27,121.38 183.19,121.59 182.35,122.85 181.72,123.48 180.28,125.64 179.75,126.91 179.75,126.97 179.51,128.32 179.7,129.33 179.44,130.8 179.7,132.26 179.46,133.65 179.64,134.92 179.47,135.78 179.57,136.34 178.96,139.41 178.5,140.52 177.27,142.32 177.03,142.53 176.91,142.59 174.99,142.59 174.56,143.02 174.56,143.3 174.36,143.51 173.83,143.51 173.65,143.69 173.65,143.84 v2(173.38,144.1)
  BOTTOM w0.079: v2(173.38,144.1) 173.38,144.02 U42.E25
  BOTTOM w0.14: C725.2 113.46,88.03 114.12,88.03 115.06,87.08 115.06,86.23 116.55,84.74 116.55,83.61 v1(116.81,83.35)
PEG12_TXP0_SSD_R: length 3.7
  BOTTOM w0.14: CN6.49 110.61,87.23 110.73,87.11 111.09,87.11 111.95,87.97 112.55,87.97 C725.1
PEG12_TXP1_SSD: length 154.9
  IN1 w0.086: v2(176.68,144.11) 176.47,143.89 176.47,143.81 176.61,143.67 177.24,143.67 178.16,142.75 179.45,140.91 179.94,139.73 180.58,136.11 180.48,135.56 180.6,135.09 180.41,133.69 180.7,132.05 180.47,130.76 180.69,129.55 180.47,128.32 180.7,127.04 181.1,126.08 182.38,124.16 183.01,123.52 184.04,122.27 184.39,121.43 184.4,121.41 184.49,120.57 184.31,119.58 184.57,118.12 184.45,117.43 184.45,116.97 184.55,115.92 184.63,115.55 184.73,115.04 185.08,114.18 185.86,113.4 186.07,113.26 186.17,113.12 186.79,112.23 187.59,111.67 188.32,110.63 189.47,109.82 189.6,109.73 190.31,108.71 190.33,108.69 191.09,108.15 191.75,106.44 191.75,91.11 191.54,90.61 191.24,90.31 191.17,90.13 191.17,89.77 191.26,89.54 191.54,89.27 191.75,88.76 191.75,84.81 191.45,84.08 188.1,80.73 187.1,80.06 186.36,79.76 169.22,79.76 168.89,79.43 163.27,79.43 162.76,79.65 150.66,79.65 148.61,80.49 140,80.49 139.7,80.37 139.29,79.97 138.74,79.74 136.67,79.74 134.98,80.44 118.43,80.44 117.83,80.5 116.97,80.67 116.15,81.34 115.59,81.9 114.98,82.31 113.92,82.75 113.62,82.95 113.26,83.3 113.08,83.76 113.08,84.17 113.2,84.46 113.43,84.7 113.77,84.83 114.75,84.83 115.02,84.57 115.02,84.29 v1(115.25,84.06)
  BOTTOM w0.079: v2(176.68,144.11) 176.68,144.08 U42.A25
  BOTTOM w0.14: C727.2 113.46,84.98 114.66,84.98 115.04,84.6 115.04,84.27 v1(115.25,84.06)
PEG12_TXP1_SSD_R: length 3.7
  BOTTOM w0.14: CN6.37 110.61,84.23 110.73,84.11 111.18,84.11 112,84.93 112.56,84.93 C727.1
PEG12_TXP2_SSD: length 163.8
  IN1 w0.086: v1(119.55,76.68) 119.39,76.69 119.29,76.78 119.29,77.1 119.39,77.2 119.7,77.2 120.54,77.2 121.5,77.03 121.99,76.68 122.61,76.58 123.33,76.7 124.58,76.48 125.83,76.7 127.08,76.48 128.33,76.7 129.58,76.48 130.21,76.59 131.56,76.59 132.19,76.48 133.44,76.7 134.69,76.48 136.15,77.09 138.01,77.46 144.26,77.46 145.49,76.95 155.46,76.95 155.83,77.01 155.84,77.01 159.54,77.01 160.98,76.73 163.87,76.73 164.56,77.01 182.07,77.01 183.07,76.6 184.68,76.6 185.27,76.84 187.49,76.84 188.14,77.11 191.6,80.57 191.89,81.28 193.64,83.03 194.03,83.96 194.03,107.43 193.27,109.26 192.59,109.94 192,110.36 191.98,110.38 191.27,111.4 190.08,112.23 189.47,113.1 189.46,113.12 189.15,113.55 188.4,114.09 188.12,114.46 188.12,114.47 187.37,115.46 187.37,115.46 187,116.36 186.93,117.85 186.9,118.65 186.75,119.49 186.96,120.68 186.8,121.59 186.8,122.44 186.29,123.65 183.8,126.15 183.17,127.33 182.98,128.31 183.12,129.12 182.88,130.48 183.15,132.01 182.89,133.48 183.09,134.64 182.92,135.6 183.24,137.4 182.59,141.08 181.96,142.3 178.06,146.2 174.25,146.2 173.55,145.5 173.55,145.24 v2(173.38,145.07)
  BOTTOM w0.079: U42.F27 173.38,144.92 v2(173.38,145.07)
  BOTTOM w0.14: C732.2 113.51,81.88 116,81.88 116.99,80.89 116.99,78.58 117.71,77.87 118.86,77.87 119.39,77.33 119.39,76.84 v1(119.55,76.68)
PEG12_TXP2_SSD_R: length 3.7
  BOTTOM w0.14: C732.1 112.56,81.88 111.91,81.88 111.14,81.11 110.73,81.11 110.61,81.23 CN6.25
PEG12_TXP3_SSD: length 157.8
  IN1 w0.086: v1(115.04,79.32) 115.04,79.2 115.12,79.12 115.43,79.12 115.52,79.21 115.52,79.75 115.59,79.92 115.69,80.02 115.89,80.1 116.12,80.1 116.32,80.02 116.6,79.74 116.74,79.42 116.74,78.91 116.83,78.68 117.27,78.24 117.51,78.14 120.45,78.14 121.08,78.25 122.33,78.03 123.58,78.25 124.55,78.09 124.92,78.15 125.3,78.52 125.92,78.78 127.62,78.78 128.26,78.52 128.55,78.22 129.31,77.83 129.73,77.76 130.67,77.92 130.7,77.92 131.92,77.7 133.17,77.92 134.84,77.63 135.88,78.06 137.51,78.38 139.73,78.38 140.18,78.57 140.56,78.95 140.74,79.02 140.74,79.02 140.92,79.1 148.1,79.1 148.97,78.74 149.55,78.35 150.55,77.94 152.34,77.94 153.8,78.19 155.27,77.94 156.66,78.18 157.76,77.99 157.94,77.96 159,78.14 160.12,77.95 161.09,78.12 163.62,77.67 164.27,77.94 177.02,77.94 178.28,78.16 179.45,77.95 180.46,78.13 181.35,77.98 181.83,78.17 182.66,78.17 183.59,77.78 183.99,77.78 187.27,77.77 187.63,77.98 187.87,78.16 188.24,78.63 189.07,79.67 189.26,79.97 192.75,83.45 193.1,84.31 193.1,106.84 192.2,109.02 192.05,109.17 191.32,109.68 191.3,109.71 190.59,110.72 189.4,111.56 188.52,112.81 188.08,113.12 187.67,113.4 187.37,113.81 187.29,114.02 186.77,114.67 186.38,115.1 186.19,115.51 185.93,116.78 185.97,118.54 185.77,119.65 185.95,120.68 185.87,121.13 185.6,122.49 185.49,122.76 184.89,123.66 183.23,125.32 182.26,126.85 182,128.6 182.12,129.32 181.92,130.46 182.16,131.97 181.89,133.4 182.13,134.75 181.94,135.61 182.15,136.79 181.64,140.37 181.2,141.43 180.59,142.34 177.4,145.53 175.92,145.53 175.8,145.41 175.8,145.26 v2(175.99,145.07)
  BOTTOM w0.079: U42.B27 175.99,144.92 v2(175.99,145.07)
  BOTTOM w0.14: v1(115.04,79.32) 115.36,79.32 115.5,79.18 115.5,78.98 115.27,78.76 113.4,78.76 113.26,78.9 C738.2
PEG12_TXP3_SSD_R: length 3.7
  BOTTOM w0.14: C738.1 112.56,78.84 111.84,78.84 111.12,78.11 110.73,78.11 110.61,78.23 CN6.13
PEG_RXN0: length 84.1
  TOP w0.079: 178.54,135.37 178.52,135.37 178.47,135.33 178.33,135.33 177.52,136.14 176.38,136.14 175.08,137.43 171.51,137.43 171.46,137.38 169.21,137.38 169.13,137.46 169.13,137.64 169.24,137.75 v2(169.42,137.75)
  TOP w0.14: 178.54,135.37 180.63,135.37 190.44,125.56 190.44,115.66 196.2,109.89 204.84,109.89 208.24,113.3 225.27,113.3 229.25,117.28 229.25,119.03 CG389.2
  BOTTOM w0.102: U42.M15 169.08,137.27 169.19,137.16 169.34,137.16 169.43,137.25 169.43,137.75 v2(169.42,137.75)
PEG_RXN0_C: length 16.7
  TOP w0.102: v2(236.1,129.77) 236.05,129.82 236.05,129.99 236.15,130.09 236.35,130.09 236.43,130.03 237.45,129.01 237.45,127.28 237.43,127.26 237.43,127.22 237.38,127.18 237.38,127.17
  TOP w0.14: CG389.1 229.25,119.98 229.25,120.5 229.82,121.07 231.51,121.07 233.44,123 233.9,123 237.38,126.48 237.38,127.17
  BOTTOM w0.102: UG6.BM31 235.86,130.12 236.1,129.88 v2(236.1,129.77)
PEG_RXN1: length 81.5
  TOP w0.079: v2(170.68,137.75) 170.83,137.75 170.98,137.9 170.98,138.07 171.23,138.33 172.41,138.33 172.69,138.04 175.06,138.04 176.54,136.57 177.9,136.57 178.21,136.26 178.47,136.26 178.52,136.31 178.54,136.31
  TOP w0.14: 178.54,136.31 180.98,136.31 191.35,125.94 191.35,116.04 196.58,110.81 204.45,110.81 207.86,114.21 224.89,114.21 227.98,117.3 227.98,120.4 CG376.2
  BOTTOM w0.102: v2(170.68,137.75) 170.68,137.65 U42.K15
PEG_RXN1_C: length 18
  TOP w0.102: v2(234.71,131.86) 234.71,132.08 234.81,132.18 235.06,132.18 235.2,132.03 235.23,131.98 235.49,130.65 235.51,130.39 235.52,130.38 235.52,129.49 235.58,128.84 236.15,127.75 236.15,127.22 236.12,127.19 236.12,127.17
  TOP w0.14: 236.12,127.17 236.12,126.56 233.49,123.93 233.07,123.93 231.3,122.16 228.29,122.16 227.99,121.87 227.99,121.36 CG376.1
  BOTTOM w0.102: v2(234.71,131.86) 234.93,131.86 235.05,131.74 UG6.BK32
PEG_RXN2: length 80.3
  TOP w0.079: 178.54,137.24 178.52,137.24 178.47,137.18 177.9,137.18 177.51,137.57 176.32,137.57 175.51,138.38 175.25,138.64 170.84,138.64 170.58,138.39 169.33,138.39 169.11,138.61 169.11,138.89 169.23,139.01 v2(169.41,139.01)
  TOP w0.14: 178.54,137.24 181.35,137.24 192.27,126.32 192.27,116.42 196.96,111.72 204.04,111.72 207.44,115.13 223.55,115.13 226.79,118.37 226.79,119.14 226.65,119.28 CG387.2
  BOTTOM w0.102: U42.L17 169.73,138.55 169.63,138.45 169.48,138.45 169.39,138.53 169.39,138.99 v2(169.41,139.01)
PEG_RXN2_C: length 17.5
  TOP w0.102: v2(234.71,129.77) 234.71,129.98 234.81,130.08 234.95,130.08 235.02,130.01 235.09,129.84 235.09,128.9 234.81,128.63 234.81,128.21 234.9,128 235.02,127.82 235.21,127.54 235.21,127.22 235.18,127.19 235.18,127.17
  TOP w0.14: 235.18,127.17 235.18,126.91 233.11,124.84 232.69,124.84 230.93,123.08 227.67,123.08 226.72,122.13 226.72,119.99 CG387.1
  BOTTOM w0.102: v2(234.71,129.77) 234.71,129.96 234.54,130.12 UG6.BM33
PEG_RXN3: length 77.5
  TOP w0.079: v2(170.71,139.05) 170.92,139.05 171.02,139.16 171.02,139.37 171.19,139.54 172.8,139.54 173.01,139.33 175.33,139.33 176.46,138.2 178.47,138.2 178.52,138.25 178.54,138.25
  TOP w0.14: 178.54,138.25 181.63,138.25 193.21,126.67 193.21,116.91 197.48,112.64 203.6,112.64 207.34,116.38 217.98,116.38 218.31,116.06 222.9,116.06 225.43,118.58 225.43,120.42 CG374.2
  BOTTOM w0.102: U42.J17 171.04,138.73 v2(170.71,139.05)
PEG_RXN3_C: length 18.7
  TOP w0.102: 234.14,127.17 234.19,127.22 234.2,127.21 234.22,127.21 234.23,127.22 234.23,127.79 234.39,127.96 234.39,128.34 234.37,128.48 234.3,128.64 234.21,128.73 234.12,128.95 234.12,130.12 234.07,130.5 233.86,131.72 233.71,132 233.56,132.16 233.51,132.16 233.41,132.16 233.31,132.06 v2(233.31,131.86)
  TOP w0.14: 234.14,127.17 232.73,125.76 232.31,125.76 230.55,123.99 226.59,123.99 225.44,122.85 225.44,121.35 CG374.1
  BOTTOM w0.102: v2(233.31,131.86) 233.51,131.86 233.65,131.72 UG6.BK34
PEG_RXN4: length 77.6
  TOP w0.079: v2(168.76,140.22) 168.58,140.22 168.46,140.11 168.46,139.81 168.61,139.66 169.83,139.66 170.02,139.85 172.25,139.85 172.34,139.95 173.35,139.95 173.45,139.86 175.48,139.86 175.83,139.52 177.77,139.52 178.17,139.11 178.47,139.11 178.52,139.17 178.54,139.17
  TOP w0.14: CG385.2 223.94,119.3 224.17,119.3 224.33,119.15 224.33,118.77 222.52,116.97 218.72,116.97 218.37,117.32 206.96,117.32 203.19,113.55 197.86,113.55 194.12,117.29 194.12,127.05 182.01,139.17 178.54,139.17
  BOTTOM w0.102: v2(168.76,140.22) 168.77,140.22 168.87,140.12 168.87,139.98 168.77,139.88 168.77,139.73 168.86,139.64 U42.M18
PEG_RXN4_C: length 18.2
  TOP w0.102: v2(233.3,129.77) 233.26,129.82 233.26,129.96 233.4,130.11 233.58,130.11 233.68,130.01 233.68,128.92 233.42,128.65 233.42,127.73 232.85,127.17
  TOP w0.14: CG385.1 224.18,119.99 224.18,122.88 226.45,125.15 230.41,125.15 231.93,126.67 232.35,126.67 232.85,127.17
  BOTTOM w0.102: v2(233.3,129.77) 233.3,129.88 233.06,130.12 UG6.BM35
PEG_RXN5: length 74.8
  TOP w0.079: 178.54,140.2 178.52,140.2 178.47,140.14 176.23,140.14 175.84,140.54 173.62,140.54 173.4,140.75 170.56,140.75 170.34,140.53 170.34,140.3 170.26,140.22 v2(170.06,140.22)
  TOP w0.14: CG372.2 222.94,120.37 222.94,118.8 222.02,117.89 219.16,117.89 218.75,118.3 206.6,118.3 202.76,114.47 198.24,114.47 195.04,117.67 195.04,127.43 182.27,140.2 178.54,140.2
  BOTTOM w0.102: v2(170.06,140.22) 170.18,140.22 170.38,140.02 U42.K18
PEG_RXN5_C: length 19.5
  TOP w0.102: v2(231.91,131.86) 231.91,132.09 232.01,132.2 232.15,132.2 232.41,131.94 232.46,131.82 232.51,131.6 232.71,130.44 232.71,128.96 232.79,128.77 232.93,128.56 232.98,128.45 232.98,128.34 232.96,128.27 232.92,128.16 232.15,127.39 231.39,127.39 231.22,127.39 230.99,127.17
  TOP w0.14: 230.99,127.17 229.89,126.06 226.07,126.06 222.9,122.89 222.9,121.35 CG372.1
  BOTTOM w0.102: UG6.BK36 232.25,131.76 232.15,131.86 v2(231.91,131.86)
PEG_RXN6: length 64.7
  TOP w0.079: 178.41,141.13 178.39,141.13 178.34,141.08 177.74,141.08 177.29,140.63 176.61,140.63 176.1,141.14 172.39,141.14 172.33,141.07 169.94,141.07 169.81,140.94 169.26,140.94 169.12,141.08 169.12,141.34 169.21,141.44 v2(169.41,141.44)
  TOP w0.14: CG383.2 221.51,119.28 221.65,119.14 221.65,118.93 221.51,118.8 219.59,118.8 218.97,119.42 210.06,119.42 207.22,122.26 205.46,122.26 202.76,124.96 198.8,124.96 182.63,141.13 178.41,141.13
  BOTTOM w0.102: U42.L20 169.73,140.77 169.64,140.68 169.5,140.68 169.39,140.79 169.39,141.42 v2(169.41,141.44)
PEG_RXN6_C: length 19.7
  TOP w0.102: 229.89,127.35 229.91,127.37 229.95,127.37 230.57,127.99 231.53,127.99 231.87,128.45 231.87,128.48 232.21,128.83 232.29,128.93 232.29,129.97 232.15,130.11 232,130.11 231.9,130 v2(231.9,129.77)
  TOP w0.14: CG383.1 221.63,119.97 221.63,124.4 224.2,126.98 229.51,126.98 229.89,127.35
  BOTTOM w0.102: UG6.BM37 231.66,130.12 231.89,129.88 231.89,129.78 v2(231.9,129.77)
PEG_RXN7: length 60.3
  TOP w0.079: v2(171.34,141.45) 171.53,141.45 171.65,141.57 171.65,141.81 171.83,142 172.34,142 172.64,141.7 176.78,141.7 176.84,141.75 176.86,141.75
  TOP w0.14: 176.86,141.75 177.23,141.75 177.71,142.23 182.83,142.23 199.16,125.9 203.42,125.9 206.08,123.24 207.61,123.24 210.33,120.52 219.17,120.52 219.63,120.07 220.22,120.07 220.36,120.21 220.36,120.4 CG370.2
  BOTTOM w0.102: U42.J20 171.17,140.86 171.34,141.03 v2(171.34,141.45)
PEG_RXN7_C: length 20.9
  TOP w0.102: v2(230.51,131.86) 230.51,132.1 230.63,132.22 230.8,132.22 231.31,131.71 231.31,129.54 231.2,129.21 230.66,128.66 230.34,128.66 230.03,128.97 229.53,128.97 228.93,128.37 228.93,128.36 228.2,127.63 223.62,127.63 223.39,127.39 223.36,127.39 223.33,127.36 223.27,127.36 223.26,127.35
  TOP w0.14: 223.26,127.35 220.44,124.53 220.36,124.45 220.36,121.35 CG370.1
  BOTTOM w0.102: UG6.BK38 230.85,131.65 230.64,131.86 v2(230.51,131.86)
PEG_RXP0: length 84.2
  TOP w0.079: 178.54,135.11 178.53,135.11 178.47,135.17 178.26,135.17 177.45,135.98 176.31,135.98 175.02,137.27 171.57,137.27 171.52,137.22 169.15,137.22 168.97,137.39 168.97,137.56 v2(168.78,137.75)
  TOP w0.14: CG390.2 229.52,119.03 229.52,117.17 225.38,113.03 208.35,113.03 204.95,109.63 196.09,109.63 190.17,115.55 190.17,125.45 180.52,135.11 178.54,135.11
  BOTTOM w0.102: v2(168.78,137.75) 168.43,137.41 U42.N15
PEG_RXP0_C: length 16.7
  TOP w0.102: v2(236.09,130.48) 236.28,130.29 236.42,130.29 236.51,130.23 236.56,130.19 237.65,129.1 237.65,127.17
  TOP w0.14: 237.65,127.17 237.65,126.37 234.01,122.73 233.55,122.73 231.62,120.8 229.93,120.8 229.52,120.39 229.52,119.98 CG390.1
  BOTTOM w0.102: UG6.BL31 v2(236.09,130.48)
PEG_RXP1: length 81.6
  TOP w0.079: 178.54,136.05 178.52,136.05 178.47,136.1 178.14,136.1 177.83,136.41 176.47,136.41 175,137.88 175,137.88 172.63,137.88 172.34,138.17 171.3,138.17 171.13,138.01 171.13,137.87 171.26,137.75 v2(171.32,137.75)
  TOP w0.14: CG377.2 228.25,120.4 228.25,117.19 225,113.95 207.97,113.95 204.57,110.54 196.47,110.54 191.09,115.93 191.09,125.83 180.87,136.05 178.54,136.05
  BOTTOM w0.102: v2(171.32,137.75) 171.04,137.46 U42.J15
PEG_RXP1_C: length 18
  TOP w0.102: 236.39,127.17 236.39,127.19 236.36,127.22 236.36,127.81 236.34,127.83 236.34,127.84 235.78,128.9 235.72,129.5 235.72,130.41 235.72,130.42 235.69,130.68 235.42,132.04 235.38,132.15 235.14,132.38 234.89,132.38 v2(234.71,132.56)
  TOP w0.14: 236.39,127.17 236.39,126.45 233.6,123.66 233.18,123.66 231.41,121.9 228.4,121.9 228.26,121.76 228.26,121.34 CG377.1
  BOTTOM w0.102: UG6.BJ32 v2(234.71,132.56)
PEG_RXP2: length 80.4
  TOP w0.079: v2(168.76,139.01) 168.95,138.82 168.95,138.55 169.27,138.23 170.65,138.23 170.9,138.48 175.19,138.48 175.4,138.27 176.26,137.41 177.45,137.41 177.83,137.03 178.47,137.03 178.52,136.97 178.54,136.97
  TOP w0.14: CG388.2 227.05,119.11 227.05,118.26 223.66,114.86 207.55,114.86 204.15,111.46 196.85,111.46 192,116.31 192,126.21 181.24,136.97 178.54,136.97
  BOTTOM w0.102: v2(168.76,139.01) 168.76,138.9 U42.M17
PEG_RXP2_C: length 17.5
  TOP w0.102: v2(234.7,130.47) 234.89,130.28 235.04,130.28 235.19,130.13 235.29,129.88 235.29,128.82 235.01,128.54 235.01,128.25 235.08,128.09 235.19,127.93 235.42,127.61 235.42,127.22 235.45,127.19 235.45,127.17
  TOP w0.14: 235.45,127.17 235.45,126.8 233.22,124.58 232.8,124.58 231.04,122.81 227.78,122.81 226.99,122.02 226.99,119.97 CG388.1
  BOTTOM w0.102: UG6.BL33 v2(234.7,130.47)
PEG_RXP3: length 77.5
  TOP w0.079: 178.54,137.99 178.52,137.99 178.47,138.04 176.39,138.04 175.78,138.66 175.27,139.17 172.94,139.17 172.73,139.38 171.26,139.38 171.18,139.3 171.18,139.19 v2(171.36,139.01)
  TOP w0.14: 178.54,137.99 181.52,137.99 192.94,126.56 192.94,116.8 197.37,112.37 203.71,112.37 207.45,116.12 217.87,116.12 218.2,115.79 223.01,115.79 225.69,118.47 225.69,120.39 CG375.2
  BOTTOM w0.102: U42.H17 171.69,138.69 v2(171.36,139.01)
PEG_RXP3_C: length 18.8
  TOP w0.102: 234.46,127.17 234.46,127.19 234.43,127.22 234.43,127.71 234.6,127.88 234.6,128.36 234.56,128.54 234.47,128.76 234.38,128.85 234.33,128.99 234.33,130.13 234.28,130.53 234.06,131.78 233.88,132.12 233.64,132.36 233.56,132.36 233.51,132.36 v2(233.3,132.57)
  TOP w0.14: 234.46,127.17 234.46,127.11 232.84,125.49 232.42,125.49 230.66,123.72 226.7,123.72 225.71,122.73 225.71,121.35 CG375.1
  BOTTOM w0.102: UG6.BJ34 v2(233.3,132.57)
PEG_RXP4: length 77.7
  TOP w0.079: v2(168.11,140.22) 168.3,140.03 168.3,139.75 168.55,139.5 169.89,139.5 170.09,139.7 172.31,139.7 172.41,139.8 173.29,139.8 173.38,139.7 175.42,139.7 175.76,139.36 177.7,139.36 178.1,138.96 178.47,138.96 178.52,138.9 178.54,138.9
  TOP w0.14: CG386.2 224.59,119.19 224.59,118.66 222.64,116.7 218.61,116.7 218.26,117.06 207.07,117.06 203.3,113.29 197.75,113.29 193.86,117.18 193.86,126.94 181.9,138.9 178.54,138.9
  BOTTOM w0.102: v2(168.11,140.22) 168.11,139.97 U42.N18
PEG_RXP4_C: length 18.2
  TOP w0.102: 233.64,127.58 233.64,128.1 233.62,128.12 233.62,128.57 233.88,128.83 233.88,130.09 233.66,130.31 233.46,130.31 v2(233.3,130.47)
  TOP w0.14: CG386.1 224.45,119.97 224.45,122.77 226.56,124.88 230.52,124.88 232.04,126.4 232.46,126.4 233.64,127.58
  BOTTOM w0.102: UG6.BL35 v2(233.3,130.47)
PEG_RXP5: length 74.8
  TOP w0.079: 178.54,139.93 178.52,139.93 178.47,139.98 176.17,139.98 175.77,140.38 173.55,140.38 173.34,140.59 170.63,140.59 170.49,140.46 170.49,140.34 170.61,140.22 v2(170.71,140.22)
  TOP w0.14: 178.54,139.93 182.16,139.93 194.77,127.32 194.77,117.56 198.13,114.2 202.87,114.2 206.71,118.03 218.63,118.03 219.05,117.62 222.13,117.62 223.21,118.69 223.21,120.44 CG373.2
  BOTTOM w0.102: v2(170.71,140.22) 171.04,139.9 U42.J18
PEG_RXP5_C: length 19.4
  TOP w0.102: 231.37,127.17 231.4,127.17 231.42,127.19 232.23,127.19 233.09,128.04 233.16,128.21 233.18,128.32 233.18,128.49 233.11,128.65 232.97,128.86 232.92,129 232.92,130.45 232.92,130.46 232.71,131.64 232.65,131.88 232.58,132.06 232.24,132.4 232.07,132.4 v2(231.9,132.57)
  TOP w0.14: CG373.1 223.17,121.35 223.17,122.78 226.18,125.79 230,125.79 230.73,126.52 231.37,127.17
  BOTTOM w0.102: UG6.BJ36 v2(231.9,132.57)
PEG_RXP6: length 64.7
  TOP w0.079: 178.41,140.87 178.39,140.87 178.34,140.92 177.8,140.92 177.35,140.47 176.55,140.47 176.04,140.98 172.46,140.98 172.39,140.91 170,140.91 169.87,140.78 169.19,140.78 168.96,141.01 168.96,141.24 v2(168.76,141.44)
  TOP w0.14: 178.41,140.87 182.52,140.87 198.69,124.7 202.65,124.7 205.35,122 207.11,122 209.95,119.15 218.86,119.15 219.47,118.53 221.63,118.53 221.92,118.82 221.92,119.05 CG384.2
  BOTTOM w0.102: v2(168.76,141.44) 168.76,141.19 U42.M20
PEG_RXP6_C: length 19.7
  TOP w0.102: 230.08,127.17 230.1,127.18 230.1,127.23 230.65,127.79 231.63,127.79 232.03,128.33 232.07,128.37 232.07,128.4 232.37,128.7 232.49,128.86 232.49,130.05 232.23,130.31 232.06,130.31 v2(231.9,130.47)
  TOP w0.14: CG384.1 221.89,119.98 221.89,124.29 224.31,126.71 229.62,126.71 229.89,126.98 230.08,127.17
  BOTTOM w0.102: UG6.BL37 v2(231.9,130.47)
PEG_RXP7: length 60.3
  TOP w0.079: v2(172,141.44) 171.81,141.63 171.81,141.75 171.9,141.84 172.27,141.84 172.57,141.54 176.78,141.54 176.84,141.48 176.86,141.48
  TOP w0.14: CG371.2 220.63,120.4 220.63,120.1 220.33,119.8 219.52,119.8 219.06,120.26 210.22,120.26 207.5,122.98 205.97,122.98 203.31,125.63 199.05,125.63 182.71,141.96 177.82,141.96 177.42,141.56 177.34,141.48 176.86,141.48
  BOTTOM w0.102: v2(172,141.44) 171.69,141.12 U42.H20
PEG_RXP7_C: length 20.9
  TOP w0.102: v2(230.49,132.58) 230.65,132.42 230.89,132.42 231.52,131.8 231.52,129.51 231.38,129.1 230.74,128.46 230.25,128.46 229.95,128.77 229.62,128.77 229.14,128.28 229.14,128.28 228.28,127.42 223.71,127.42 223.45,127.17
  TOP w0.14: 223.45,127.17 220.63,124.34 220.63,121.35 CG371.1
  BOTTOM w0.102: UG6.BJ38 v2(230.49,132.58)
PEG_TXN0: length 78.8
  BOTTOM w0.079: UG6.BT32 234.98,127.32 234.9,127.4 234.9,127.67 234.98,127.75 235.23,127.75 235.38,127.59 235.38,124.08 234.74,123.43 234.66,123.43 234.64,123.42
  BOTTOM w0.14: 234.64,123.42 231.42,120.19 228.85,120.19 225,116.34 212.88,116.34 206.85,110.31 196.31,110.31 190.38,116.24 190.38,121.9 186.48,125.81 186.48,129.54 184.42,131.6 182.31,131.6 182.01,131.89 182.01,132.12 182.14,132.26 182.33,132.26 C682.2
PEG_TXN0_C: length 11.7
  BOTTOM w0.079: U42.D16 174.17,137.91 174.09,137.83 174.09,137.7 174.17,137.63 176.41,137.63 arc(176.45,137.63) 176.49,137.64 arc(176.49,137.64) 176.5,137.64 176.55,137.67 arc(176.87,137.78) 177.21,137.83 177.71,137.83 177.93,137.6 178.39,137.6 180.35,135.64 180.35,135.39 180.41,135.34 180.41,135.32
  BOTTOM w0.14: 180.41,135.32 180.41,134.44 181.46,133.39 181.85,133.39 182.15,133.09 182.15,132.89 C682.1
PEG_TXN1: length 78
  BOTTOM w0.079: 233.74,123.81 233.75,123.82 233.83,123.82 234.54,124.54 234.54,127.82 234.62,127.9 234.62,128.33 234.54,128.4 234.43,128.4 234.35,128.32 UG6.BR33
  BOTTOM w0.14: C679.2 182.18,134.71 182.18,134.51 182.32,134.37 183.37,134.37 187.46,130.28 187.46,126.19 191.3,122.36 191.3,116.62 196.69,111.23 206.47,111.23 212.5,117.26 224.62,117.26 228.47,121.11 231.03,121.11 233.74,123.81
PEG_TXN1_C: length 7.9
  BOTTOM w0.079: 181.33,135.32 181.33,135.33 178.52,138.14 176.78,138.14 176.73,138.19 176.25,138.19 arc(176.21,138.18) 176.17,138.17 U42.B16
  BOTTOM w0.14: 181.33,135.32 181.33,134.94 181.6,134.68 181.69,134.68 C679.1
PEG_TXN2: length 75.1
  BOTTOM w0.079: UG6.BT34 233.59,127.38 233.59,127.63 233.67,127.71 233.9,127.71 234.03,127.58 234.03,125.32 233.18,124.47 233.1,124.47 233.09,124.46
  BOTTOM w0.14: 233.09,124.46 230.65,122.02 228.09,122.02 224.25,118.17 212.13,118.17 206.09,112.14 197.07,112.14 192.21,117 192.21,122.79 188.52,126.48 188.52,131.23 184.19,135.56 183.78,135.56 183.64,135.7 C677.2
PEG_TXN2_C: length 11.9
  BOTTOM w0.079: U42.E17 173.49,138.8 arc(173.37,138.75) 173.32,138.63 arc(173.35,138.55) 173.43,138.52 176.87,138.52 176.93,138.46 177.43,138.46 177.63,138.65 178.69,138.65 181.66,135.68 181.94,135.68 181.99,135.73
  BOTTOM w0.14: 181.99,135.73 182.98,135.73 C677.1
PEG_TXN3: length 75.8
  BOTTOM w0.079: UG6.BR35 232.95,128.32 233.03,128.39 233.14,128.39 233.22,128.32 233.22,125.81 232.01,124.6 231.93,124.6 231.92,124.59
  BOTTOM w0.14: 231.92,124.59 230.28,122.95 227.73,122.95 223.87,119.09 211.75,119.09 205.71,113.06 197.48,113.06 193.12,117.41 193.12,123.17 189.45,126.84 189.45,131.69 184.42,136.72 182.32,136.72 182.19,136.86 182.19,137.05 C675.2
PEG_TXN3_C: length 8.2
  BOTTOM w0.079: C675.1 181.49,136.81 181.27,136.81 178.93,139.14 177.65,139.14 177.44,139.35 177.06,139.35 arc(176.88,139.33) 176.72,139.28 arc(176.69,139.27) 176.66,139.26 arc(176.59,139.24) 176.52,139.24 175.36,139.24 arc(175.19,139.17) 175.12,138.99 arc(175.1,138.91) 175.05,138.85 U42.C17
PEG_TXN4: length 72.6
  BOTTOM w0.079: UG6.BT36 232.25,127.65 232.32,127.72 232.55,127.72 232.66,127.62 232.66,126.55 232.65,126.55 230.7,124.6 230.63,124.6 230.61,124.59
  BOTTOM w0.14: 230.61,124.59 229.92,123.89 227.37,123.89 223.49,120 211.37,120 205.44,114.07 197.76,114.07 194.04,117.79 194.04,123.68 193.4,124.32 190.46,127.25 190.46,132.15 184.7,137.92 183.69,137.92 183.58,138.03 183.58,138.22 C673.2
PEG_TXN4_C: length 10.6
  BOTTOM w0.079: U42.D18 174.1,139.84 174.02,139.76 174.02,139.64 174.1,139.56 176.41,139.56 176.62,139.65 arc(176.76,139.74) 176.93,139.77 179.19,139.77 179.34,139.63 179.41,139.63 179.43,139.61
  BOTTOM w0.14: C673.1 182.88,137.97 181.07,137.97 179.43,139.61
PEG_TXN5: length 73.2
  BOTTOM w0.079: 229.53,124.88 229.55,124.88 229.61,124.82 229.92,124.82 231.82,126.73 231.82,128.33 231.74,128.41 231.63,128.41 231.55,128.33 UG6.BR37
  BOTTOM w0.14: 229.53,124.88 227.07,124.88 223.11,120.92 210.99,120.92 205.07,115 198.35,115 194.95,118.4 194.95,124.12 191.39,127.68 191.39,132.52 184.86,139.05 182.35,139.05 182.21,139.19 182.21,139.41 C669.2
PEG_TXN5_C: length 6.9
  BOTTOM w0.079: U42.B18 175.66,139.84 176.24,140.12 178.16,140.12 178.5,140.46 178.91,140.46 178.98,140.53 179,140.53
  BOTTOM w0.14: 179,140.53 179.81,140.53 180.99,139.35 181.69,139.35 C669.1
PEG_TXN6: length 70.1
  BOTTOM w0.079: UG6.BT38 230.85,127.64 230.93,127.72 231.1,127.72 231.2,127.62 231.2,127.08 229.9,125.78 229.59,125.78 229.54,125.83
  BOTTOM w0.102: 229.52,125.83 229.54,125.83
  BOTTOM w0.14: C667.2 183.64,140.35 183.78,140.21 185.12,140.21 192.31,133.03 192.31,128.25 195.87,124.69 195.87,118.9 198.86,115.91 204.69,115.91 210.61,121.83 222.73,121.83 226.73,125.83 229.52,125.83
PEG_TXN6_C: length 11.2
  BOTTOM w0.079: U42.E20 173.56,140.73 arc(173.48,140.69) 173.44,140.61 173.44,140.53 arc(173.44,140.52) 173.45,140.52 arc(173.47,140.47) 173.53,140.45 177.22,140.45 177.36,140.59 177.36,140.67 177.37,140.68
  BOTTOM w0.14: 177.37,140.68 178.13,141.44 180.19,141.44 181.31,140.32 182.9,140.32 C667.1
PEG_TXN7: length 65.6
  BOTTOM w0.079: UG6.BR39 230.15,128.32 230.23,128.4 230.34,128.4 230.42,128.32 230.42,127.34 229.83,126.75 229.58,126.75 229.53,126.81 229.52,126.81
  BOTTOM w0.14: 229.52,126.81 226.52,126.81 226.42,126.82 222.35,122.75 210.23,122.75 207.36,119.88 205.36,119.88 204.83,120.41 204.83,121.58 202.34,124.07 197.88,124.07 193.36,128.59 193.36,133.35 185.32,141.39 182.37,141.39 182.24,141.52 C665.2
PEG_TXN7_C: length 8
  BOTTOM w0.079: 177.11,141.84 177.09,141.82 177.09,141.75 176.94,141.59 176.67,141.59 176.44,141.37 175.45,141.37 175.13,141.05 175.13,140.86 U42.C20
  BOTTOM w0.14: C665.1 181.59,141.58 181.34,141.58 180.57,142.36 177.63,142.36 177.11,141.84
PEG_TXP0: length 78.9
  BOTTOM w0.079: UG6.BR32 235.17,127.9 235.29,127.9 235.54,127.66 235.54,124.02 234.85,123.32 234.85,123.24 234.83,123.23
  BOTTOM w0.14: C681.2 181.74,132.08 181.74,131.78 182.2,131.33 184.31,131.33 186.21,129.43 186.21,125.7 190.11,121.79 190.11,116.13 196.2,110.05 206.96,110.05 212.99,116.08 225.11,116.08 228.96,119.93 231.53,119.93 234.83,123.23
PEG_TXP0_C: length 11.7
  BOTTOM w0.079: 180.14,135.32 180.14,135.34 180.19,135.39 180.19,135.58 178.33,137.44 177.87,137.44 177.65,137.67 177.21,137.67 arc(176.91,137.63) 176.62,137.53 176.62,137.52 176.57,137.5 arc(176.55,137.49) 176.53,137.49 arc(176.47,137.47) 176.41,137.47 174.1,137.47 173.94,137.64 173.94,137.83 173.86,137.91 U42.E16
  BOTTOM w0.14: C681.1 181.88,132.86 181.88,132.98 181.74,133.12 181.35,133.12 180.14,134.33 180.14,135.32
PEG_TXP1: length 78
  BOTTOM w0.079: 233.92,123.62 233.94,123.64 233.94,123.71 234.7,124.47 234.7,127.75 234.78,127.83 234.78,128.39 234.61,128.56 234.45,128.56 234.35,128.67 UG6.BP33
  BOTTOM w0.14: 233.92,123.62 231.14,120.84 228.58,120.84 224.73,116.99 212.62,116.99 206.58,110.96 196.58,110.96 191.03,116.51 191.03,122.25 187.2,126.08 187.2,130.17 183.26,134.1 182.33,134.1 C680.2
PEG_TXP1_C: length 7.8
  BOTTOM w0.079: U42.A16 176.31,137.94 176.4,138.03 176.67,138.03 176.71,137.98 178.45,137.98 181.07,135.37 181.07,135.32
  BOTTOM w0.14: 181.07,135.32 181.07,134.83 181.49,134.41 181.76,134.41 181.88,134.3 181.88,134.1 C680.1
PEG_TXP2: length 75.2
  BOTTOM w0.079: UG6.BR34 233.65,127.95 233.74,127.87 233.96,127.87 234.19,127.64 234.19,125.26 233.29,124.36 233.29,124.28 233.28,124.27
  BOTTOM w0.14: C678.2 183.75,135.29 184.08,135.29 188.25,131.12 188.25,126.37 191.94,122.68 191.94,116.89 196.96,111.88 206.2,111.88 212.24,117.91 224.36,117.91 228.2,121.76 230.76,121.76 233.28,124.27
PEG_TXP2_C: length 11.9
  BOTTOM w0.079: U42.F17 173.11,138.74 arc(173.15,138.69) 173.16,138.63 arc(173.24,138.44) 173.43,138.36 176.8,138.36 176.86,138.3 177.5,138.3 177.7,138.49 178.62,138.49 181.6,135.52 181.92,135.52 181.97,135.47 181.99,135.47
  BOTTOM w0.14: C678.1 182.9,135.47 181.99,135.47
PEG_TXP3: length 75.9
  BOTTOM w0.079: 232.11,124.4 232.12,124.41 232.12,124.49 233.38,125.74 233.38,128.38 233.21,128.55 233.05,128.55 232.95,128.65 UG6.BP35
  BOTTOM w0.14: 232.11,124.4 230.39,122.68 227.84,122.68 223.98,118.82 211.86,118.82 205.83,112.79 197.37,112.79 192.86,117.3 192.86,123.06 189.18,126.73 189.18,131.58 184.31,136.45 182.35,136.45 C676.2
PEG_TXP3_C: length 8.3
  BOTTOM w0.079: C676.1 181.49,136.65 181.21,136.65 178.87,138.98 177.58,138.98 177.37,139.19 177.06,139.19 arc(176.92,139.18) 176.78,139.14 arc(176.74,139.12) 176.7,139.11 arc(176.61,139.09) 176.52,139.08 175.36,139.08 arc(175.3,139.05) 175.27,138.99 175.27,138.93 arc(175.31,138.84) 175.41,138.8 U42.B17
PEG_TXP4: length 72.7
  BOTTOM w0.079: 230.8,124.4 230.81,124.41 230.81,124.49 232.81,126.49 232.81,127.68 232.61,127.88 232.33,127.88 232.25,127.96 UG6.BR36
  BOTTOM w0.14: 230.8,124.4 230.03,123.62 227.48,123.62 223.6,119.74 211.48,119.74 205.55,113.81 197.65,113.81 193.77,117.68 193.77,123.57 190.2,127.14 190.2,132.04 184.59,137.65 183.77,137.65 C674.2
PEG_TXP4_C: length 10.7
  BOTTOM w0.079: U42.E18 173.86,139.68 173.86,139.57 174.03,139.4 176.44,139.4 176.44,139.4 arc(176.6,139.44) 176.73,139.53 arc(176.82,139.59) 176.93,139.61 179.13,139.61 179.23,139.52 179.23,139.44 179.24,139.43
  BOTTOM w0.14: C674.1 182.99,137.71 180.96,137.71 179.24,139.43
PEG_TXP5: length 73.2
  BOTTOM w0.079: 229.53,124.61 229.55,124.61 229.61,124.67 229.98,124.67 231.98,126.66 231.98,128.39 231.81,128.56 231.63,128.56 231.55,128.64 UG6.BP37
  BOTTOM w0.14: C670.2 182.34,138.78 184.75,138.78 191.13,132.41 191.13,127.57 194.69,124.01 194.69,118.29 198.24,114.73 205.18,114.73 211.1,120.65 223.22,120.65 227.18,124.61 229.53,124.61
PEG_TXP5_C: length 6.8
  BOTTOM w0.079: U42.A18 176.31,139.87 176.4,139.96 178.22,139.96 178.56,140.3 178.94,140.3 178.98,140.26 179,140.26
  BOTTOM w0.14: 179,140.26 179.7,140.26 180.88,139.08 181.84,139.08 181.94,138.98 181.94,138.78 181.85,138.68 C670.1
PEG_TXP6: length 70.1
  BOTTOM w0.079: 229.54,125.57 229.59,125.62 229.97,125.62 231.36,127.01 231.36,127.69 231.17,127.88 230.94,127.88 230.85,127.97 UG6.BR38
  BOTTOM w0.102: 229.52,125.57 229.54,125.57
  BOTTOM w0.14: 229.52,125.57 226.84,125.57 222.84,121.56 210.72,121.56 204.8,115.65 198.75,115.65 195.6,118.79 195.6,124.58 192.04,128.14 192.04,132.92 185.01,139.95 183.73,139.95 C668.2
PEG_TXP6_C: length 11.3
  BOTTOM w0.079: 177.56,140.49 177.55,140.48 177.47,140.48 177.34,140.35 177.28,140.29 173.53,140.29 arc(173.37,140.35) 173.29,140.49 arc(173.29,140.51) 173.29,140.53 173.29,140.61 arc(173.25,140.69) 173.17,140.73 U42.F20
  BOTTOM w0.14: C668.1 182.98,140.06 181.2,140.06 180.08,141.18 178.25,141.18 177.56,140.49
PEG_TXP7: length 65.7
  BOTTOM w0.079: 229.52,126.54 229.54,126.54 229.59,126.6 229.9,126.6 230.58,127.28 230.58,128.38 230.41,128.55 230.23,128.55 230.15,128.63 UG6.BP39
  BOTTOM w0.14: 229.52,126.54 226.52,126.54 222.46,122.48 210.34,122.48 207.47,119.61 205.25,119.61 204.56,120.3 204.56,121.47 202.23,123.8 197.77,123.8 193.09,128.48 193.09,133.24 185.2,141.13 182.35,141.13 C666.2
PEG_TXP7_C: length 8
  BOTTOM w0.079: 177.3,141.65 177.28,141.63 177.2,141.63 177,141.44 176.73,141.44 176.51,141.21 175.52,141.21 175.29,140.98 175.29,140.81 175.37,140.73 U42.B20
  BOTTOM w0.14: C666.1 181.49,141.31 181.23,141.31 180.46,142.09 177.74,142.09 177.3,141.65
PEGX_RST#: length 69
  TOP w0.14: v1(264.47,115.78) 264.47,114.01 262.39,111.94 RG101.2 ; v1(260.75,114.57) 260.75,114 260.24,113.49 260.24,112.83 259.34,111.93 RG103.2 ; v1(245.44,118.94) 245.24,118.94 244.94,119.24 RG68.2 ; v1(255.46,116.96) 255.46,116.96 255.53,116.9 RG85.2
  IN1 w0.086: v1(264.47,115.78) 263.26,114.57 v1(260.75,114.57)
  IN2 w0.089: v1(245.44,118.94) 245.77,118.61 249.34,118.61 250.39,117.55 252.73,117.55 253.13,117.15 255.27,117.15 255.46,116.97 v1(255.46,116.96) 255.46,116.96 256.08,116.35 257.81,116.35 258.31,115.85 258.31,115.49 257.81,115 257.81,114.26 257.99,114.09 260.27,114.09 v1(260.75,114.57) ; v1(264.47,115.78) 264.26,115.57 263.49,115.57 261.77,117.29 261.77,121.58 262.13,121.94 262.13,122.82 261.92,123.03 261.92,124.51 261.35,125.08 261.35,125.5 262.33,126.48 v1(262.33,127.34)
  IN3 w0.089: v1(235.41,121.71) 236.04,121.71 238.1,119.64 240.16,119.64 241.34,120.82 242.82,120.82 244.42,119.23 245.14,119.23 v1(245.44,118.94)
  BOTTOM w0.102: UG6.BT30 236.07,126.94 236.07,123.55
  BOTTOM w0.14: v1(255.46,116.96) 255.35,116.85 255.35,115.31 255.51,115.14 RG181.1 ; 236.07,123.55 236.07,122.36 v1(235.41,121.71) ; QG19.2 262.19,127.21 v1(262.33,127.34)
PEX_CLKREQ: length 18.4
  TOP w0.14: RG76.1 239.65,117.84 237.34,117.84 236.88,117.38 QG9.1 236.61,117.1 235.46,118.25 235.11,118.25 v1(234.75,118.61)
  BOTTOM w0.102: 236.48,123.22 236.48,123.47 236.58,123.57 236.58,126.61 236.76,126.79 236.76,127.55 236.6,127.7 236.32,127.7 236.1,127.93 236.1,128.36 235.75,128.71 UG6.BP31
  BOTTOM w0.14: 236.48,123.22 236.48,122.11 235.6,121.24 235.27,121.24 234.7,120.66 234.7,118.66 v1(234.75,118.61)
PEX_TERMP: length 4.1
  BOTTOM w0.11: UG6.BT50 222.45,127.11 221.85,126.51
  BOTTOM w0.14: RG137.2 220.32,124.98 221.85,126.51
PEXVDD_EN_U: length 15.4
  IN4 w0.086: v1(243.61,118.56) 243.08,118.02 243.08,117.74 244.18,116.64 248.98,116.64 249.09,116.53 v1(249.09,116.51)
  BOTTOM w0.14: DG3.2 248.64,115.24 249.22,115.82 249.22,116.38 v1(249.09,116.51) 249.05,116.55 247.92,116.55 247.43,116.06 CG528.1 247.04,116.85 RG177.2 246.51,116.44 246.51,116.23 RG179.2 ; UG9.2 242.8,117.95 243.41,118.56 v1(243.61,118.56)
PLTRST#: length 485
  TOP w0.14: v1(100.2,82.6) 100.17,82.6 98.67,84.11 U12.1 98.67,85.22 99.24,85.79 99.24,87.16 99.32,87.24 R197.2 ; D18.1 309.2,87.69 308.89,87.99 v1(308.89,89.76) ; v1(229.04,52.83) 229.04,54.53 228.09,55.48 228.09,59.41 227.63,59.86 R548.1 227.08,59.86 v1(226.72,60.21) 226.72,59.25 226.82,59.15 227.34,59.15 227.71,58.78 227.71,56.91 226.85,56.05 224.97,56.05 224.41,56.6 224.41,58.13 224.16,58.38 U28.1 223.5,58.72 223.93,59.14 R536.2 ; UG1.2 244.07,116.25 243.9,116.41 243.03,116.41 v1(242.88,116.27) ; U18.17 240.63,72.3 240.81,72.49 241.19,72.49 241.72,71.96 243.86,71.96 244.99,70.83 244.99,69.74 247.81,66.92 250.96,66.92 254.1,70.05 262.24,70.05 262.41,70.22 v1(262.54,70.22) ; U25.1 97.73,63.99 98.23,63.49 99.77,63.49 99.95,63.67 100.56,63.67 100.79,63.44 R495.2 100.96,63.21 101.2,63.45 101.2,64.86 100.96,65.1 v1(100.95,65.1)
  IN1 w0.086: v1(271.6,72.36) 271.25,72.36 270.74,71.85 269.43,71.85 269.06,71.48 267.7,71.48 267.23,71.94 265.49,71.94 263.72,70.17 262.58,70.17 v1(262.54,70.22)
  IN2 w0.089: v1(317.66,83.96) 316.94,84.67 316.94,87.58 316.03,88.5 313.78,88.5 313.43,88.84 311.03,88.84 309.82,90.06 309.19,90.06 v1(308.89,89.76) 308.89,89.86 308.37,90.38 306.28,90.38 305.85,90.81 305.43,90.81 304.71,91.53 304.71,92.08 304.11,92.68 302.6,92.68 302.36,92.44 298.68,92.44 297.95,93.18 296.17,93.18 293.95,90.96 293.95,89 292.22,87.27 288.61,87.27 287.42,86.07 283.76,86.07 280.61,82.92 276.65,82.92 275.02,81.29 275.02,77.94 273.24,76.15 273.24,73.49 273.4,73.33 273.4,72.21 272.62,71.43 271.98,71.43 271.6,71.81 v1(271.6,72.36) ; v1(103.21,72.75) 103.25,72.71 103.5,72.71 110.01,66.2 119.19,66.2 123.72,70.73 134.07,70.73 134.56,70.25 158.39,70.25 159.05,69.59 164.64,69.59 165.4,68.84 169.48,68.84 169.6,68.71 173.13,68.71 173.66,69.25 174.15,69.25 175.29,68.11 177.56,68.11 178.45,67.21 179.25,67.21 179.94,66.51 181.7,66.51 182.05,66.86 183.84,66.86 184.58,66.12 185.38,66.12 187.77,63.72 187.77,63.06 188.86,61.98 191.75,61.98 192.67,61.07 193.29,61.07 193.68,60.68 196.9,60.68 198.49,59.09 198.72,59.09 200.44,57.37 200.44,56.16 202.5,54.1 209.13,54.1 209.75,53.48 211.05,53.48 211.19,53.61 212.52,53.61 213.7,52.43 227.44,52.43 228,53 228.87,53 v1(229.04,52.83) 229.65,52.22 231.28,52.22 231.58,52.51 233.7,52.51 235,51.22 238.7,51.22 239.03,50.89 243.73,50.89 244.09,51.25 249.05,51.25 249.99,52.19 251.89,52.19 252.25,52.55 265.03,52.55 266.77,54.29 269.51,54.29 v1(269.55,54.25)
  IN3 w0.089: v1(226.72,60.21) 227.46,60.95 227.46,61.84 227.05,62.24 224.77,62.24 224.34,62.68 224.34,63.36 223.77,63.92 223.77,69.36 222.92,70.21 222.92,74.19 223.8,75.07 223.8,85.43 222.97,86.27 219.32,86.27 218.97,85.91 217.71,85.91 217.32,86.3 217.32,86.67 216.73,87.26 216.12,87.26 216.11,87.27 215.14,88.25 215.14,93.48 v1(214.68,93.94) ; v1(242.88,116.27) 242.41,115.79 238.74,115.79 238.5,115.56 237.4,115.56 236.4,116.56 233.02,116.56 232.26,117.32 228.9,117.32 227.78,116.21 v1(226.16,116.21)
  IN4 w0.086: v1(100.95,65.1) 101.21,65.37 101.21,70.76 v1(103.21,72.75)
  BOTTOM w0.102: U49.BD39 223.23,59.94 223.7,59.94 223.8,60.04 224.31,60.04 224.5,60.24 225.38,60.24 225.5,60.12 226.63,60.12 v1(226.72,60.21)
  BOTTOM w0.14: v1(262.54,70.22) 262.54,69.42 264.64,67.32 264.64,65.93 264.27,65.55 264.27,61.48 269.55,56.2 v1(269.55,54.25) ; R951.2 271.77,73.08 271.6,72.9 v1(271.6,72.36) ; CN10.11 316.82,81.41 317,81.59 317,83.3 v1(317.66,83.96) ; v1(100.2,82.6) 99.35,82.6 97.64,80.89 97.64,79.38 97.96,79.05 97.96,77.97 99.38,76.56 99.38,74.73 100.95,73.16 102.35,73.16 102.76,72.75 v1(103.21,72.75) ; v1(226.16,116.21) 225.05,115.09 212.92,115.09 207.85,110.02 207.85,107.96 208.43,107.39 208.43,105.54 209.67,104.3 209.67,101.19 208.05,99.58 208.05,98.07 209.48,96.65 210.84,96.65 211.46,96.03 211.8,96.03 212.24,95.59 213.82,95.59 214.19,95.22 214.19,94.38 214.64,93.94 v1(214.68,93.94)
PLTRST#_EC: length 4.4
  TOP w0.14: U23.22 167.1,62.9 v1(166.51,62.31) 166.26,62.06 R514.2 165.26,62.06 164.9,62.42 C470.2 R509.2
PM_SYNC: length 162.7
  IN2 w0.089: v1(213.26,85.74) 213.23,85.7 213.23,85.47 212.69,84.94 212.69,83.82 211.72,82.85 209.23,82.85 207.46,84.62 206.46,84.62 201.43,89.65 200.17,89.65 199.47,90.35 199.47,99.78 193.82,105.43 193.82,106.39 179.23,120.98 125.5,120.98 123.29,123.2 112.45,123.2 111.55,124.1 111.55,125.91 112.58,126.95 112.58,134.02 113.12,134.56 114.39,134.56 120.15,140.31 120.15,141.89 v1(119.65,142.39)
  BOTTOM w0.102: 126.6,141.97 127.12,142.49 127.8,142.49 127.95,142.64 128.35,142.64 128.79,143.08 U42.CR23
  BOTTOM w0.14: v1(119.65,142.39) 120.27,141.77 120.27,141.19 121.64,139.82 123.61,139.82 124.1,140.31 124.1,141.09 124.99,141.97 126.6,141.97 ; R879.1 213.23,85.7 v1(213.26,85.74)
PM_SYNC_R: length 8.6
  BOTTOM w0.102: 214.5,82.24 214.5,81.8 214.69,81.61 214.69,80.9 214.08,80.29 214.08,79.96 214.35,79.69 214.35,79.17 214.54,78.98 214.54,78.2 214.72,78.02 U49.AH4
  BOTTOM w0.14: R879.2 213.57,84.7 213.64,84.77 TP138.1 214.25,84.57 C731.1 214.25,83.81 214.5,83.56 214.5,82.24
PM_THRMTRIP#: length 554
  TOP w0.14: v1(157.82,95.13) 157.14,95.82 Q19.3 ; Q33.3 v1(152.42,78.42)
  IN1 w0.086: v1(277.84,131.74) 279.19,130.39 279.19,118.68 284.19,113.67 284.19,113.61 286.07,111.73 v1(286.07,111.66) ; v1(214.66,94.83) 214.24,94.42 214.24,92.72 214.81,92.16 214.81,89.15 212.02,86.37 212.02,85.91 v1(212.25,85.69) 212.7,85.69 213.05,85.34 213.47,85.34 214.22,86.09 215.33,86.09 215.52,85.89 217.88,85.89 218.64,85.13 220.76,85.13 221.07,85.44 225.04,85.44 226.05,84.44 230.71,84.44 232.21,82.95 232.21,82.25 234.6,79.86 236.1,79.86 236.91,79.05 245.61,79.05 246.18,79.62 247.02,79.62 248.93,81.53 249.62,82.23 v1(249.67,82.23) ; v2(172.69,149.06) 172.69,148.79 173.17,148.31 176.07,148.31 176.94,149.18 181.84,149.18 186.25,144.77 186.25,128.42 190.13,124.54 190.13,116.46 196.25,110.34 196.25,107.04 196.68,106.61 196.68,105.44 196.29,105.05 v1(196.29,104.42)
  IN2 w0.089: v1(277.84,131.74) 278.48,132.37 278.48,136.17 280.78,138.48 280.78,151.99 282.5,153.71 282.5,165.23 285.13,167.87 285.13,170.83 284.23,171.74 283.73,171.74 277.14,178.33 277.14,180.26 278.1,181.22 279.54,181.22 280.23,181.92 280.23,188.02 281.03,188.82 281.03,195.9 281.36,196.23 281.36,197.59 281.96,198.19 281.96,199.58 281.26,200.28 278.37,200.28 277.79,200.86 277.79,204.99 275.55,207.23 275.08,207.23 273.55,208.76 271.94,208.76 270.89,209.82 270.89,210.84 267.74,213.98 267.53,213.98 266.64,214.87 266.64,215.91 v1(266.06,216.49) ; v1(212.25,85.69) 212.4,85.53 212.4,83.94 211.6,83.14 209.35,83.14 207.58,84.92 206.58,84.92 202.64,88.85 202.64,89.55 203.13,90.03 203.13,93.1 201.17,95.06 201.17,99.38 200.84,99.71 200.84,101.64 200.57,101.91 199.55,101.91 198.44,103.02 198.04,103.02 196.65,104.42 v1(196.29,104.42) ; v1(286.07,111.66) 286.3,111.43 287.4,111.43 288.35,110.48 289.07,110.48 292.5,107.04 292.5,98.46 291.92,97.87 291.92,92.87 291.61,92.56 291.61,89.97 291.25,89.61 290.03,89.61 290.03,89.6 287.34,89.6 286.61,90.33 283.47,90.33 280.2,87.06 269.55,87.06 269.36,86.87 265.61,86.87 261.38,82.65 255.57,82.65 254.7,81.78 252.38,81.78 251.93,82.23 v1(249.67,82.23) ; 113.26,126.29 113.26,132.27 v1(113.47,132.48) ; 113.26,126.29 v1(113.24,126.28) ; 113.26,126.29 113.43,126.46 113.98,126.46 114.47,126.96 123.17,126.96 126.54,123.58 171.73,123.58 175.44,127.29 175.44,128.82 176.42,129.8 176.42,137.43 172.49,141.36 172.49,148.85 v2(172.69,149.06)
  IN4 w0.086: v1(113.24,126.28) 113.48,126.05 113.48,125.84 113.54,125.78 113.54,125.45 112.99,124.9 112.99,122.08 113.42,121.64 113.42,119.53 112.87,118.97 112.87,115.87 112.48,115.49 112.48,109.9 118.99,103.39 118.99,96.46 119.5,95.96 120.32,95.13 v1(157.82,95.13)
  BOTTOM w0.102: v2(172.69,149.06) 172.69,149.13 U42.F34
  BOTTOM w0.14: v1(152.42,78.42) 153.56,79.57 157.23,79.57 158.17,80.51 158.17,84.8 158.96,85.59 158.96,89.79 158.91,89.83 157.82,90.92 v1(157.82,95.13) ; v1(266.06,216.49) 265.46,217.09 264.93,217.09 264.81,216.98 D50.2 ; v1(212.25,85.69) 212.22,85.66 208.61,85.66 208.13,85.18 R886.1 ; v1(113.47,132.48) 113.31,132.65 R811.2 112.02,133.35 Q97.1 ; D56.2 215.24,95.42 v1(214.66,94.83)
PM_THRMTRIP#_P: length 9.4
  BOTTOM w0.102: 209.29,82.84 209.6,82.53 209.6,82.34 210.82,81.12 211.56,81.12 211.98,80.7 211.98,79.68 212.77,78.89 212.81,78.89 U49.AD3
  BOTTOM w0.14: 209.29,82.84 207.68,84.45 R886.2 207.68,85.23 TP137.1
PMON: length 254.9
  TOP w0.14: v1(99.73,56.38) 99.79,56.38 102.8,59.39 v1(102.8,59.73) 103.42,60.35 103.42,66.06 106.02,68.66 106.02,69.97 105.54,70.45 105.54,73.45 106.02,73.92 106.02,76.57 106.49,77.05 106.49,83.86 107.41,84.78 107.41,98.15 108.17,98.9 108.17,115.41 107.39,116.19 107.39,124.3 109,125.91 109,140.5 109.81,141.31 109.81,166.89 109,167.7 109,195.69 110.04,196.73 110.04,203.26 112.32,205.53 112.32,209.13 114.95,211.77 114.95,215.72 116.44,217.22 121.87,217.22 v1(122.56,216.53) ; PR325.2 34.58,42.8 v1(34.41,42.64)
  TOP w0.152: PR325.2 34.46,43.38 34.25,43.38 33.21,42.35 PR328.1 33.2,41.6 33.23,41.58 PC260.2
  IN3 w0.089: v1(34.41,42.64) 37.54,45.77 39.04,45.77 39.42,46.15 39.42,47.64 40.79,49 41.95,49 43.5,50.55 57.83,50.55 60.49,47.9 72.2,47.9 73.9,49.6 73.9,50.83 75.26,52.19 76.57,52.19 77.71,53.33 94.19,53.33 97.24,56.38 v1(99.73,56.38)
  BOTTOM w0.14: v1(122.56,216.53) PR363.1
PP: length 1.6
  TOP w0.14: U18.4 238.63,65.79 238.49,65.66 T1.1
PROCHOT_EC: length 12.9
  TOP w0.14: U23.17 166.77,64.9 166.56,65.1 165.19,65.1 164.82,64.73 C456.1 R489.2 161.68,64.73 161.28,65.13 161.28,65.37 160.93,65.72 159.9,65.72 159.36,66.26 156.84,66.26 156.71,66.39 Q46.2
PS1_I2C_IRQ: length 2.6
  BOTTOM w0.14: R1050.1 R1056.1 276.17,55.74 276.27,55.74 v1(276.27,55.73) 276.27,55.74 276.99,55.74 U50.A2
PS1_I2C_SCL: length 2.7
  BOTTOM w0.14: U50.B1 277.52,56.54 278.12,57.14 v1(278.31,57.14) 278.31,57.14 R1035.1 R1034.1
