# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Nets (continued)
5650_SHO4: PC2.2 PR6.1 PR24.2 PU2.17
5650_SHP1: PC16.1 PR78.1 PU2.2
5650_SHP2: PR399.1 PU2.5
5650_SKIP: PR40.2 PR386.2 PU2.25
8068EN_1.8V: PC487.1 PR617.1 PU14.5
8068FB_1.8V: PC211.2 PR290.1 PR291.2 PU14.6
8068FB_1.8V_S: PC211.1 PR291.1 PR616.1
8068LX_1.8V: PL3.1 PR268.1 PU14.1 PU14.2 PU14.3
8068NC_1.8V: PC486.1 PU14.7
8068PG_1.8V: PR285.1 PU14.4
8068SVIN_1.8V: PC484.1 PR615.2 PU14.8
8816ABOOT1: PC314.2 PU19.1
8816ABOOT2: PC310.2 PU19.15
8816AEN: PC302.1 PR20.1 PR50.1 PU19.3
8816ALGATE1: PQ43.8 PQ44.8 PU19.19
8816ALGATE2: PQ41.8 PQ42.8 PU19.17
8816APG: PR383.1 PR388.1 PU19.13
8816APHASE1: PC314.1 PL5.1 PQ43.5 PQ43.6 PQ43.7 PQ44.5 PQ44.6 PQ44.7 PR100.2 PU19.20
8816APHASE2: PC310.1 PL4.1 PQ41.5 PQ41.6 PQ41.7 PQ42.5 PQ42.6 PQ42.7 PR429.2 PU19.16
8816APSI: PR377.2 PR380.2 PR382.1 PU19.4
8816APVCC: PC321.1 PR402.2 PU19.18
8816AREFIN: PC286.1 PR354.1 PR365.1 PR366.2 PU19.7
8816ARGDN: PC289.1 PC294.2 PR367.2 PU19.10
8816ASS: PC298.1 PR384.1 PU19.12
8816ATON: PC281.1 PR351.1 PU19.9
8816AUGATE1: PR394.1 PU19.2
8816AUGATE1_1: PQ43.1 PQ44.1 PR394.2
8816AUGATE2: PR392.1 PU19.14
8816AUGATE2_1: PQ41.1 PQ42.1 PR392.2
8816AVREF: PC282.1 PR369.2 PU19.8
8816AVSNS: PC285.1 PC294.1 PR113.2 PR114.1 PU19.11(VSNS)
9336ADJ: PR130.1 PR134.2 PU28.5
9336DRV: PD1.1(CATHODE) PQ14.4 PR530.1 PU28.6
9512_5VCC: PC158.1 PR185.2 PU10.12
9512_ADDR: PR232.2 PR249.1 PU10.26
9512_CH_OC: PR176.2 PU10.3
9512_COMP: PC194.2 PR234.2 PU10.30
9512_CSNSUM: PR228.1 PU10.21
9512_CSP1: PC181.1 PR235.2 PR243.2 PR244.2 PU10.20
9512_CSP2: PC174.1 PR227.2 PR236.2 PR237.2 PU10.19
9512_CSP3: PC168.1 PR224.2 PR225.2 PR226.1 PU10.18
9512_CSP4: PC164.1 PR213.2 PR222.2 PR223.1 PU10.17
9512_CSP5: PC162.1 PR205.2 PR210.2 PR211.1 PU10.16
9512_CSP6: PC161.1 PR199.2 PR202.2 PR203.1 PU10.15
9512_CSP7: PC160.1 PR193.2 PR196.2 PR197.1 PU10.14
9512_CSP8: PC159.1 PR187.2 PR190.1 PR191.2 PU10.13
9512_CSPSUM: PR229.1 PU10.22
9512_DAC: PC163.2 PC188.2 PR612.2 PU10.28
9512_EAP: PR233.2 PU10.29
9512_EN: PQ20.3 PR168.2 PR177.1 PU10.36
9512_EN_1: PC155.1 PD2.2 PQ19.2 PR145.2 PR167.1
9512_EN_S: PR177.2 PR575.1 PR578.1 PR582.2 PR587.2 PR592.2 PR597.2 PR602.2 PR607.2
9512_FB: PR240.2 PR241.2 PR247.2 PR248.1 PU10.31
9512_FBRTN: PC154.2 PC157.2 PC163.1 PC169.2 PC179.1 PR164.2 PR201.2 PR207.1 PU10.32
9512_IMON: PC193.1 PR231.1 PU10.25
9512_LPC: PR230.2 PR246.1 PU10.24
9512_PGOOD: PR184.1 PR188.1 PU10.38
9512_PSI: PR186.1 PR189.1 PR192.1 PU10.37
9512_PWM1: PR180.2 PR181.1 PU10.11
9512_PWM1_S: PR181.2 PU31.34
9512_PWM2: PR155.2 PR169.1 PU10.10
9512_PWM2_S: PR169.2 PU32.34
9512_PWM3: PR156.2 PR170.1 PU10.9
9512_PWM3_S: PR170.2 PU33.34
9512_PWM4: PR157.2 PR171.1 PU10.8
9512_PWM4_S: PR171.2 PU34.34
9512_PWM5: PR158.2 PR172.1 PU10.7
9512_PWM5_S: PR172.2 PU35.34
9512_PWM6: PR159.2 PR173.1 PU10.6
9512_PWM6_S: PR173.2 PU36.34
9512_PWM7: PR160.2 PR174.1 PU10.5
9512_PWM7_S: PR174.2 PU29.34
9512_PWM8: PR161.2 PR175.1 PU10.4
9512_PWM8_S: PR175.2 PU30.34
9512_REFADJ: PR178.2 PU10.40
9512_REFIN: PC154.1 PR165.2 PR166.2 PU10.1
9512_REFOUT: PR242.1 PU10.23
9512_SCL: PR195.2 PU10.35
9512_SDA: PR200.2 PU10.34
9512_TSENSE: PR206.2 PU10.33
9512_VID: PR183.1 PU10.39
9512_VINMON: PR238.1 PR239.1 PU10.27
9512_VREF: PC153.1 PR163.2 PU10.2(VREF)
9619_BST1: PR583.1 PU31.33
9619_BST2: PR588.1 PU32.33
9619_BST3: PR593.1 PU33.33
9619_BST4: PR598.1 PU34.33
9619_BST5: PR603.1 PU35.33
9619_BST6: PR608.1 PU36.33
9619_BST7: PR569.1 PU29.33
9619_BST8: PR567.1 PU30.33
9619_PHASE1: PC476.2 PU31.32
9619_PHASE2: PC477.2 PU32.32
9619_PHASE3: PC478.2 PU33.32
9619_PHASE4: PC479.2 PU34.32
9619_PHASE5: PC480.2 PU35.32
9619_PHASE6: PC481.2 PU36.32
9619_PHASE7: PC475.2 PU29.32
9619_PHASE8: PC474.2 PU30.32
9619_SW1: PL16.1 PR543.2 PU31.10
9619_SW2: PL17.1 PR544.2 PU32.10
9619_SW3: PL18.1 PR545.2 PU33.10
9619_SW4: PL19.1 PR546.2 PU34.10
9619_SW5: PL20.1 PR547.2 PU35.10
9619_SW6: PL21.1 PR548.2 PU36.10
9619_SW7: PL14.1 PR541.2 PU29.10
9619_SW8: PL15.1 PR542.2 PU30.10
9619_VOS1: PR527.1 PU31.1
9619_VOS2: PR521.1 PU32.1
9619_VOS3: PR522.1 PU33.1
9619_VOS4: PR523.1 PU34.1
9619_VOS5: PR524.1 PU35.1
9619_VOS6: PR525.1 PU36.1
9619_VOS7: PR519.1 PU29.1
9619_VOS8: PR520.1 PU30.1
24780_ACDET: PC238.1 PR315.2 PR316.2 PU18.6
24780_ACDRV: PR485.2 PU18.4
24780_ACN: PC236.1 PC239.2 PR501.2 PU18.1
24780_ACP: PC235.2 PC239.1 PR500.2 PU18.2
24780_BATDRV: PR314.2 PU18.18
24780_BATSRC: PR320.2 PU18.17
24780_BM#: PR341.2 PU18.16
24780_BST: PR327.1 PU18.25
24780_CMPIN: PR337.1 PR343.1 PR344.2 PU18.13
24780_CMPOUT: PR335.2 PR342.2 PU18.14
24780_CMSRC: PR470.2 PU18.3
24780_DH: PQ69.4 PU18.26
24780_DL: PQ71.4 PU18.23
24780_ILIM: PC263.2 PR655.1 PR656.1 PU18.21
24780_LX: PC259.1 PL26.1 PQ69.1 PQ69.2 PQ69.3(S_3) PQ71.5 PR345.1 PU18.27
24780_SRN: PC267.2 PC272.2 PR623.1 PU18.19
24780_SRP: PC266.2 PC272.1 PR622.1 PU18.20
51225_CS1: PR277.1 PU15.1
51225_CS2: PR278.1 PU15.5
51225_DH1: PQ66.1 PU15.16
51225_DH2: PQ65.1 PU15.10
51225_DL1: PQ66.8 PU15.15
51225_DL2: PQ65.8 PU15.11
51225_EN1: PR294.2 PU15.20
51225_FB1: PR281.1 PR283.2 PU15.2
51225_FB2: PR279.1 PR280.2 PU15.4
51225_SW1: PC212.1 PL25.1 PQ66.9 PR308.1 PU15.18
51225_SW2: PC213.1 PL24.2 PQ65.9 PR307.1 PU15.8
51225_VBST1: PR295.2 PU15.17
51225_VBST2: PR296.1 PU15.9
51225_VIN: PC219.1 PR300.1 PU15.12
81305_ALERT#: PR372.2 PU20.35
81305_COMP: PC311.2 PC313.2 PU20.6
81305_CSCOMP: PC316.1 PC317.1 PR395.1 PR398.2 PR481.1 PU20.8
81305_CSP1: PC329.2 PR414.2 PR6041.2 PU20.21
81305_CSP2: PC328.2 PR415.2 PR6040.2 PU20.19
81305_CSP3: PC326.2 PR416.2 PR6039.2 PU20.17
81305_CSP4: PC327.2 PR417.2 PR6038.2 PU20.15
81305_CSP5: PC325.2 PR418.2 PR6037.2 PU20.13
81305_CSP6: PC323.2 PR419.2 PR6036.2 PU20.11
81305_CSREF: PC324.2 PR420.2 PR421.2 PR422.2 PR423.2 PR424.2 PR425.2 PU20.10
81305_CSSUM: PC316.2 PC317.2 PR397.1 PR403.2 PR404.2 PR405.2 PR406.2 PR407.2 PR408.2 PU20.9
81305_DIFFOUT: PC301.1 PR391.2 PU20.4
81305_EN: PC290.2 PR29.2 PR362.2 PU3.4 PU20.39
81305_FB: PC313.1 PR387.1 PR390.2 PR391.1 PU20.5
81305_ILIM: PR395.2 PU20.7
81305_IOUT: PC299.2 PR378.1 PR381.1 PU20.3
81305_PSYS: PC291.2 PR353.1 PR363.2 PU20.40
81305_ROSC: PR375.1 PU20.33
81305_SCLK: PR370.2 PU20.36
81305_SDIO: PR371.2 PU20.34
81305_TSENSE: PC320.2 PR396.2 PU20.23
81305_VCC: PC284.1 PR355.1 PU20.32
81305_VR_RDY: PR374.2 PU20.38
81305_VRHOT: PR373.2 PU20.37
81305_VRMP: PC297.2 PR376.2 PU20.31
81305_VSN: PC295.2 PR364.1 PU20.2
81305_VSP: PC280.1 PC287.1 PR19.2 PR356.2 PU20.1(VSP)
+BAT_RTC: CN16.1 Q116.1(EMITTER) R1160.1
+CORE_PLLVDD: CG299.1 CG306.1 CG338.1 CG339.1 CG342.1 CG344.1 CG353.1 CG354.2 CG355.2 LG1.2 UG6.BF9 UG6.BF25 UG6.BG22 UG6.BG25 UG6.BH16 UG6.BH19 UG6.BH22
+FBA_PLL_AVDD: CG98.1 CG106.1 CG123.1 CG152.1 CG184.1 CG197.1 CG198.1 CG245.1 CG305.1 CG406.2 CG407.2 LG2.1 UG6.AC46 UG6.AE11 UG6.AP46 UG6.L17 UG6.L35 UG6.T46
+FBVDDQ_MEM: C625.1 C626.1 C627.1 C628.1 C671.1 C672.1 C683.1 C684.1 CG1.1 CG2.1 CG3.1 CG4.1 CG5.1 CG10.1 CG14.1 CG15.1 CG16.1 CG17.1 CG18.1 CG19.1 CG20.1 CG21.1 CG22.1 CG23.1 CG24.1 CG25.1 CG26.1 CG27.1 CG28.1 CG29.1 CG30.1 CG31.1 CG32.1 CG33.1 CG34.1 CG35.1 CG36.1 CG37.1 CG38.1 CG39.1 CG40.1 CG41.1 CG42.1 CG43.1 CG44.1 CG45.1 CG46.1 CG47.1 CG48.1 CG49.1 CG50.1 CG51.1 CG53.1 CG54.1 CG55.1 CG56.1 CG57.1 CG58.2 CG59.1 CG60.1 CG61.1 CG62.1 CG64.1 CG65.1 CG66.1 CG67.1 CG68.1 CG69.1 CG71.1 CG73.1 CG74.1 CG75.1 CG76.1 CG77.1 CG78.1 CG79.1 CG80.1 CG81.1 CG83.1 CG85.1 CG86.1 CG88.1 CG89.1 CG90.1 CG92.2 CG93.2 CG94.1 CG96.2 CG97.2 CG99.1 CG100.2 CG101.1 CG102.1 CG104.2 CG105.1 CG107.2 CG108.2 CG109.1 CG110.1 CG112.2 CG116.1 CG118.1 CG119.2 CG121.1 CG124.2 CG127.1 CG129.1 CG136.1 CG141.1 CG143.1 CG144.1 CG146.1 CG153.1 CG154.1 CG155.1 CG156.1 CG157.1 CG158.1 CG159.1 CG161.1 CG162.1 CG163.1 CG164.1 CG167.1 CG169.1 CG172.1 CG173.1 CG174.1 CG175.1 CG177.1 CG179.1 CG182.1 CG185.1 CG187.2 CG189.1 CG190.1 CG191.2 CG192.1 CG194.1 CG196.1 CG199.2 CG203.1 CG206.1 CG207.1 CG209.1 CG212.2 CG213.1 CG214.1 CG215.1 CG216.2 CG220.1 CG230.1 CG232.2 CG234.1 CG235.2 CG236.1 CG244.1 CG247.1 CG248.2 CG249.1 CG250.1 CG251.2 CG253.1 CG261.1 CG262.1 CG263.1 CG264.1 CG265.2 CG266.1 CG275.1 CG276.2 CG277.1 CG278.1 CG279.1 CG280.1 CG281.2 CG290.1 CG291.1 CG293.2 CG303.1 CG308.1 CG337.1 CG359.1 CG363.1 CG364.1 CG366.1 CG409.1 CG410.1 CG411.1 CG412.1 CG413.1 CG414.1 CG415.1 CG416.1 CG417.1 CG418.1 CG419.1 CG420.2 CG421.2 CG422.1 CG423.1 CG424.1 CG425.1 CG426.2 CG427.1 CG428.1 CG429.1 CG430.1 CG431.1 CG432.1 CG433.1 CG434.1 CG435.1 CG436.2 CG437.1 CG438.2 CG439.1 CG440.1 CG441.1 CG442.1 CG443.1 CG444.1 CG445.1 CG446.1 CG447.2 CG448.1 CG449.1 CG450.1 CG451.1 CG452.1 CG453.1 CG454.1 CG455.1 CG456.1 CG457.2 CG458.2 CG459.2 CG460.1 CG461.1 CG462.2 CG463.1 CG464.2 CG465.1 CG466.1 CG467.1 CG468.1 CG469.1 CG470.1 CG471.1 CG472.1 CG473.1 CG474.1 CG475.1 CG476.1 CG477.1 CG478.1 CG479.1 CG480.1 CG481.1 CG482.1 CG483.1 CG484.1 CG485.1 CG486.1 CG487.1 CG488.1 CG489.1 CG490.1 CG491.1 CG492.1 CG493.1 CG494.1 CG495.1 CG496.1 CG497.1 CG498.1 CG499.1 CG500.1 CG501.1 CG502.1 CG503.1 CG505.1 CG506.1 CG507.1 CG508.1 CG509.1 CG510.1 CG511.1 CG512.1 CG513.1 CG514.1 CG515.1 CG516.1 CG517.1 PC31.1 PC33.1 PC34.1 PC36.1 PC37.1 PC38.1 PC39.1 PC50.1 PC51.1 PC52.1 PL4.2 PL5.2 PR11.1 PR114.2 RG3.1 RG4.1 RG5.1 RG17.1 RG18.1 RG19.1 RG20.1 RG21.1 RG22.1 RG23.1 RG34.1 RG36.1 RG37.1 RG38.1 RG39.1 RG50.1 RG51.1 UG6.AB11 UG6.AB46 UG6.AC11 UG6.AE46 UG6.AF11 UG6.AF46 UG6.AH11 UG6.AH46 UG6.AJ11 UG6.AJ46 UG6.AL11 UG6.AL46 UG6.AM11 UG6.AM46 UG6.AP11 UG6.AR11 UG6.AR46 UG6.AU11 UG6.AU46 UG6.AV11 UG6.AV46 UG6.AY46 UG6.BA46 UG6.BC46 UG6.K10 UG6.L11 UG6.L13 UG6.L14 UG6.L16 UG6.L19 UG6.L20 UG6.L22 UG6.L23 UG6.L25 UG6.L26 UG6.L28 UG6.L29 UG6.L31 UG6.L32 UG6.L34 UG6.L37 UG6.L38 UG6.L40 UG6.L41 UG6.L43 UG6.L44 UG6.L46 UG6.N11 UG6.N46 UG6.P11 UG6.P46 UG6.T11 UG6.U11 UG6.U46 UG6.W11 UG6.W46 UG6.Y11 UG6.Y46 VRAM1.A1 VRAM1.A14 VRAM1.B5 VRAM1.B10 VRAM1.C1 VRAM1.C4 VRAM1.C11 VRAM1.C14 VRAM1.E1 VRAM1.E5 VRAM1.E10 VRAM1.E14 VRAM1.F4 VRAM1.F11 VRAM1.H1 VRAM1.H2 VRAM1.H13 VRAM1.H14 VRAM1.J2 VRAM1.J13 VRAM1.K2 VRAM1.K13 VRAM1.L1 VRAM1.L2 VRAM1.L13 VRAM1.L14 VRAM1.N4 VRAM1.N11 VRAM1.P1 VRAM1.P5 VRAM1.P10 VRAM1.P14 VRAM1.T1 VRAM1.T4 VRAM1.T11 VRAM1.T14 VRAM1.U5 VRAM1.U10 VRAM1.V1 VRAM1.V14 VRAM2.A1 VRAM2.A14 VRAM2.B5 VRAM2.B10 VRAM2.C1 VRAM2.C4 VRAM2.C11 VRAM2.C14 VRAM2.E1 VRAM2.E5 VRAM2.E10 VRAM2.E14 VRAM2.F4 VRAM2.F11 VRAM2.H1 VRAM2.H2 VRAM2.H13 VRAM2.H14 VRAM2.J2 VRAM2.J13 VRAM2.K2 VRAM2.K13 VRAM2.L1 VRAM2.L2 VRAM2.L13 VRAM2.L14 VRAM2.N4 VRAM2.N11 VRAM2.P1 VRAM2.P5 VRAM2.P10 VRAM2.P14 VRAM2.T1 VRAM2.T4 VRAM2.T11 VRAM2.T14 VRAM2.U5 VRAM2.U10 VRAM2.V1 VRAM2.V14 VRAM3.A1 VRAM3.A14 VRAM3.B5 VRAM3.B10 VRAM3.C1 VRAM3.C4 VRAM3.C11 VRAM3.C14 VRAM3.E1 VRAM3.E5 VRAM3.E10 VRAM3.E14 VRAM3.F4 VRAM3.F11 VRAM3.H1 VRAM3.H2 VRAM3.H13 VRAM3.H14 VRAM3.J2 VRAM3.J13 VRAM3.K2 VRAM3.K13 VRAM3.L1 VRAM3.L2 VRAM3.L13 VRAM3.L14 VRAM3.N4 VRAM3.N11 VRAM3.P1 VRAM3.P5 VRAM3.P10 VRAM3.P14 VRAM3.T1 VRAM3.T4 VRAM3.T11 VRAM3.T14 VRAM3.U5 VRAM3.U10 VRAM3.V1 VRAM3.V14 VRAM4.A1 VRAM4.A14 VRAM4.B5 VRAM4.B10 VRAM4.C1 VRAM4.C4 VRAM4.C11 VRAM4.C14 VRAM4.E1 VRAM4.E5 VRAM4.E10 VRAM4.E14 VRAM4.F4 VRAM4.F11 VRAM4.H1 VRAM4.H2 VRAM4.H13 VRAM4.H14 VRAM4.J2 VRAM4.J13 VRAM4.K2 VRAM4.K13 VRAM4.L1 VRAM4.L2 VRAM4.L13 VRAM4.L14 VRAM4.N4 VRAM4.N11 VRAM4.P1 VRAM4.P5 VRAM4.P10 VRAM4.P14 VRAM4.T1 VRAM4.T4 VRAM4.T11 VRAM4.T14 VRAM4.U5 VRAM4.U10 VRAM4.V1 VRAM4.V14 VRAM5.A1 VRAM5.A14 VRAM5.B5 VRAM5.B10 VRAM5.C1 VRAM5.C4 VRAM5.C11 VRAM5.C14 VRAM5.E1 VRAM5.E5 VRAM5.E10 VRAM5.E14 VRAM5.F4 VRAM5.F11 VRAM5.H1 VRAM5.H2 VRAM5.H13 VRAM5.H14 VRAM5.J2 VRAM5.J13 VRAM5.K2 VRAM5.K13 VRAM5.L1 VRAM5.L2 VRAM5.L13 VRAM5.L14 VRAM5.N4 VRAM5.N11 VRAM5.P1 VRAM5.P5 VRAM5.P10 VRAM5.P14 VRAM5.T1 VRAM5.T4 VRAM5.T11 VRAM5.T14 VRAM5.U5 VRAM5.U10 VRAM5.V1 VRAM5.V14 VRAM6.A1 VRAM6.A14 VRAM6.B5 VRAM6.B10 VRAM6.C1 VRAM6.C4 VRAM6.C11 VRAM6.C14 VRAM6.E1 VRAM6.E5 VRAM6.E10 VRAM6.E14 VRAM6.F4 VRAM6.F11 VRAM6.H1 VRAM6.H2 VRAM6.H13 VRAM6.H14 VRAM6.J2 VRAM6.J13 VRAM6.K2 VRAM6.K13 VRAM6.L1 VRAM6.L2 VRAM6.L13 VRAM6.L14 VRAM6.N4 VRAM6.N11 VRAM6.P1 VRAM6.P5 VRAM6.P10 VRAM6.P14 VRAM6.T1 VRAM6.T4 VRAM6.T11 VRAM6.T14 VRAM6.U5 VRAM6.U10 VRAM6.V1 VRAM6.V14 VRAM7.A1 VRAM7.A14 VRAM7.B5 VRAM7.B10 VRAM7.C1 VRAM7.C4 VRAM7.C11 VRAM7.C14 VRAM7.E1 VRAM7.E5 VRAM7.E10 VRAM7.E14 VRAM7.F4 VRAM7.F11 VRAM7.H1 VRAM7.H2 VRAM7.H13 VRAM7.H14 VRAM7.J2 VRAM7.J13 VRAM7.K2 VRAM7.K13 VRAM7.L1 VRAM7.L2 VRAM7.L13 VRAM7.L14 VRAM7.N4 VRAM7.N11 VRAM7.P1 VRAM7.P5 VRAM7.P10 VRAM7.P14 VRAM7.T1 VRAM7.T4 VRAM7.T11 VRAM7.T14 VRAM7.U5 VRAM7.U10 VRAM7.V1 VRAM7.V14 VRAM8.A1 VRAM8.A14 VRAM8.B5 VRAM8.B10 VRAM8.C1 VRAM8.C4 VRAM8.C11 VRAM8.C14 VRAM8.E1 VRAM8.E5 VRAM8.E10 VRAM8.E14 VRAM8.F4 VRAM8.F11 VRAM8.H1 VRAM8.H2 VRAM8.H13 VRAM8.H14 VRAM8.J2 VRAM8.J13 VRAM8.K2 VRAM8.K13 VRAM8.L1 VRAM8.L2 VRAM8.L13 VRAM8.L14 VRAM8.N4 VRAM8.N11 VRAM8.P1 VRAM8.P5 VRAM8.P10 VRAM8.P14 VRAM8.T1 VRAM8.T4 VRAM8.T11 VRAM8.T14 VRAM8.U5 VRAM8.U10 VRAM8.V1 VRAM8.V14
+FP_FUSE_GPU: RG64.1 UG6.BH25
+PCH_AUX: C482.2 C487.1 C493.2 C502.1 C503.2 C505.1 C506.1 C508.1 C509.2 C511.1 C512.1 C514.2 C537.2 C539.1 C540.1 PJ7.2 PR309.1 PR638.2 U49.AA38 U49.AC38 U49.AC39 U49.AC41 U49.AC42 U49.AC44 U49.AD38 U49.AD39 U49.AD41 U49.AD42 U49.AD44 U49.AE38 U49.AE39 U49.AE41 U49.AE42 U49.AE44 U49.AG38
+PEX_PLL_HVDD: CG408.1 RG107.1 UG6.BF43
+SMDDR_VREF_DQ0: C316.1 C317.1 JDIM2.164 R229.2 R275.1 R279.2
+SMDDR_VREF_DQ1: C200.1 C208.1 JDIM1.164 R174.1 R177.2 R180.2
+TPVDD: CN17.1 Q62.2 Q62.5 Q63.2 R625.2
+USBPWR3: C510.1 C515.2 C520.2 C521.2 C794.2 C812.1 CN15.1(VBUS) D66.1 U52.12(VOUT)
+USBPWR_DB1: C714.1 C720.1 CN4.8 CN4.9 CN4.10 U7.12(VOUT)
+USBPWR_DB2: C178.1 C180.1 CN4.5 CN4.6 CN4.7 U6.12(VOUT)
+VGPU_SRC_R: PC334.1 PQ46.5 PQ60.1 PQ60.2 PQ60.3(S3) PR101.2 PR474.1 PR480.1 PR487.1
+WL_VDD: C333.2 C340.2 C392.1 C401.2 C432.1 C433.1 C498.2 C499.1 C500.2 CN12.2 CN12.4 CN12.72 CN12.74 Q38.2 R295.2 R365.1 R392.1 R408.2 R431.2 R933.2 R938.2
A0_DP: R655.2 R658.2 U56.11
A_DE: R1166.2 R1167.1 U55.9
A_EQ1: R1153.1 R1154.2 U55.18
A_EQ2: R1141.1 R1142.2 U55.19
ACIN: PR312.1 PR313.2 PR317.2 U23.72
ACPRESENT: R577.2 U23.84 U49.AH46
ACZ_BCLK: C792.2 R1021.2 U49.BE42
ACZ_RST#: R1048.1 R1049.2 U49.BF44
ACZ_RST#_AUDIO: Q23.1(S) R1049.1
ACZ_SDIN0: R526.2 U49.BG44
ACZ_SDIN0_U: R526.1 U20.16
ACZ_SDOUT: R1023.1 R1036.1 R1046.2 R1052.2 U49.BE43
ACZ_SDOUT_AUDIO: R1046.1 U20.17
ACZ_SPKR: D25.2 R1009.2 R1010.1 U49.BD40
ACZ_SYNC: R1031.1 R1037.2 U49.BD43
ACZ_SYNC_AUDIO: R1037.1 U20.15
ADC_MUX_SEL: PR54.1 RG54.1 UG6.BG6
ADDR0: R456.1 U24.36
ADDR1: R465.1 U24.35
ADOGND: C397.1 C405.1 C407.1 C445.1 C469.2 C483.2 C486.1 C488.1 C489.1 C490.2 C494.1 C501.2 C749.1 C755.1 C762.1 C772.1 C778.2 C782.1 CN10.36 CN10.45 CN19.3 R950.1 R957.1 R966.1 R977.1 R990.1 R993.1 R995.1 R1007.1 R1011.1 R1012.1 R1151.1 U20.22 U20.37 U21.16 U21.20
ADP1_DET: PQ8.3 PR96.1 U23.80
ADP1_SW: PR95.1 PR412.2 PR468.2 PR475.2 PR476.2 PR502.1
ADP2_DET: PQ10.3 PR427.1 R493.2
ADP2_SW: PQ56.3 PR93.2 PR411.1 PR471.2 PR478.1 PR503.1
ADP_ID1: PJ8.4 PQ6.1(S)
ADP_ID2: PJ9.4 PQ40.1(S)
ADRS0: PR10.2 PR368.2 PU2.21
ADRS1: PC292.1 PR3.1 PR7.2 PR15.1 PU2.22
AFS: R30.2 R31.2 R35.1 U36.28
AMP_MUTE#: D21.1(CATHODE) D37.1(CATHODE) R418.1 U23.108
ASEL: R518.1 R535.1 U21.14
AUD_AZACPU_SCLK: C728.1 R795.1 R905.2 U42.B32
AUD_AZACPU_SCLK_R: R905.1 U49.AJ3
AUD_AZACPU_SDI: R796.1 U49.AK4
AUD_AZACPU_SDI_R: R796.2 U42.A32
AUD_AZACPU_SDO: R797.1 R885.2 U42.A31
AUD_AZACPU_SDO_R: R885.1 U49.AJ5
B_CTL: Q2.5 Q36.2 Q66.2 Q76.2 Q77.3 R1.1 R302.1 R653.1 R709.1 R710.2
B_CTL_LOGO: Q127.2 R1217.1 U1.30
B_CTL_LOGO_C: CN1.10 R1214.1
B_CTL_MCU: Q77.2 R710.1 R712.2 U1.23
B_CTL_TURBO: Q86.2 R734.1
B_CTL_TURBO_C: CN1.13 R729.1 U1.25
B_CTRL_LEFT: CN14.4 R330.1
B_CTRL_RIGHT: CN22.4 R650.1
B_DE: R1155.2 R1156.1 U55.8
B_EQ1: R1135.1 R1136.2 U55.20
B_EQ2: R1164.1 R1165.2 U55.17
BAT-V: PC247.1 PC248.1 PC249.1 PC250.1 PC251.1 PC252.1 PC253.1 PD3.2 PJ19.8 PJ19.9 PJ19.10 PR623.2 PR631.2
BATLED0#: CN1.23 D7.1 U23.29
BATLED1#: CN1.24 D8.1 R538.2
BATLOW#: R1080.2 U49.AG45
BATTERY_LEARN: PQ56.2 R735.2 U23.77
BEEP1: D25.1(CATHODE) D26.1(CATHODE) R394.1
BEEP2: C406.1 C423.1 R394.2 R401.1
BEEP3: C423.2 U20.34
BFS: R28.2 R29.2 R36.1 U36.27
BI: PJ19.7 PR329.2 R615.1
BI_GATE: C524.1 Q53.5 Q56.2 R610.2 R612.1 R616.1 SW2.3 SW2.4
BIT_CLK_AUDIO: R525.2 R1021.1
BIT_CLK_AUDIO_U: C484.1 R525.1 U20.14
BKL_PWM_GFX: QG2.6 R87.2 U4.6(Y2)
BL_ON: CN2.33 U40.4
BOARD_ID0_R: C32.1 CN2.31 R72.2
BOARD_ID1_R: C33.1 CN2.32 R73.2
BRD_ID0: R72.1 R1098.2 R1123.1 U49.V46
BRD_ID1: R73.1 R1096.2 R1121.1 U49.U46
BRD_ID2: R1097.2 R1122.1 U49.U47
BRD_ID3: R1092.2 R1120.1 U49.T45
BRD_ID4: R1094.2 R1125.1 U49.T46
BRD_ID5: R1091.2 R1119.1 U49.T48
BRD_ID6: R1095.2 R1118.1 U49.T47
BRD_ID7: R1093.2 R1134.1 U49.R46
BRD_ID8: R512.1 R513.2 U49.V35
BRD_ID9: R529.1 R530.2 U49.V37
BRD_ID10: R541.1 R542.2 U49.Y39
BRD_ID11: R554.1 R555.2 U49.Y41
BRD_ID12: R572.1 R573.2 U49.W42
BRIGHT: CN2.34 R736.1 R748.2 U4.1
BRIGHT_EC: R748.1 U23.28
BSTAUX1: PC245.2 PR321.2
BSTAUX2: PC271.2 PR349.2
BT_EN: R474.1 R947.2
BT_EN_R: CN12.54(W_DISABLE2#) R938.1 R943.1 R947.1
BT_OFF_PCH#: R943.2 R984.1 U49.AW35
BV_REF: PC283.1 PR4.1 PR5.2 PR18.1 PR26.1 PR32.2
C10_WAKE: R804.2 TP133.1 U49.AJ4
C10_WAKE_CPU: R804.1 U42.CU23
C_INT_DP_AUXN: C561.1 CN24.18 ESD1.2 ESD1.9 Q72.6 R677.2 R1185.2 U56.25
C_INT_DP_AUXP: C560.1 CN24.16 ESD1.1 ESD1.10(NC#4) Q71.6 R676.1 R1184.2 U56.24
C_OUT_DP_TXN0: C861.1 CN24.5 D74.2
C_OUT_DP_TXN1: C865.1 CN24.11 D76.2
C_OUT_DP_TXN2: C863.1 CN24.17 D77.2
C_OUT_DP_TXN3: C866.1 CN24.12(ML_L3-) D79.2
C_OUT_DP_TXP0: C862.1 CN24.3 D73.2
C_OUT_DP_TXP1: C868.1 CN24.9 D75.2
C_OUT_DP_TXP2: C864.1 CN24.15 D78.2
C_OUT_DP_TXP3: C867.1 CN24.10 D80.2
C_OUT_EDP_TXN0: C585.1 U36.33
C_OUT_EDP_TXN1: C583.1 U36.30
C_OUT_EDP_TXN2: C587.1 U36.24
C_OUT_EDP_TXN3: C589.1 U36.21
C_OUT_EDP_TXP0: C584.1 U36.34
C_OUT_EDP_TXP1: C582.1 U36.31
C_OUT_EDP_TXP2: C586.1 U36.25
C_OUT_EDP_TXP3: C588.1 U36.22
C_TX0_HDMI+: R601.1 U27.29
C_TX0_HDMI-: R600.1 U27.28
C_TX1_HDMI+: R603.1 U27.32
C_TX1_HDMI-: R602.1 U27.31
C_TX2_HDMI+: R605.1 U27.35
C_TX2_HDMI-: R604.1 U27.34
C_TXC_HDMI+: R599.1 U27.26
C_TXC_HDMI-: R598.1 U27.25
CAD_SNK: CN24.4 ESD1.5 ESD1.6 Q67.2 R668.1 R670.1 U34.2
CAD_SNK_R_DP: R664.2 R667.1 R668.2 U34.4 U56.29
CAP+: C471.2 U20.23
CAP-: C471.1 U20.24
CATERR#: R102.1 TP14.1 U42.H36
CCD_PWR: C34.2 C36.2 C37.1 CN2.36 R74.2
CFG0: TP107.1 U42.N36
CFG1: R93.1 TP7.1 U42.M37
CFG2: R99.1 U42.M35
CFG3: R96.1 TP8.1 U42.L37
CFG4: R768.1 U42.N39
CFG5: R94.1 U42.J35
CFG6: R780.1 U42.J38
CFG7: R770.1 U42.M38
CFG8: TP90.1 U42.J37
CFG9: R97.1 TP9.1 U42.M39
CFG10: R769.1 TP97.1 U42.N40
CFG11: R779.1 TP95.1 U42.L40
CFG12: TP106.1 U42.N41
CFG13: TP99.1 U42.J41
CFG14: R778.1 U42.L41
CFG15: TP87.1 U42.J40
CFG16: TP108.1 U42.L39
CFG17: TP98.1 U42.M41
CFG_RCOMP: R794.1 U42.A34
CHA_SA0: JDIM2.256 R297.1 R298.2
CHA_SA1: JDIM2.260 R237.1 R238.2
CHA_SA2: JDIM2.166 R296.1 R316.2
CHB_SA0: JDIM1.256 R120.2 R122.1
CHB_SA1: JDIM1.260 R131.2 R135.1
CHB_SA2: JDIM1.166 R134.1 R137.2
CLK_CPU_BCLKN: U42.D36 U49.A9
CLK_CPU_BCLKP: U42.C36 U49.B8
CLK_DPLL_NSCCLKN: R92.1 U49.D8
CLK_DPLL_NSCCLKN_C: R92.2 U42.D39
CLK_DPLL_NSCCLKP: R95.1 U49.C8
CLK_DPLL_NSCCLKP_C: R95.2 U42.C39
CLK_PCIE_LANN: CN10.5 U49.AE9
CLK_PCIE_LANP: CN10.6 U49.AE11
CLK_PCIE_SSD1N: R854.1 U49.V15
CLK_PCIE_SSD1N_R: CN6.53 R854.2
CLK_PCIE_SSD1P: R850.1 U49.V13
CLK_PCIE_SSD1P_R: CN6.55 R850.2
CLK_PCIE_SSDN: R992.1 U49.Y11
CLK_PCIE_SSDN_R: CN13.53 R992.2
CLK_PCIE_SSDP: R988.1 U49.Y9
CLK_PCIE_SSDP_R: CN13.55 R988.2
CLK_PCIE_WLANN: CN12.49 U49.AG13
CLK_PCIE_WLANP: CN12.47 U49.AG15
CLK_PCIE_WWANN: R890.2 U49.V4
CLK_PCIE_WWANP: R900.2 U49.W3
CLK_VGA_N: U49.V11 UG6.BK30
CLK_VGA_P: U49.U9 UG6.BJ30
CLR_CMOS: Q112.2 Q113.2 R1064.2 U23.19
CNV_BRI_DT: CN12.36 R878.1 R959.1 R960.2
CNV_BRI_DT_C: R878.2 U49.AV3
CNV_BRI_RSP: R914.1 R978.2 U49.AV4
CNV_BRI_RSP_R: CN12.22 R978.1
CNV_MFUART2_RXD: CN12.48 R352.1 R928.1
CNV_MFUART2_RXD_C: R352.2 U49.AU9
CNV_MFUART2_TXD: CN12.46 R916.1 R925.1
CNV_MFUART2_TXD_C: R916.2 U49.BA5
CNV_PA_BLANKING: CN12.44 R371.1 R920.1
CNV_PA_BLANKING_C: R371.2 U49.AU8
CNV_RF_RESET#: R491.1 R500.1 U26.1 U26.2 U49.BA33
CNV_RF_RESET_L: CN12.10 R491.2 U26.4
CNV_RGI_DT: CN12.32 R889.1 R967.1 R968.2
CNV_RGI_DT_C: R889.2 U49.AW3
CNV_RGI_RSP: R897.1 R971.2 U49.AW4
CNV_RGI_RSP_R: CN12.34 R971.1
CNV_WR_CLK_DN: CN12.21 U49.BC12
CNV_WR_CLK_DP: CN12.23 U49.BD12
CNV_WR_LANE0_DN: CN12.15 U49.BC13
CNV_WR_LANE0_DP: CN12.17 U49.BD13
CNV_WR_LANE1_DN: CN12.9 U49.BD11
CNV_WR_LANE1_DP: CN12.11 U49.BE11
CNV_WT_CLK_DN: CN12.71 U49.AW13
CNV_WT_CLK_DP: CN12.73 U49.AU14
CNV_WT_LANE0_DN: CN12.65 U49.BA14
CNV_WT_LANE0_DP: CN12.67 U49.AY15
CNV_WT_LANE1_DN: CN12.59 U49.AW15
CNV_WT_LANE1_DP: CN12.61 U49.AU16
CNV_WT_RCOMP: R949.2 U49.BE12
CPU_2_PCH_TRIG: R800.1 U49.AL3
CPU_C10_GATE#: Q32.3 Q93.2 R70.1 R310.2 R321.1 R751.1
CPU_EDP_HPD: R692.1 R909.1 U49.AT2
CPU_EDP_HPD_R: R692.2 U37.2
CPU_ID: R344.2 R354.1 U23.126
CPU_ID_64314600: TP111.1 U42.CT3
CPU_PCI_BCLKN: U42.B37 U49.A5
CPU_PCI_BCLKP: U42.C37 U49.A6
CPU_PLTRST#: R913.2 TP142.1 U49.AE3
CPU_PLTRST#R: R913.1 U42.CR25
CPU_RTC_CLK: R808.1 U49.AD1
CPU_RTC_CLK_R: R808.2 U42.CR22
CPU_VCCIO_PWR_GATE#: Q32.1(S) R309.2 R310.1 R320.1 U49.AV7
CRISIS_DISK_ENABLE: R455.1 R610.1
CSI_RCOMP: R776.1 U42.R35
CTL0_DP: R1181.2 R1182.2 U56.22
CTL1_DP: R661.1 R662.1 R663.2 U56.23
CTL2_1: R172.2 U7.7
CTL2_2: R168.2 U6.7
CTL2_3: R1113.1 U52.7
CTL3_1: R173.2 U7.8
CTL3_2: R167.2 U6.8
CTL3_3: R1114.1 U52.8
DBG_PMODE: R290.1 R291.2 U49.AG5
DC-DET: R503.1 R505.1 R519.1 U20.13
DCI_EN: R479.2 R486.1 U24.12
DDR0_VREF_CA0: C315.1 R279.1 U42.CR21
DDR1_VREF_CA0: C256.1 R180.1 U42.CU21
DDR4_DRAMRST#: C183.2 C295.2 JDIM1.108 JDIM2.108 R613.1 TP78.1
DDR4_DRAMRST#_PCH: R613.2 R1104.2 U49.AC46
DDR4_SUSON_2V5: PR539.1 R594.2 U23.57
DDR_THERMDA: C689.1 Q101.2 Q101.3 U46.2
DDR_THERMDC: C689.2 Q101.1(EMITTER) U46.3
DDR_VTT: C186.1 C190.1 C197.1 C199.1 C203.1 C209.1 C210.1 C211.1 C212.1 C309.1 C313.1 C314.1 JDIM1.258(VTT) JDIM2.258(VTT) PC508.1 PU38.2(VTTSNS) PU38.20
DDR_VTT_CTRL: R108.1 U42.CG12
DDR_VTTT_PG_CTRL: PR651.1 Q17.3 R111.2 R112.2 R113.2
DDSP_HPD1: R185.2 R325.1 U49.AU3
DDSP_HPD2: R288.2 R301.1 U49.AU4
DDSP_HPD3: R209.2 R393.1 U49.AP15
DDSP_HPD4: R405.1 U49.AK15
DEVSLP0_HDD: R1112.1 U49.N47
DEVSLP0_R: CN18.1 R1112.2
DEVSLP_N1: CN6.38 R894.1 R895.2
DEVSLP_N2: CN13.38 R1013.1
DEVSLP_SSD_PCH: R894.2 U49.M45
DGPU_EC_PROCHOT#: PR62.2 U23.122
DGPU_HOLD_RST#: R1089.1 TP166.1 U49.L46 UG1.1
DGPU_OPP#: C472.1 Q50.2 R520.2 U23.71
DGPU_OPP#_PROCHOT#: Q8.3 Q50.3 QG24.3
DGPU_OVT#: DG6.1(CATHODE) QG19.3 QG20.3 RG130.1
DGPU_PWR_EN: R1124.1 TP175.1 U49.K47 UG3.2 UG8.1 UG9.1
DGPU_PWROK: QG9.2 QG13.1(S) QG14.3 RG87.2
DGPU_PWROK_Q: QG13.3 R1088.1 TP168.1 U49.K46
DGPU_THER_ALERT#: QG18.3 R344.1
DIMM1_EVENT#: JDIM2.134 Q33.1(EMITTER) R294.1
DIMM2_EVENT#: JDIM1.134 Q19.1(EMITTER) R158.1
DISP_ON: Q84.2 R715.1 R814.2 TP4.1 U44.4
DMI_RCOMP_N: R107.1 U42.C5
DMI_RCOMP_P: R107.2 U42.C4
DMI_RXN0: U42.A8 U49.C32
DMI_RXN1: U42.B9 U49.C30
DMI_RXN2: U42.A10 U49.D30
DMI_RXN3: U42.B11 U49.B29
DMI_RXN4: U42.D13 U49.D29
DMI_RXN5: U42.A13 U49.C27
DMI_RXN6: U42.E14 U49.C26
DMI_RXN7: U42.B14 U49.A25
DMI_RXP0: U42.B8 U49.D32
DMI_RXP1: U42.C9 U49.D31
DMI_RXP2: U42.B10 U49.E30
DMI_RXP3: U42.C11 U49.C29
DMI_RXP4: U42.E13 U49.E28
DMI_RXP5: U42.B13 U49.D27
DMI_RXP6: U42.F14 U49.D26
DMI_RXP7: U42.C14 U49.C25
DMI_TXN0: U42.C6 U49.L31
DMI_TXN1: U42.D8 U49.H30
DMI_TXN2: U42.E9 U49.L29
DMI_TXN3: U42.D10 U49.J26
DMI_TXN4: U42.L11 U49.H26
DMI_TXN5: U42.G11 U49.R26
DMI_TXN6: U42.L13 U49.P22
DMI_TXN7: U42.H13 U49.L24
DMI_TXP0: U42.D6 U49.J32
DMI_TXP1: U42.E8 U49.F30
DMI_TXP2: U42.F9 U49.J29
DMI_TXP3: U42.E10 U49.L26
DMI_TXP4: U42.N11 U49.F26
DMI_TXP5: U42.H11 U49.P26
DMI_TXP6: U42.M13 U49.R22
DMI_TXP7: U42.J13 U49.J24
DMIC_CLK: C450.1 R62.1 R464.1
DMIC_CLK0: R432.2 U17.4 U49.AW21
DMIC_CLK_C: CN2.26 D4.1 R61.2 R62.2
DMIC_CLK_U: R464.2 U20.5
DMIC_DAT: C447.1 R60.1 R457.1
DMIC_DAT0: R460.2 R461.2 R478.1 U19.4 U49.AU21
DMIC_DAT_U: R457.2 U20.4
DMIC_DATA_C: CN2.25 D2.1 R59.2 R60.2
DNBSWON#: TP161.1 U23.123 U49.AH47
DP_D0: C850.1 UG6.BM16
DP_D0#: C851.1 UG6.BL16
DP_D1: C852.1 UG6.BL14
DP_D1#: C853.1 UG6.BK14
DP_D2: C854.1 UG6.BJ13
DP_D2#: C855.1 UG6.BK13
DP_D3: C856.1 UG6.BM13
DP_D3#: C857.1 UG6.BL13
DP_HPD: C559.1 CN24.2 ESD1.4 ESD1.7 R672.2
DP_HPD_PCH: CG365.1 Q28.3 R665.2 R672.1 RG61.2
DP_HPD_PCH_Q: Q28.1(S) R271.2 U49.AT13
DP_TXN0_R: C851.2 U56.10
DP_TXN1_R: C853.2 U56.13
DP_TXN2_R: C855.2 U56.16
DP_TXN3_R: C857.2 U56.19
DP_TXP0_R: C850.2 U56.9
DP_TXP1_R: C852.2 U56.12
DP_TXP2_R: C854.2 U56.15
DP_TXP3_R: C856.2 U56.18
DPEQ0_A1_DP: R656.2 R659.2 U56.14
DPEQ1_DP: R1183.2 R1186.2 U56.2
DPIHPD: R288.1 UG5.4(Y)
DPIP0_HPD: CG504.1 R755.2 R760.2 RG120.2
DPIP0_HPD_CPU: R754.1 R760.1 R1199.1 U42.AE38
DPIP0_HPD_CPU_R: Q121.3 R1206.2 UG4.1
DPIP0_RCOMP: R777.1 U42.AT40
DPIP1_HPD: CG382.1 R755.1 R761.2 RG70.2
DPIP1_HPD_CPU: R757.1 R761.1 R1201.1 U42.AE35
DPIP1_HPD_CPU_R: Q122.3 R1207.2 UG4.2
DPIP1_RCOMP: R787.1 U42.AU39
DPIP2_HPD: CG292.1 R762.2 RG45.2
DPIP2_HPD_CPU: R758.1 R762.1 R1204.1 U42.AE37
DPIP2_HPD_CPU_R: Q123.3 R1208.2 UG5.2
DPIP2_RCOMP: R781.1 U42.AU40
DPIP3_HPD_CPU: R783.1 U42.AC35
DPIP3_RCOMP: R786.1 U42.AT41
DPWROK_EC: R1102.1 U23.119
DPWROK_EC_R: R1102.2 R1127.1 TP172.1 U49.AB46
DRMOS_IMON1: PR244.1 PU31.38
DRMOS_IMON2: PR237.1 PU32.38
DRMOS_IMON3: PR226.2 PU33.38
DRMOS_IMON4: PR223.2 PU34.38
DRMOS_IMON5: PR211.2 PU35.38
DRMOS_IMON6: PR203.2 PU36.38
DRMOS_IMON7: PR197.2 PU29.38
DRMOS_IMON8: PR190.2 PU30.38
DRMOS_REFIN: PC159.2 PC160.2 PC161.2 PC162.2 PC164.2 PC168.2 PC174.2 PC181.2 PC191.1 PR187.1 PR193.1 PR199.1 PR205.1 PR213.1 PR224.1 PR227.1 PR228.2 PR235.1 PR242.2 PR250.1 PR570.1 PR572.1 PR579.2 PR584.2 PR589.2 PR594.2 PR599.2 PR604.2
DRVON: PC305.2 PR458.1 PR459.1 PR460.1 PR461.1 PR462.1 PR463.1 PU20.24
EAPD: D31.1(CATHODE) R372.1 R503.2
EAR#: R91.2 R766.2 U42.F36
EC_FPBACK: U23.86 U39.2
EC_GPI2: R539.1 R540.1 U23.68
EC_HRST: Q21.2 R594.1
EC_I2C_INT_D: Q22.1(S) R193.2 R203.1 TP33.1 U11.D1
EC_I2C_SCL_D: Q20.1(S) R178.2 R200.1 TP31.1 U11.E1
EC_I2C_SDA_D: Q20.4 R159.2 R192.1 TP29.1 U11.F1
EC_PECI: C729.1 R364.1 R911.1 U42.CP25
EC_PECI_PCH: R893.1 R911.2 U49.AH3
EC_PECI_R: R364.2 U23.117
EC_PWROK: R622.2 R623.2 R624.2 R626.2 U23.33 U30.1
EC_PWROK_R: C538.1 R626.1 R632.1 R1085.1 R1133.2 TP173.1 U49.AB47
ECAGND: C464.2 C465.1 C504.2 L13.2 U23.75
EDP_AUX#_C: C594.2 CN2.6 R52.1 R53.2
EDP_AUX#_C_R: C594.1 U37.9
EDP_AUX_C: C595.1 CN2.5 R50.1 R51.2
EDP_AUX_C_R: C595.2 U37.7
EDP_HPD_PANEL: C28.1 Q6.2 R37.1 R42.2 R71.1 U37.4
EDP_HPD_R: CN2.30 R71.2
EDP_I2C_CLK: QG10.3 R55.1
EDP_I2C_CLK_C: CN2.22 R55.2 R56.2 R727.2
EDP_I2C_DATA: QG10.6 R57.1
EDP_I2C_DATA_C: CN2.23 R57.2 R58.2
EDP_RCOMP: R785.1 U42.BC38
EDP_TXN0_C: C585.2 CN2.9
EDP_TXN1_C: C583.2 CN2.12
EDP_TXN2_C: C587.2 CN2.15
EDP_TXN3_C: C589.2 CN2.18
EDP_TXP0_C: C584.2 CN2.8
EDP_TXP1_C: C582.2 CN2.11
EDP_TXP2_C: C586.2 CN2.14
EDP_TXP3_C: C588.2 CN2.17
EN: C839.2 R1145.1 U55.7
EN_U3: R462.1 U24.11
ESPI_0: R1161.2 U23.10
ESPI_0_R: R1161.1 U49.AN46
ESPI_1: R1075.2 U23.9
ESPI_1_R: R1075.1 U49.AN45
ESPI_2: R1074.2 U23.8
ESPI_2_R: R1074.1 U49.AP47
ESPI_3: R1162.2 U23.7
ESPI_3_R: R1162.1 U49.AP46
ESPI_ALERT0#: R1078.1 TP163.1 U49.AU46
ESPI_ALERT1#: TP170.1 U49.AU45
ESPI_CLK: C840.1 R440.2 R1163.2 U23.13
ESPI_CLK_R: R1163.1 U49.AR47
ESPI_CS1#: R1077.1 TP169.1 U49.AT46
ESPI_CS#: R1076.2 U23.6
ESPI_CS#_R: R1076.1 U49.AR46
ESPI_RESET#: R509.1 R565.2
ESPI_RESET#_R: R565.1 U49.AT45
FAN1_PWM: Q99.1(EMITTER) U23.32
FAN1_PWM_Q: C690.1 CN3.3 Q99.3 R818.2
FAN1_RPM: Q100.1(S) R817.2 R820.1 U23.47
FAN2_PWM: Q35.1(EMITTER) U23.31
FAN2_PWM_Q: C321.1 CN8.3 Q35.3 R283.2
FAN2_RPM: Q31.1(S) R272.2 R274.1 U23.48
FB_CAL_PD_VDDQ: RG34.2 UG6.W47
FB_CAL_PU_GND: RG35.2 UG6.Y47
FB_CAL_TERM_GND: RG31.2 UG6.W48
FB_VREF_PROBE: CG165.2 RG30.2 UG6.W49
FBA_CMD0: UG6.Y53 VRAM6.J4
FBA_CMD1: UG6.AA56 VRAM6.H3
FBA_CMD2: UG6.AB55 VRAM6.J3
FBA_CMD3: RG28.1 UG6.AB56 VRAM6.J1
FBA_CMD4: UG6.AC56 VRAM6.K3
FBA_CMD5: UG6.AC53 VRAM6.L3
FBA_CMD6: UG6.AD56 VRAM6.K4
FBA_CMD7: UG6.AE55 VRAM6.M4
FBA_CMD8: UG6.AE56 VRAM6.L5
FBA_CMD9: UG6.AF56 VRAM6.K5
FBA_CMD10: UG6.AF53 VRAM6.J5
FBA_CMD11: UG6.AG56 VRAM6.H5
FBA_CMD12: UG6.AH55 VRAM6.G4
FBA_CMD13: UG6.AH56 VRAM6.G11
FBA_CMD14: RG37.2 UG6.AJ56 VRAM6.G10
FBA_CMD15: UG6.AJ53 VRAM6.H10
FBA_CMD16: UG6.AK56 VRAM6.L10
FBA_CMD17: RG39.2 UG6.AL55 VRAM6.M10
FBA_CMD18: UG6.AL56 VRAM6.M11
FBA_CMD19: UG6.AM56 VRAM6.K11
FBA_CMD20: UG6.AM53 VRAM6.L12
FBA_CMD21: UG6.AN56 VRAM6.K12
FBA_CMD22: UG6.AP55 VRAM6.J12
FBA_CMD23: UG6.AP56 VRAM6.J11
FBA_CMD24: UG6.AR56 VRAM6.H12
FBA_CMD28: UG6.BM56 VRAM8.K4
FBA_CMD29: UG6.BM55 VRAM8.L3
FBA_CMD30: UG6.BL56 VRAM8.K3
FBA_CMD31: RG132.1 UG6.BK55 VRAM8.J1
FBA_CMD32: UG6.BK56 VRAM8.J3
FBA_CMD33: UG6.BJ56 VRAM8.H3
FBA_CMD34: UG6.BJ55 VRAM8.J4
FBA_CMD35: UG6.BH56 VRAM8.G4
FBA_CMD36: UG6.BG53 VRAM8.H5
FBA_CMD37: UG6.BG56 VRAM8.J5
FBA_CMD38: UG6.BF56 VRAM8.K5
FBA_CMD39: UG6.BF55 VRAM8.L5
FBA_CMD40: UG6.BE56 VRAM8.M4
FBA_CMD41: RG51.2 UG6.BD53 VRAM8.M10
FBA_CMD42: UG6.BD56 VRAM8.L10
FBA_CMD43: UG6.BC56 VRAM8.H10
FBA_CMD44: RG50.2 UG6.BC55 VRAM8.G10
FBA_CMD45: UG6.BB56 VRAM8.G11
FBA_CMD46: UG6.BA53 VRAM8.H12
FBA_CMD47: UG6.BA56 VRAM8.J11
FBA_CMD48: UG6.AY56 VRAM8.J12
FBA_CMD49: UG6.AY55 VRAM8.K12
FBA_CMD50: UG6.AW56 VRAM8.L12
FBA_CMD51: UG6.AV53 VRAM8.K11
FBA_CMD52: UG6.AV56 VRAM8.M11
FBA_DBI0: UG6.AE50 VRAM6.R2
FBA_DBI1: UG6.AB50 VRAM6.D2
FBA_DBI2: UG6.AL50 VRAM6.R13
FBA_DBI3: UG6.AH50 VRAM6.D13
FBA_DBI4: UG6.BC50 VRAM8.R2
FBA_DBI5: UG6.BF50 VRAM8.D2
FBA_DBI6: UG6.AU50 VRAM8.R13
FBA_DBI7: UG6.AY50 VRAM8.D13
FBA_EDC0: UG6.AE53 VRAM6.T2
FBA_EDC1: UG6.AB53 VRAM6.C2
FBA_EDC2: UG6.AL53 VRAM6.T13
FBA_EDC3: UG6.AH53 VRAM6.C13
FBA_EDC4: UG6.BC53 VRAM8.T2
FBA_EDC5: UG6.BF53 VRAM8.C2
FBA_EDC6: UG6.AU53 VRAM8.T13
FBA_EDC7: UG6.AY53 VRAM8.C13
FBA_VREFC: RG29.1 VRAM6.K1
FBA_VREFC_H: RG131.1 VRAM8.K1
FBA_ZQ_1_A: RG40.1 VRAM6.J14
FBA_ZQ_1_B: RG41.1 VRAM6.K14(ZQ_B)
FBA_ZQ_2_A: RG43.1 VRAM8.J14
FBA_ZQ_2_B: RG46.1 VRAM8.K14(ZQ_B)
FBB_CMD0: UG6.B37 VRAM1.J4
FBB_CMD1: UG6.A37 VRAM1.H3
FBB_CMD2: UG6.A38 VRAM1.J3
FBB_CMD3: RG11.1 UG6.D38 VRAM1.J1
FBB_CMD4: UG6.A39 VRAM1.K3
FBB_CMD5: UG6.B40 VRAM1.L3
FBB_CMD6: UG6.A40 VRAM1.K4
FBB_CMD7: UG6.A41 VRAM1.M4
FBB_CMD8: UG6.D41 VRAM1.L5
FBB_CMD9: UG6.A42 VRAM1.K5
FBB_CMD10: UG6.B43 VRAM1.J5
FBB_CMD11: UG6.A43 VRAM1.H5
FBB_CMD12: UG6.A44 VRAM1.G4
FBB_CMD13: UG6.D44 VRAM1.G11
FBB_CMD14: RG3.2 UG6.A45 VRAM1.G10
FBB_CMD15: UG6.B46 VRAM1.H10
FBB_CMD16: UG6.A46 VRAM1.L10
FBB_CMD17: RG17.2 UG6.A47 VRAM1.M10
FBB_CMD18: UG6.D47 VRAM1.M11
FBB_CMD19: UG6.A48 VRAM1.K11
FBB_CMD20: UG6.B49 VRAM1.L12
FBB_CMD21: UG6.A49 VRAM1.K12
FBB_CMD22: UG6.B50 VRAM1.J12
FBB_CMD23: UG6.A50 VRAM1.J11
FBB_CMD24: UG6.C50 VRAM1.H12
FBB_CMD28: UG6.Y56 VRAM4.K4
FBB_CMD29: UG6.W56 VRAM4.L3
FBB_CMD30: UG6.W55 VRAM4.K3
FBB_CMD31: RG25.1 UG6.V56 VRAM4.J1
FBB_CMD32: UG6.U53 VRAM4.J3
FBB_CMD33: UG6.U56 VRAM4.H3
FBB_CMD34: UG6.T56 VRAM4.J4
FBB_CMD35: UG6.T55 VRAM4.G4
FBB_CMD36: UG6.R56 VRAM4.H5
FBB_CMD37: UG6.P53 VRAM4.J5
FBB_CMD38: UG6.P56 VRAM4.K5
FBB_CMD39: UG6.N56 VRAM4.L5
FBB_CMD40: UG6.N55 VRAM4.M4
FBB_CMD41: RG20.2 UG6.M56 VRAM4.M10
FBB_CMD42: UG6.L53 VRAM4.L10
FBB_CMD43: UG6.L56 VRAM4.H10
FBB_CMD44: RG21.2 UG6.K56 VRAM4.G10
FBB_CMD45: UG6.K55 VRAM4.G11
FBB_CMD46: UG6.J56 VRAM4.H12
FBB_CMD47: UG6.H53 VRAM4.J11
FBB_CMD48: UG6.H56 VRAM4.J12
FBB_CMD49: UG6.G56 VRAM4.K12
FBB_CMD50: UG6.G55 VRAM4.L12
FBB_CMD51: UG6.E56 VRAM4.K11
FBB_CMD52: UG6.B54 VRAM4.M11
FBB_DBI0: UG6.F38 VRAM1.R2
FBB_DBI1: UG6.F35 VRAM1.D2
FBB_DBI2: UG6.G46 VRAM1.R13
FBB_DBI3: UG6.G43 VRAM1.D13
FBB_DBI4: UG6.N50 VRAM4.R2
FBB_DBI5: UG6.T50 VRAM4.D2
FBB_DBI6: UG6.E49 VRAM4.R13
FBB_DBI7: UG6.K50 VRAM4.D13
FBB_EDC0: UG6.C38 VRAM1.T2
FBB_EDC1: UG6.C35 VRAM1.C2
FBB_EDC2: UG6.D46 VRAM1.T13
FBB_EDC3: UG6.D43 VRAM1.C13
FBB_EDC4: UG6.N53 VRAM4.T2
FBB_EDC5: UG6.T53 VRAM4.C2
FBB_EDC6: UG6.E53 VRAM4.T13
FBB_EDC7: UG6.K53 VRAM4.C13
FBB_FB_TCK0: TPG15.1 VRAM1.N5
FBB_FB_TDI0: TPG3.1 VRAM1.F10
FBB_FB_TDO0: TPG17.1 VRAM1.N10
FBB_FB_TMS0: TPG1.1 VRAM1.F5
FBB_VREFC: RG15.1 VRAM1.K1
FBB_VREFC_H: RG24.1 VRAM4.K1
FBB_ZQ_1_A: RG7.1 VRAM1.J14
FBB_ZQ_1_B: RG12.1 VRAM1.K14(ZQ_B)
FBB_ZQ_2_A: RG112.1 VRAM4.J14
FBB_ZQ_2_B: RG111.1 VRAM4.K14(ZQ_B)
FBC_CMD0: UG6.B5 VRAM3.J4
FBC_CMD1: UG6.A5 VRAM3.H3
FBC_CMD2: UG6.C5 VRAM3.J3
FBC_CMD3: RG108.1 UG6.A6 VRAM3.J1
FBC_CMD4: UG6.B7 VRAM3.K3
FBC_CMD5: UG6.A7 VRAM3.L3
FBC_CMD6: UG6.A8 VRAM3.K4
FBC_CMD7: UG6.D8 VRAM3.M4
FBC_CMD8: UG6.A9 VRAM3.L5
FBC_CMD9: UG6.B10 VRAM3.K5
FBC_CMD10: UG6.A10 VRAM3.J5
FBC_CMD11: UG6.A11 VRAM3.H5
FBC_CMD12: UG6.D11 VRAM3.G4
FBC_CMD13: UG6.A12 VRAM3.G11
FBC_CMD14: RG4.2 UG6.B13 VRAM3.G10
FBC_CMD15: UG6.A13 VRAM3.H10
FBC_CMD16: UG6.A14 VRAM3.L10
FBC_CMD17: RG18.2 UG6.D14 VRAM3.M10
FBC_CMD18: UG6.A15 VRAM3.M11
FBC_CMD19: UG6.B16 VRAM3.K11
FBC_CMD20: UG6.A16 VRAM3.L12
FBC_CMD21: UG6.A17 VRAM3.K12
FBC_CMD22: UG6.D17 VRAM3.J12
FBC_CMD23: UG6.A18 VRAM3.J11
FBC_CMD24: UG6.B19 VRAM3.H12
FBC_CMD28: UG6.A36 VRAM2.K4
FBC_CMD29: UG6.D35 VRAM2.L3
FBC_CMD30: UG6.A35 VRAM2.K3
FBC_CMD31: RG10.1 UG6.A34 VRAM2.J1
FBC_CMD32: UG6.B34 VRAM2.J3
FBC_CMD33: UG6.A33 VRAM2.H3
FBC_CMD34: UG6.D32 VRAM2.J4
FBC_CMD35: UG6.A32 VRAM2.G4
FBC_CMD36: UG6.A31 VRAM2.H5
FBC_CMD37: UG6.B31 VRAM2.J5
FBC_CMD38: UG6.A30 VRAM2.K5
FBC_CMD39: UG6.D29 VRAM2.L5
FBC_CMD40: UG6.A29 VRAM2.M4
FBC_CMD41: RG5.2 UG6.A28 VRAM2.M10
FBC_CMD42: UG6.B28 VRAM2.L10
FBC_CMD43: UG6.A27 VRAM2.H10
FBC_CMD44: RG19.2 UG6.D26 VRAM2.G10
FBC_CMD45: UG6.A26 VRAM2.G11
FBC_CMD46: UG6.A25 VRAM2.H12
FBC_CMD47: UG6.B25 VRAM2.J11
FBC_CMD48: UG6.A24 VRAM2.J12
FBC_CMD49: UG6.D23 VRAM2.K12
FBC_CMD50: UG6.A23 VRAM2.L12
FBC_CMD51: UG6.A22 VRAM2.K11
FBC_CMD52: UG6.B22 VRAM2.M11
FBC_DBI0: UG6.G7 VRAM3.R2
FBC_DBI1: UG6.E3 VRAM3.D2
FBC_DBI2: UG6.G16 VRAM3.R13
FBC_DBI3: UG6.G13 VRAM3.D13
FBC_DBI4: UG6.F29 VRAM2.R2
FBC_DBI5: UG6.F32 VRAM2.D2
FBC_DBI6: UG6.G19 VRAM2.R13
FBC_DBI7: UG6.G25 VRAM2.D13
FBC_EDC0: UG6.D7 VRAM3.T2
FBC_EDC1: UG6.B3 VRAM3.C2
FBC_EDC2: UG6.D16 VRAM3.T13
FBC_EDC3: UG6.D13 VRAM3.C13
FBC_EDC4: UG6.C29 VRAM2.T2
FBC_EDC5: UG6.C32 VRAM2.C2
FBC_EDC6: UG6.D19 VRAM2.T13
FBC_EDC7: UG6.D25 VRAM2.C13
FBC_VREFC: RG16.1 VRAM3.K1
FBC_VREFC_H: RG6.1 VRAM2.K1
FBC_ZQ_1_A: RG9.1 VRAM3.J14
FBC_ZQ_1_B: RG13.1 VRAM3.K14(ZQ_B)
FBC_ZQ_2_A: RG14.1 VRAM2.J14
FBC_ZQ_2_B: RG8.1 VRAM2.K14(ZQ_B)
FBD_CMD0: UG6.AU1 VRAM7.J4
FBD_CMD1: UG6.AU4 VRAM7.H3
FBD_CMD2: UG6.AT1 VRAM7.J3
FBD_CMD3: RG115.1 UG6.AR2 VRAM7.J1
FBD_CMD4: UG6.AR1 VRAM7.K3
FBD_CMD5: UG6.AP1 VRAM7.L3
FBD_CMD6: UG6.AP4 VRAM7.K4
FBD_CMD7: UG6.AN1 VRAM7.M4
FBD_CMD8: UG6.AM2 VRAM7.L5
FBD_CMD9: UG6.AM1 VRAM7.K5
FBD_CMD10: UG6.AL1 VRAM7.J5
FBD_CMD11: UG6.AL4 VRAM7.H5
FBD_CMD12: UG6.AK1 VRAM7.G4
FBD_CMD13: UG6.AJ2 VRAM7.G11
FBD_CMD14: RG36.2 UG6.AJ1 VRAM7.G10
FBD_CMD15: UG6.AH1 VRAM7.H10
FBD_CMD16: UG6.AH4 VRAM7.L10
FBD_CMD17: RG38.2 UG6.AG1 VRAM7.M10
FBD_CMD18: UG6.AF2 VRAM7.M11
FBD_CMD19: UG6.AF1 VRAM7.K11
FBD_CMD20: UG6.AE1 VRAM7.L12
FBD_CMD21: UG6.AE4 VRAM7.K12
FBD_CMD22: UG6.AD1 VRAM7.J12
FBD_CMD23: UG6.AC2 VRAM7.J11
FBD_CMD24: UG6.AC1 VRAM7.H12
FBD_CMD28: UG6.G2 VRAM5.K4
FBD_CMD29: UG6.G1 VRAM5.L3
FBD_CMD30: UG6.G3 VRAM5.K3
FBD_CMD31: RG109.1 UG6.H1 VRAM5.J1
FBD_CMD32: UG6.H2 VRAM5.J3
FBD_CMD33: UG6.J1 VRAM5.H3
FBD_CMD34: UG6.K4 VRAM5.J4
FBD_CMD35: UG6.K1 VRAM5.G4
FBD_CMD36: UG6.K2 VRAM5.H5
FBD_CMD37: UG6.L1 VRAM5.J5
FBD_CMD38: UG6.L2 VRAM5.K5
FBD_CMD39: UG6.M1 VRAM5.L5
FBD_CMD40: UG6.N4 VRAM5.M4
FBD_CMD41: RG23.2 UG6.N1 VRAM5.M10
FBD_CMD42: UG6.P1 VRAM5.L10
FBD_CMD43: UG6.P2 VRAM5.H10
FBD_CMD44: RG22.2 UG6.R1 VRAM5.G10
FBD_CMD45: UG6.T4 VRAM5.G11
FBD_CMD46: UG6.T1 VRAM5.H12
FBD_CMD47: UG6.U1 VRAM5.J11
FBD_CMD48: UG6.U2 VRAM5.J12
FBD_CMD49: UG6.V1 VRAM5.K12
FBD_CMD50: UG6.W4 VRAM5.L12
FBD_CMD51: UG6.W1 VRAM5.K11
FBD_CMD52: UG6.Y1 VRAM5.M11
FBD_DBI0: UG6.AM7 VRAM7.R2
FBD_DBI1: UG6.AV7 VRAM7.D2
FBD_DBI2: UG6.AF7 VRAM7.R13
FBD_DBI3: UG6.AJ7 VRAM7.D13
FBD_DBI4: UG6.P7 VRAM5.R2
FBD_DBI5: UG6.L7 VRAM5.D2
FBD_DBI6: UG6.Y7 VRAM5.R13
FBD_DBI7: UG6.U7 VRAM5.D13
FBD_EDC0: UG6.AM4 VRAM7.T2
FBD_EDC1: UG6.AV4 VRAM7.C2
FBD_EDC2: UG6.AF4 VRAM7.T13
FBD_EDC3: UG6.AJ4 VRAM7.C13
FBD_EDC4: UG6.P4 VRAM5.T2
FBD_EDC5: UG6.L4 VRAM5.C2
FBD_EDC6: UG6.Y4 VRAM5.T13
FBD_EDC7: UG6.U4 VRAM5.C13
FBD_VREFC: RG42.1 VRAM7.K1
FBD_VREFC_H: RG110.1 VRAM5.K1
FBD_ZQ_1_A: RG33.1 VRAM7.J14
FBD_ZQ_1_B: RG32.1 VRAM7.K14(ZQ_B)
FBD_ZQ_2_A: RG26.1 VRAM5.J14
FBD_ZQ_2_B: RG27.1 VRAM5.K14(ZQ_B)
FBVDD_EN: PR50.2 UG2.4(Y)
FBVDD_PSI: PR382.2 RG126.1 RG127.1 UG6.BG3
FBVDDQ_SENSE: PR113.1 UG6.E54
FLIP_DP: R1179.2 R1180.2 U56.21
FRM_LCK#: Q82.1(S) RG176.1 UG6.BM2
FVDDQ_SENSE_I: PR79.2 PR435.1
FVDDQ_SENSE_V: PR47.2 PR74.1 PR82.2 PR444.1
G5719LX2.5V: PL22.1 PU37.3
G_CTL: Q4.2 Q34.2 Q65.2 Q73.2 Q78.3 R26.1 R278.1 R652.1 R681.1 R714.2
G_CTL_LOGO: Q126.2 R1216.1 U1.31
G_CTL_LOGO_C: CN1.18 R1213.1
G_CTL_MCU: Q78.5 R714.1 R716.2 U1.22
G_CTL_TURBO: Q81.2 R725.1
G_CTL_TURBO_C: CN1.14 R724.1 U1.26
G_CTRL_LEFT: CN14.3 R322.1
G_CTRL_RIGHT: CN22.3 R654.1
GC6FBEN: QG21.5 QG23.2 RG180.1 UG2.1 UG6.BN3
GC6FBEN_Q: QG22.3 R1090.1 TP164.1 U49.N46
GEN2_MODE: PR39.2 PR41.2 PU2.26
GFX_SCL: QG11.4 RG100.1 UG6.BL8
GFX_SDA: QG11.1(S) RG86.1 UG6.BL7
GPD_7: R575.2 R1073.1 R1079.2 U49.AL46
GPIO14_IFPA_HPD_TBT: QG17.3 RG124.2 UG6.BJ6
GPIO14_IFPA_HPD_TBT_Q: QG17.2 RG119.1 RG120.1
GPIO15_IFPB_HPD_TBT: QG7.3 RG62.2 UG6.BJ5
GPIO15_IFPB_HPD_TBT_Q: QG7.2 RG70.1 RG78.1
GPIO17_IFPD_HPD_EDP: QG4.3 RG48.2 UG6.BJ3
GPIO17_IFPD_HPD_EDP_Q: QG4.2 RG47.1 RG49.1
GPIO18_IFPE_HPD_DP: QG6.3 RG59.2 UG6.BJ2
GPIO18_IFPE_HPD_DP_Q: QG6.2 RG60.1 RG61.1
GPIO24_IFPF_HPD: QG3.3 RG63.2 RG144.1 UG6.BG4
GPIO24_IFPF_HPD_Q: QG3.2 RG44.1 RG45.1
GPIO26_SPI_WP#: RG118.1 RG122.2 TPG51.1 UG6.BG2 UG7.3
GPIO27_IFPC_HPD_HDMI: QG5.3 RG52.2 UG6.BG1
GPIO27_IFPC_HPD_HDMI_Q: QG5.2 RG53.1 RG55.1
GPP_B18: R524.1 R532.2 U49.AU36
GPP_B22: R546.2 R553.1 U49.AW41
GPP_D1: TP64.1 U49.AW32
GPP_G2: TP177.1 U49.BE15
GPP_G10: TP54.1 U49.BA17
GPP_G11: R952.2 R953.1 U49.AY17
GPP_G14: TP55.1 U49.AN21
GPP_G15: R433.2 R437.1 U49.AL21
GPP_H18: R931.2 R932.1 U49.BE3
GPS_EN#_EC: CN7.26 R576.1 R596.1 R865.2
GPU_ADC_INN: CG521.2 PR13.2 UG6.BR10
GPU_ADC_INP: CG522.2 PR8.2 UG6.BP10
GPU_CLK: C475.1 UG6.BL17
GPU_CLK#: C474.1 UG6.BK17
GPU_CLK#_C: C474.2 U27.14
GPU_CLK_C: C475.2 U27.13
GPU_D0: C477.1 UG6.BM19
GPU_D0#: C476.1 UG6.BL19
GPU_D0#_C: C476.2 U27.11
GPU_D0_C: C477.2 U27.10
GPU_D1: C479.1 UG6.BJ19
GPU_D1#: C478.1 UG6.BK19
GPU_D1#_C: C478.2 U27.8
GPU_D1_C: C479.2 U27.7
GPU_D2: C481.1 UG6.BL20
GPU_D2#: C480.1 UG6.BK20
GPU_D2#_C: C480.2 U27.5
GPU_D2_C: C481.2 U27.4
GPU_DDCCLK: Q117.4 R1174.2 RG154.1 UG6.BL10
GPU_DDCDATA: Q117.1(S) R1173.1 RG155.1 UG6.BM10
GPU_EDP_AUXN: R708.2 RG157.1 UG6.BL11
GPU_EDP_AUXN_R: R708.1 U37.10
GPU_EDP_AUXP: R707.1 RG156.1 UG6.BM11
GPU_EDP_AUXP_R: R707.2 U37.6
GPU_EDP_TXN0: C580.1 UG6.BT19
GPU_EDP_TXN0_R: C580.2 U36.36
GPU_EDP_TXN1: C574.1 UG6.BP19
GPU_EDP_TXN1_R: C574.2 U36.2
GPU_EDP_TXN2: C568.1 UG6.BR17
GPU_EDP_TXN2_R: C568.2 U36.11
GPU_EDP_TXN3: C566.1 UG6.BT16
GPU_EDP_TXN3_R: C566.2 U36.17
GPU_EDP_TXP0: C581.1 UG6.BT20
GPU_EDP_TXP0_R: C581.2 U36.35
GPU_EDP_TXP1: C573.1 UG6.BR19
GPU_EDP_TXP1_R: C573.2 U36.1
GPU_EDP_TXP2: C567.1 UG6.BP17
GPU_EDP_TXP2_R: C567.2 U36.10
GPU_EDP_TXP3: C565.1 UG6.BT17
GPU_EDP_TXP3_R: C565.2 U36.16
GPU_EVENT#: TP162.1 U49.L45
GPU_THERMDA: C578.1 Q11.2 Q11.3 U35.2
GPU_THERMDC: C578.2 Q11.1(EMITTER) U35.3
GPU_THROTTING#: DG2.1(CATHODE) PR648.1 RG168.1
GPU_TSENSE: PR206.1 PR574.1 PR577.1 PR581.2 PR586.2 PR591.2 PR596.2 PR601.2 PR606.2
GPUT_CLK: QG11.3 R357.2
GPUT_DATA: QG11.6 R356.2
H_CPU_SVIDALRT#: R790.1 U42.F32
H_CPU_SVIDDAT: R792.1 R793.2 U42.D32
H_PM_DOWN: R805.1 R869.2 TP132.1 U49.AH2
H_PM_DOWN_R: R805.2 U42.CR24
H_PROCHOT#: C40.1 PR331.1 PR360.1 PR373.1 Q46.3 Q48.1(S) R89.1 R90.1
H_PROCHOT#_R: R90.2 U42.H35
H_PWRGD: TP141.1 U42.CT25 U49.AC3
H_VCCST_PWRGD: R803.1 U42.CP24
H_VCCST_PWRGD_R: Q96.6 R802.1 R803.2
HDMI_HPD: C546.1 CN23.19 Q52.3 R590.2 R608.1 RV1.1
HDMI_HPD_GPU: CG360.1 R563.1 RG55.2
HDMI_HPD_PCH: Q30.3 R556.1 R1191.1
HDMI_HPD_Q: Q30.1(S) R264.2 R1191.2 U49.AU5
HDMI_SCLK: CN23.15 R1175.2 R1177.2 RV3.1
HDMI_SDATA: CN23.16 R1176.2 R1178.2 RV4.1
HP-L2: CN10.44 U20.27
HP-R2: CN10.43 U20.26
HP_JD#: CN10.42 R407.1
HP_JD_C#: R407.2 R419.1 U20.48
HWPG: D36.2 D39.2 D40.2 D41.2 D42.2 D43.2 D44.2 Q45.3 R459.1 R472.2 R502.2 R799.1 U23.21 U41.1
HWPG_1.8V: D36.1(CATHODE) Q39.6 R414.2
HWPG_1.8VS5: D41.1(CATHODE) PR56.1 PR284.2 PR285.2 PR661.1
HWPG_2.5V: D42.1(CATHODE) PR571.1 PR609.2 PR639.1
HWPG_VDDR: D44.1(CATHODE) PR628.2 PR630.2
I2C_EN_DP: R657.2 R660.2 U56.17
I2C_TP_SCL_C: CN17.6 Q62.4 R638.1 R639.2
I2C_TP_SDA_C: CN17.5 Q62.1(S) R647.2 R648.1
I2CB_SCL_G: QG10.4 RG105.2 UG6.BN8
I2CB_SDA_G: QG10.1(S) RG79.2 UG6.BM8
I2CC_SCL_GFX: QG12.4 RG1.2 RG84.1 UG6.BM7
I2CC_SDA_GFX: QG12.1(S) RG2.2 RG102.1 UG6.BN7
I2S2_RXD: R998.2 U49.BE36
I2S2_SCLK: R1001.2 U49.BD36
ICMNT: C504.1 PC242.2 PR319.2 U23.67
IDCHG_R: PC244.2 PR322.2 PR343.2 R540.2
IFPAB_RSET: RG58.2 UG6.BH23
IFPC_RSET: RG56.2 UG6.BH20
IFPEF_RSET: RG57.2 UG6.BH17
IGPU_BL_EN: QG25.1(S) RG175.1 TP16.1 UG6.BK1
ILIM_HI1: R124.1 U7.16
ILIM_HI2: R126.1 U6.16
ILIM_HI3: R1057.1 U52.16
ILIM_LO1: R125.1 U7.15
ILIM_LO2: R127.1 U6.15
ILIM_LO3: R1054.2 U52.15
IMVP_PWRGD: PR361.2 PR374.1 Q98.2 R627.2 U30.2
IN1_EQ0: R18.1 R21.2 R22.2 U36.8
IN1_EQ1: R23.2 R24.2 R25.1 U36.7
IN1_EQ2: R17.1 R19.2 R20.2 U36.9
INA199_IN+: PC48.1 PC49.2 PR101.1 PU5.4 PU6.4
INA199_IN-: PC47.1 PC48.2 PR102.1 PU5.5 PU6.5
INT_DP0_AUXN: C50.2 RG164.1 UG6.BT10
INT_DP0_AUXN_C: C50.1 U42.AT38
INT_DP0_AUXP: C49.2 RG163.1 UG6.BT11
INT_DP0_AUXP_C: C49.1 U42.AT37
INT_DP0_D0: C637.2 UG6.BP23
INT_DP0_D0#: C636.2 UG6.BR23
INT_DP0_D0#_C: C636.1 U42.AM38
INT_DP0_D0_C: C637.1 U42.AM37
INT_DP0_D1: C639.2 UG6.BT23
INT_DP0_D1#: C638.2 UG6.BT22
INT_DP0_D1#_C: C638.1 U42.AL40
INT_DP0_D1_C: C639.1 U42.AL39
INT_DP0_D2: C647.2 UG6.BR22
INT_DP0_D2#: C646.2 UG6.BP22
INT_DP0_D2#_C: C646.1 U42.AK41
INT_DP0_D2_C: C647.1 U42.AK40
INT_DP0_D3: C51.2 UG6.BP20
INT_DP0_D3#: C52.2 UG6.BR20
INT_DP0_D3#_C: C52.1 U42.AL37
INT_DP0_D3_C: C51.1 U42.AL36
INT_DP1_AUXN: C47.2 RG159.1 UG6.BR11
INT_DP1_AUXN_C: C47.1 U42.AR37
INT_DP1_AUXP: C48.2 RG158.1 UG6.BP11
INT_DP1_AUXP_C: C48.1 U42.AR36
INT_DP1_D0: C45.2 UG6.BJ25
INT_DP1_D0#: C46.2 UG6.BK25
INT_DP1_D0#_C: C46.1 U42.AK38
INT_DP1_D0_C: C45.1 U42.AK37
INT_DP1_D1: C53.2 UG6.BL23
INT_DP1_D1#: C54.2 UG6.BK23
INT_DP1_D1#_C: C54.1 U42.AJ37
INT_DP1_D1_C: C53.1 U42.AJ36
INT_DP1_D2: C641.2 UG6.BJ22
INT_DP1_D2#: C640.2 UG6.BK22
INT_DP1_D2#_C: C640.1 U42.AJ40
INT_DP1_D2_C: C641.1 U42.AJ39
INT_DP1_D3: C650.2 UG6.BM22
INT_DP1_D3#: C649.2 UG6.BL22
INT_DP1_D3#_C: C649.1 U42.AG41
INT_DP1_D3_C: C650.1 U42.AG40
INT_DP2_AUXN: C634.2 RG113.1 UG6.BK10
INT_DP2_AUXN_C: C634.1 U42.AR40
INT_DP2_AUXP: C635.2 RG114.1 UG6.BJ10
INT_DP2_AUXP_C: C635.1 U42.AR39
INT_DP2_D0: C58.2 UG6.BR16
INT_DP2_D0#: C57.2 UG6.BP16
INT_DP2_D0#_C: C57.1 U42.AG38
INT_DP2_D0_C: C58.1 U42.AG37
INT_DP2_D1: C56.2 UG6.BP14
INT_DP2_D1#: C55.2 UG6.BR14
INT_DP2_D1#_C: C55.1 U42.AF37
INT_DP2_D1_C: C56.1 U42.AF36
INT_DP2_D2: C643.2 UG6.BT14
INT_DP2_D2#: C642.2 UG6.BT13
INT_DP2_D2#_C: C642.1 U42.AF40
INT_DP2_D2_C: C643.1 U42.AF39
INT_DP2_D3: C652.2 UG6.BR13
INT_DP2_D3#: C651.2 UG6.BP13
INT_DP2_D3#_C: C651.1 U42.AE41
INT_DP2_D3_C: C652.1 U42.AE40
INT_DP_AUXN: QG8.4 RG74.1 UG6.BJ11
INT_DP_AUXN_Q: C561.2 Q72.3 QG8.3
INT_DP_AUXP: QG8.1(S) RG73.1 UG6.BK11
INT_DP_AUXP_Q: C560.2 Q71.3 QG8.6
INT_EDP_AUXN: R706.2 U42.BA41
INT_EDP_AUXN_R: R706.1 U37.11
INT_EDP_AUXP: R705.1 U42.BA40
INT_EDP_AUXP_R: R705.2 U37.5
INT_EDP_TXN0: C577.1 U42.AW40
INT_EDP_TXN0_R: C577.2 U36.39
INT_EDP_TXN1: C572.1 U42.AV38
INT_EDP_TXN1_R: C572.2 U36.5
INT_EDP_TXN2: C570.1 U42.AV41
INT_EDP_TXN2_R: C570.2 U36.14
INT_EDP_TXN3: C590.1 U42.AU37
INT_EDP_TXN3_R: C590.2 U36.20
INT_EDP_TXP0: C579.1 U42.AW39
INT_EDP_TXP0_R: C579.2 U36.38
INT_EDP_TXP1: C571.1 U42.AV37
INT_EDP_TXP1_R: C571.2 U36.4
INT_EDP_TXP2: C569.1 U42.AV40
INT_EDP_TXP2_R: C569.2 U36.13
INT_EDP_TXP3: C591.1 U42.AU36
INT_EDP_TXP3_R: C591.2 U36.19
INT_ULT_DP_HPD: R662.2 R665.1 R666.1 U56.32
JTAG_SEL: RG66.1 TPG49.1 UG6.BL25
JTAG_TCK: TPG56.1 UG6.BP25
JTAG_TCK_PCH: R873.1 TP139.1 U49.AM5
JTAG_TDI: TPG59.1 UG6.BT25
JTAG_TDI_PCH: R765.1 R884.2 R907.1 TP88.1 U42.F39 U49.AN4
JTAG_TDO: TPG58.1 UG6.BR25
JTAG_TDO_PCH: R764.1 R899.1 RS1.1 TP94.1 U42.G39 U49.AM3
JTAG_TMS: TPG60.1 UG6.BN25
JTAG_TMS_PCH: R773.1 R883.2 R901.1 TP109.1 U42.G41 U49.AM4
JTAG_TRST#: RG67.2 UG6.BM25
JTAGX_PCH: R771.1 TP103.1 U42.G40 U49.AM2
KB_INT#_C: CN19.4 Q57.3 R619.1
L_SPK+: R1150.1 U20.42
L_SPK+_C: C844.2 CN20.2 R1150.2
L_SPK-: R1149.1 U20.43
L_SPK-_C: C843.2 CN20.1 R1149.2
LAN_DISABLE: TP160.1 U49.AK46
LAN_PWR#: R132.2 R136.2 R483.1
LAN_WAKE#: R1082.2 U49.AH48
LANVCC: C696.1 C697.1 CN4.2 Q18.3
LCD_BL_PWM: QG2.5 RG167.1 UG6.BL1
LCD_BLEN: RG149.1 TP19.1 U45.2 UG6.BG7
LCD_VDD: RG147.1 TP17.1 U43.2 UG6.BK3
LCDVCC: C11.1 C12.1 C598.1 C600.1 R40.1 R723.1 R1230.1 U38.1(VOUT)
LCDVCC_CONN: C13.2 C14.1 C15.1 C16.1 C17.2 CN2.1 CN2.2 CN2.3 CN2.4 R40.2
LCDVCC_CTL_EC: R813.1 U23.23
LCDVCC_CTL_PCH: R589.1 R812.1 U49.Y47
LED_B1: Q76.3 R4.2 R47.2 R682.2 R683.2
LED_B2: Q2.3 R11.2 R14.1 R678.2
LED_G1: Q73.6 R5.2 R49.2 R694.2 R697.2
LED_G2: Q4.3 R8.2 R679.1 R680.2
LED_PWR_CTL1: Q74.2 R703.1 U1.12
LED_PWR_CTL2: Q74.5 R689.1 U1.13
LED_PWR_CTL3: Q1.2 R2.1 U1.14
LED_PWR_CTL4: Q1.5 R3.1 U1.15
LED_PWR_CTL5: Q3.2 R9.1 U1.16
LED_PWR_CTL6: Q3.5 R6.1 U1.17
LED_PWR_CTL7: Q5.2 R27.1 U1.18
LED_PWR_CTL_L: Q79.2 R720.1 U1.19
LED_PWR_CTL_LOGO: Q125.2 R1211.1 U1.11
LED_PWR_CTL_R: Q79.5 R719.1 U1.20
LED_PWR_CTL_TURBO: Q85.2 R733.1 U1.24
LED_PWR_LEFT: CN14.1 Q79.6
LED_PWR_LOGO: CN1.6 CN1.11 Q125.3
LED_PWR_RIGHT: CN22.1 Q79.3
LED_PWR_TURBO: CN1.12 Q85.3
LED_R1: Q73.3 R48.2 R686.2 R695.2 R696.2
LED_R2: Q2.6 R7.2 R685.2 R690.2
LID#: CN1.9 D1.1 R333.1 U40.2
LID#_EC_L: C350.2 D24.1 R333.2 U23.118
LINEOUT_LED: C421.2 C422.2 R434.1 R435.1 R1117.1 U54.4
LINEOUT_LED_C: CN19.2 R1117.2 R1146.2 U54.1
LINLVP: CN11.2 R956.2 U21.22
LIP: C757.2 L18.2 R956.1 U21.21
LTE_BODY_SAR1: D70.1(CATHODE) R1050.2 R1187.1
LTE_BODY_SAR2: D45.1(CATHODE) R1055.2 R1188.1
LVDS_BLON1: R718.2 R722.1 TP3.1 U39.1 U45.4(Y)
LVN: C748.2 CN11.1 L17.2 U21.23
M2_WWAN_PERST_L: C263.1 CN7.50 D15.2 D18.2 R181.2 R1232.1
M_A_A0: JDIM2.144 U42.BE4
M_A_A1: JDIM2.133 U42.BH1
M_A_A2: JDIM2.132 U42.BG1
M_A_A3: JDIM2.131 U42.BM2
M_A_A4: JDIM2.128 U42.BM3
M_A_A5: JDIM2.126 U42.BN3
M_A_A6: JDIM2.127 U42.BM1
M_A_A7: JDIM2.122 U42.BV3
M_A_A8: JDIM2.125 U42.BM4
M_A_A9: JDIM2.121 U42.BP3
M_A_A10: JDIM2.146 U42.BD1
M_A_A11: JDIM2.120 U42.BP2
M_A_A12: JDIM2.119 U42.BP4
M_A_A13: JDIM2.158 U42.AM2
M_A_ACT#: JDIM2.114 U42.BW2
M_A_ALERT#: JDIM2.116 U42.D3
M_A_BA0: JDIM2.150 U42.AW3
M_A_BA1: JDIM2.145 U42.AY3
M_A_BG#0: JDIM2.115 U42.BP1
M_A_BG#1: JDIM2.113 U42.BV1
M_A_CAS#: JDIM2.156 U42.AN3
M_A_CB0: JDIM2.92 R265.2
M_A_CB1: JDIM2.91 R199.2
M_A_CB2: JDIM2.101 R212.2
M_A_CB3: JDIM2.105 R188.2
M_A_CB4: JDIM2.88 R270.2
M_A_CB5: JDIM2.87 R191.2
M_A_CB6: JDIM2.100 R268.2
M_A_CB7: JDIM2.104 R267.2
M_A_CKE0: JDIM2.109 U42.BW1
M_A_CKE1: JDIM2.110 U42.BN1
M_A_CLKN0: JDIM2.139 U42.BK2
M_A_CLKN1: JDIM2.140 U42.BK4
M_A_CLKP0: JDIM2.137 U42.BK1
M_A_CLKP1: JDIM2.138 U42.BK3
M_A_CS#0: JDIM2.149 U42.AV3
M_A_CS#1: JDIM2.157 U42.AN4
M_A_DIM0_ODT0: JDIM2.155 U42.AR3
M_A_DIM0_ODT1: JDIM2.161 U42.AM3
M_A_DQ0: JDIM2.3 U42.CR18
M_A_DQ1: JDIM2.4 U42.CP18
M_A_DQ2: JDIM2.8 U42.CU17
M_A_DQ3: JDIM2.7 U42.CU18
M_A_DQ4: JDIM2.21 U42.CP16
M_A_DQ5: JDIM2.17 U42.CR16
M_A_DQ6: JDIM2.16 U42.CU16
M_A_DQ7: JDIM2.20 U42.CT14
M_A_DQ8: JDIM2.29 U42.CR13
M_A_DQ9: JDIM2.25 U42.CP13
M_A_DQ10: JDIM2.24 U42.CU12
M_A_DQ11: JDIM2.28 U42.CU13
M_A_DQ12: JDIM2.41 U42.CP11
M_A_DQ13: JDIM2.37 U42.CR11
M_A_DQ14: JDIM2.42 U42.CU11
M_A_DQ15: JDIM2.38 U42.CT9
M_A_DQ16: JDIM2.45 U42.CR8
M_A_DQ17: JDIM2.46 U42.CU8
M_A_DQ18: JDIM2.49 U42.CR7
M_A_DQ19: JDIM2.50 U42.CU7
M_A_DQ20: JDIM2.62 U42.CM3
M_A_DQ21: JDIM2.58 U42.CM4
M_A_DQ22: JDIM2.63 U42.CM1
M_A_DQ23: JDIM2.59 U42.CK2
M_A_DQ24: JDIM2.66 U42.CJ3
M_A_DQ25: JDIM2.71 U42.CJ4
M_A_DQ26: JDIM2.70 U42.CH1
M_A_DQ27: JDIM2.67 U42.CJ1
M_A_DQ28: JDIM2.83 U42.CF3
M_A_DQ29: JDIM2.80 U42.CF4
M_A_DQ30: JDIM2.79 U42.CF1
M_A_DQ31: JDIM2.84 U42.CE2
M_A_DQ32: JDIM2.174 U42.AG3
M_A_DQ33: JDIM2.169 U42.AG4
M_A_DQ34: JDIM2.173 U42.AF1
M_A_DQ35: JDIM2.170 U42.AG1
M_A_DQ36: JDIM2.186 U42.AD4
M_A_DQ37: JDIM2.187 U42.AD3
M_A_DQ38: JDIM2.183 U42.AD1
M_A_DQ39: JDIM2.182 U42.AC2
M_A_DQ40: JDIM2.190 U42.AB3
M_A_DQ41: JDIM2.194 U42.AB4
M_A_DQ42: JDIM2.195 U42.Y1
M_A_DQ43: JDIM2.191 U42.AB1
M_A_DQ44: JDIM2.208 U42.W4
M_A_DQ45: JDIM2.204 U42.W3
M_A_DQ46: JDIM2.203 U42.W1
M_A_DQ47: JDIM2.207 U42.V2
M_A_DQ48: JDIM2.212 U42.U3
M_A_DQ49: JDIM2.216 U42.U4
M_A_DQ50: JDIM2.211 U42.R1
M_A_DQ51: JDIM2.215 U42.U1
M_A_DQ52: JDIM2.224 U42.P4
M_A_DQ53: JDIM2.228 U42.P3
M_A_DQ54: JDIM2.225 U42.P1
M_A_DQ55: JDIM2.229 U42.N2
M_A_DQ56: JDIM2.232 U42.L3
M_A_DQ57: JDIM2.237 U42.L4
M_A_DQ58: JDIM2.236 U42.K1
M_A_DQ59: JDIM2.233 U42.L1
M_A_DQ60: JDIM2.250 U42.H4
M_A_DQ61: JDIM2.245 U42.H3
M_A_DQ62: JDIM2.249 U42.H1
M_A_DQ63: JDIM2.246 U42.G2
M_A_DQSN0: JDIM2.11 U42.CP17
M_A_DQSN1: JDIM2.32 U42.CP12
M_A_DQSN2: JDIM2.53 U42.CN3
M_A_DQSN3: JDIM2.74 U42.CH4
M_A_DQSN4: JDIM2.177 U42.AF4
M_A_DQSN5: JDIM2.198 U42.Y4
M_A_DQSN6: JDIM2.219 U42.R4
M_A_DQSN7: JDIM2.240 U42.K4
M_A_DQSN8: JDIM2.95 R213.2
M_A_DQSP0: JDIM2.13 U42.CR17
M_A_DQSP1: JDIM2.34 U42.CR12
M_A_DQSP2: JDIM2.55 U42.CN2
M_A_DQSP3: JDIM2.76 U42.CH3
M_A_DQSP4: JDIM2.179 U42.AF3
M_A_DQSP5: JDIM2.200 U42.Y3
M_A_DQSP6: JDIM2.221 U42.R3
M_A_DQSP7: JDIM2.242 U42.K3
M_A_DQSP8: JDIM2.97 R190.2
M_A_PARITY: JDIM2.143 U42.BE1
M_A_RAS#: JDIM2.152 U42.AY2
M_A_WE#: JDIM2.151 U42.AR1
M_B_A0: JDIM1.144 U42.BE9
M_B_A1: JDIM1.133 U42.BH6
M_B_A2: JDIM1.132 U42.BG6
M_B_A3: JDIM1.131 U42.BM8
M_B_A4: JDIM1.128 U42.BM6
M_B_A5: JDIM1.126 U42.BM7
M_B_A6: JDIM1.127 U42.BN9
M_B_A7: JDIM1.122 U42.BV8
M_B_A8: JDIM1.125 U42.BM9
M_B_A9: JDIM1.121 U42.BP8
M_B_A10: JDIM1.146 U42.AY7
M_B_A11: JDIM1.120 U42.BP7
M_B_A12: JDIM1.119 U42.BP9
M_B_A13: JDIM1.158 U42.AM7
M_B_ACT#: JDIM1.114 U42.BW7
M_B_ALERT#: JDIM1.116 U42.E4
M_B_BA0: JDIM1.150 U42.AY8
M_B_BA1: JDIM1.145 U42.AY9
M_B_BG#0: JDIM1.115 U42.BP6
M_B_BG#1: JDIM1.113 U42.BV7
M_B_CAS#: JDIM1.156 U42.AN8
M_B_CB0: JDIM1.92 R129.2
M_B_CB1: JDIM1.91 R119.2
M_B_CB2: JDIM1.101 R114.2
M_B_CB3: JDIM1.105 R118.2
M_B_CB4: JDIM1.88 R133.2
M_B_CB5: JDIM1.87 R116.2
M_B_CB6: JDIM1.100 R123.2
M_B_CB7: JDIM1.104 R130.2
M_B_CKE0: JDIM1.109 U42.BW6
M_B_CKE1: JDIM1.110 U42.BN7
M_B_CLKN0: JDIM1.139 U42.BK9
M_B_CLKN1: JDIM1.140 U42.BK7
