# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
INT_DP0_D0#_C: length 12.5
  BOTTOM w0.079: 156.17,155.88 156.25,155.8 156.25,155.04 156.39,154.89 156.39,154.21 156.55,154.06 156.55,151.83 156.43,151.71 156.3,151.71 156.22,151.79 U42.AM38
  BOTTOM w0.14: 156.17,155.88 156.17,157.42 154.5,159.08 154.5,160.29 154.32,160.47 153.63,160.47 152.95,161.16 152.95,161.45 152.81,161.59 C636.1
INT_DP0_D0_C: length 12.5
  BOTTOM w0.079: U42.AM37 156.22,151.44 156.33,151.55 156.49,151.55 156.7,151.77 156.7,154.21 156.55,154.36 156.55,154.96 156.4,155.1 156.4,155.8 156.48,155.88
  BOTTOM w0.14: 156.48,155.88 156.48,157.55 154.82,159.21 154.82,160.42 154.45,160.79 153.77,160.79 153.26,161.29 153.26,161.47 C637.1
INT_DP0_D1: length 156.3
  IN1 w0.086: v1(156.1,165.87) 155.83,165.87 155.72,165.98 155.72,166.29 155.92,166.49 156.62,166.49 156.72,166.38 156.72,166.06 157.23,165.55 157.23,164.59 157.43,164.39 158,164.39 158.2,164.59 158.2,165.72 158.29,165.81 158.68,165.81 158.79,165.69 158.79,164.59 158.99,164.39 159.57,164.39 159.76,164.59 159.76,165.75 159.85,165.84 163.04,165.84 163.2,165.68 163.2,165.03 163.4,164.84 164.06,164.84 164.25,165.03 164.25,165.79 164.7,166.23 164.7,167.5 164.78,167.59 165.2,167.59 165.29,167.5 165.29,166.3 165.49,166.1 166.07,166.1 166.26,166.3 166.26,167.55 166.35,167.64 166.77,167.64 166.86,167.55 166.86,166.3 167.05,166.1 169.13,166.1 171.92,163.31 174.58,163.31 175.25,162.64 182.54,162.64 191.44,153.75 191.44,153.3 191.35,153.22 190.7,153.22 190.51,153.02 190.51,152.44 190.7,152.25 191.75,152.25 191.84,152.16 191.84,151.74 191.75,151.65 190.7,151.65 190.51,151.46 190.51,150.88 190.7,150.68 191.74,150.68 191.83,150.6 191.83,150.17 191.74,150.09 190.7,150.09 190.51,149.89 190.51,149.31 190.7,149.12 191.89,149.12 191.97,149.03 191.97,148.61 191.89,148.52 190.7,148.52 190.51,148.33 190.51,147.75 190.7,147.55 191.27,147.55 191.78,147.04 192.24,147.04 192.33,146.96 192.33,146.53 192.24,146.45 191.61,146.45 191.41,146.25 191.41,145.67 191.61,145.48 192.24,145.48 192.33,145.39 192.33,144.97 192.24,144.88 191.61,144.88 191.41,144.69 191.41,144.11 191.61,143.91 192.24,143.91 192.33,143.83 192.33,143.41 192.24,143.32 191.61,143.32 191.41,143.12 191.41,132.39 198.93,124.88 208,124.88 208.5,125.38 214.01,125.38 214.52,124.88 216.37,124.88 216.73,125.23 224,125.23 224.3,125.53 225.5,125.53 225.75,125.28 225.75,123.6 225.94,123.4 226.52,123.4 226.72,123.6 226.72,125.44 226.8,125.53 238.36,125.53 238.75,125.92 238.87,125.92 239.39,125.41 239.67,125.41 240.05,125.8 240.05,126.12 239.56,126.61 239.56,126.88 239.91,127.22 241.26,127.22 241.36,127.12 241.36,126.5 241.28,126.41 v2(241.07,126.41)
  BOTTOM w0.102: v2(241.07,126.41) 241.23,126.57 241.42,126.77 241.42,127.25 UG6.BT23
  BOTTOM w0.14: C639.2 156.35,161.89 156.21,162.03 156.21,162.14 157.14,163.07 157.14,164.25 156.65,164.75 156.27,164.75 155.8,165.21 155.8,165.7 155.97,165.87 v1(156.1,165.87)
INT_DP0_D1#: length 156.3
  IN1 w0.086: v2(241.73,126.41) 241.55,126.59 241.55,127.2 241.34,127.41 239.83,127.41 239.37,126.95 239.37,126.53 239.87,126.04 239.87,125.88 239.59,125.6 239.47,125.6 238.95,126.11 238.67,126.11 238.28,125.72 226.73,125.72 226.53,125.52 226.53,123.67 226.44,123.59 226.02,123.59 225.93,123.67 225.93,125.36 225.57,125.72 224.22,125.72 223.93,125.42 216.65,125.42 216.29,125.06 214.6,125.06 214.09,125.57 208.42,125.57 207.92,125.06 199.01,125.06 191.6,132.47 191.6,143.04 191.68,143.13 192.32,143.13 192.52,143.33 192.52,143.91 192.32,144.1 191.68,144.1 191.6,144.19 191.6,144.61 191.68,144.7 192.32,144.7 192.52,144.89 192.52,145.47 192.32,145.67 191.68,145.67 191.6,145.75 191.6,146.17 191.68,146.26 192.32,146.26 192.52,146.46 192.52,147.03 192.32,147.23 191.86,147.23 191.35,147.74 190.78,147.74 190.69,147.83 190.69,148.25 190.78,148.34 191.96,148.34 192.16,148.53 192.16,149.11 191.96,149.31 190.78,149.31 190.69,149.39 190.69,149.81 190.78,149.9 191.82,149.9 192.01,150.1 192.01,150.67 191.82,150.87 190.78,150.87 190.69,150.96 190.69,151.38 190.78,151.47 191.83,151.47 192.02,151.66 192.02,152.24 191.83,152.44 190.78,152.44 190.69,152.52 190.69,152.94 190.78,153.03 191.43,153.03 191.62,153.23 191.62,153.82 182.62,162.83 175.32,162.83 174.65,163.5 172,163.5 169.21,166.29 167.13,166.29 167.04,166.37 167.04,167.63 166.85,167.82 166.27,167.82 166.07,167.63 166.07,166.37 165.99,166.29 165.57,166.29 165.48,166.37 165.48,167.58 165.28,167.77 164.71,167.77 164.51,167.58 164.51,166.31 164.07,165.87 164.07,165.11 163.98,165.03 163.47,165.03 163.39,165.11 163.39,165.76 163.12,166.03 159.77,166.03 159.58,165.83 159.58,164.66 159.49,164.58 159.07,164.58 158.98,164.66 158.98,165.77 158.76,165.99 158.21,165.99 158.01,165.8 158.01,164.66 157.93,164.58 157.5,164.58 157.42,164.66 157.42,165.62 156.91,166.13 156.91,166.46 156.7,166.67 155.84,166.67 155.53,166.36 155.53,166.07 v1(155.34,165.87)
  BOTTOM w0.102: UG6.BT22 241.63,126.9 241.63,126.51 v2(241.73,126.41)
  BOTTOM w0.14: v1(155.34,165.87) 155.48,165.73 155.48,165.08 156.14,164.43 156.52,164.43 156.82,164.12 156.82,163.2 155.9,162.28 155.9,162.07 C638.2
INT_DP0_D1#_C: length 10.3
  BOTTOM w0.079: U42.AL40 156.99,153.12 157.06,153.04 157.17,153.04 157.3,153.18 157.3,154.69 156.9,155.1 156.9,156 156.84,156.06
  BOTTOM w0.102: 156.82,156.08 156.84,156.06
  BOTTOM w0.14: C638.1 155.91,161.44 156.02,161.34 156.02,161.14 155.16,160.28 155.16,159.22 156.82,157.55 156.82,156.08
INT_DP0_D1_C: length 10.4
  BOTTOM w0.079: 157.1,156.06 157.1,156.03 157.06,155.99 157.06,155.16 157.46,154.76 157.46,153.11 U42.AL39
  BOTTOM w0.102: 157.1,156.06 157.1,156.09 157.04,156.15
  BOTTOM w0.14: C639.1 156.34,161.3 156.34,161.01 155.47,160.14 155.47,159.35 157.14,157.68 157.14,156.76 157.04,156.66 157.04,156.15
INT_DP0_D2: length 158.6
  IN1 w0.086: v2(240.93,124.03) 240.66,123.76 238.5,123.76 238.3,123.56 238.3,123.35 238.22,123.27 237.8,123.27 237.71,123.35 237.71,123.56 237.51,123.76 236.93,123.76 236.74,123.56 236.74,123.35 236.65,123.27 236.23,123.27 236.14,123.35 236.14,123.56 235.95,123.76 235.37,123.76 235.17,123.56 235.17,123.35 235.09,123.27 234.67,123.27 234.58,123.35 234.58,123.56 234.38,123.76 233.76,123.76 233.56,123.56 233.56,122.23 233.48,122.14 233.06,122.14 232.97,122.23 232.97,123.46 232.76,123.67 232.2,123.67 232,123.47 232,122.23 231.91,122.14 231.49,122.14 231.4,122.23 231.4,123.45 231.19,123.66 230.63,123.66 230.43,123.46 230.43,122.23 230.35,122.14 229.88,122.14 229.79,122.23 229.79,123.24 229.6,123.44 229.02,123.44 228.82,123.24 228.82,122.23 228.74,122.14 223.78,122.14 223.47,121.83 209.31,121.83 208.23,122.91 205.03,122.91 204.12,122 204.12,118.1 201.96,115.94 199,115.94 196.51,118.44 196.51,123.5 189.44,130.57 189.44,145.09 186.24,148.29 186.24,149.35 186.05,149.54 184.55,149.54 184.29,149.8 184.29,150.04 184.38,150.14 186.05,150.14 186.24,150.33 186.24,150.91 186.05,151.11 185.54,151.11 185.45,151.19 185.45,151.61 185.54,151.7 186.05,151.7 186.24,151.9 186.24,154.04 186.05,154.24 185.45,154.24 185.36,154.32 185.36,154.74 185.45,154.83 186.05,154.83 186.24,155.03 186.24,155.65 186.05,155.85 185.45,155.85 185.36,155.94 185.36,156.95 182.18,160.14 181.28,160.14 181.19,160.22 181.19,160.48 181,160.68 180.43,160.68 180.22,160.47 180.22,160.22 180.14,160.14 178.93,160.14 178.84,160.22 178.84,160.48 178.64,160.68 178.07,160.68 177.87,160.48 177.87,160.22 177.78,160.14 177.36,160.14 177.28,160.22 177.28,160.48 177.08,160.68 176.5,160.68 176.31,160.48 176.31,160.22 176.22,160.14 175.98,160.14 175.79,159.95 175.33,159.95 175.04,160.24 174.9,160.24 174.81,160.33 174.81,160.48 174.61,160.68 174.11,160.68 173.91,160.48 173.91,160.31 173.83,160.23 173.41,160.23 173.33,160.32 173.33,160.46 173.13,160.65 172.55,160.65 172.36,160.46 172.36,160.32 172.27,160.23 171.8,160.23 170.96,161.07 170.45,161.07 169.78,161.74 166.95,161.74 166.62,161.41 163.41,161.41 163.32,161.5 163.32,161.59 163.12,161.78 162.55,161.78 162.35,161.59 162.35,161.5 162.26,161.41 161.8,161.41 161.71,161.5 161.71,161.99 161.51,162.19 160.93,162.19 160.74,161.99 160.74,161.5 160.65,161.41 160.18,161.41 160.1,161.5 160.1,163.07 159.9,163.27 159.32,163.27 159.13,163.07 159.13,161.5 158.46,160.83 158.07,160.83 157.79,161.1 157.79,161.74 157.88,161.83 158.18,161.83 158.27,161.74 v1(158.27,161.61)
  BOTTOM w0.102: v2(240.93,124.03) 240.91,124.01 240.91,123.87 241.04,123.74 241.25,123.74 241.44,123.93 241.44,125.4 242.48,126.44 242.48,127.46 242.24,127.7 242.24,127.92 242.14,128.02 UG6.BR22
  BOTTOM w0.14: v1(158.27,161.61) 157.99,161.61 157.81,161.43 157.81,161.24 157.99,161.06 C647.2
INT_DP0_D2#: length 158.6
  IN1 w0.086: v1(157.39,161.63) 157.6,161.42 157.6,161.02 157.99,160.64 158.54,160.64 159.32,161.42 159.32,162.99 159.4,163.08 159.82,163.08 159.91,162.99 159.91,161.42 160.11,161.22 160.73,161.22 160.93,161.42 160.93,161.91 161.01,162 161.43,162 161.52,161.91 161.52,161.42 161.72,161.22 162.34,161.22 162.54,161.42 162.54,161.51 162.62,161.6 163.04,161.6 163.13,161.51 163.13,161.42 163.33,161.22 166.7,161.22 167.03,161.55 169.7,161.55 170.37,160.88 170.88,160.88 171.72,160.04 172.35,160.04 172.54,160.24 172.54,160.38 172.63,160.47 173.05,160.47 173.14,160.38 173.14,160.24 173.33,160.04 173.91,160.04 174.1,160.23 174.1,160.4 174.19,160.49 174.54,160.49 174.62,160.4 174.62,160.25 174.82,160.05 174.96,160.05 175.25,159.76 175.87,159.76 176.05,159.95 176.3,159.95 176.49,160.14 176.49,160.4 176.58,160.49 177,160.49 177.09,160.4 177.09,160.14 177.28,159.95 177.86,159.95 178.06,160.14 178.06,160.4 178.14,160.49 178.57,160.49 178.65,160.4 178.65,160.14 178.85,159.95 180.21,159.95 180.41,160.14 180.41,160.39 180.51,160.49 180.92,160.49 181,160.4 181,160.14 181.2,159.95 182.1,159.95 185.17,156.88 185.17,155.86 185.37,155.66 185.97,155.66 186.06,155.58 186.06,155.1 185.97,155.02 185.37,155.02 185.17,154.82 185.17,154.24 185.37,154.05 185.97,154.05 186.06,153.96 186.06,151.98 185.97,151.89 185.46,151.89 185.26,151.69 185.26,151.12 185.46,150.92 185.97,150.92 186.06,150.83 186.06,150.41 185.97,150.32 184.31,150.32 184.1,150.12 184.1,149.72 184.47,149.35 185.97,149.35 186.06,149.27 186.06,148.21 189.26,145.01 189.26,130.49 196.32,123.43 196.32,118.36 198.93,115.75 202.03,115.75 204.3,118.02 204.3,121.92 205.11,122.72 208.16,122.72 209.23,121.64 223.55,121.64 223.86,121.95 228.82,121.95 229.01,122.15 229.01,123.16 229.1,123.25 229.52,123.25 229.61,123.16 229.61,122.15 229.8,121.95 230.43,121.95 230.62,122.15 230.62,123.38 230.71,123.47 231.12,123.47 231.22,123.37 231.22,122.15 231.41,121.95 231.99,121.95 232.19,122.15 232.19,123.4 232.27,123.48 232.69,123.48 232.78,123.39 232.78,122.15 232.98,121.95 233.56,121.95 233.75,122.15 233.75,123.48 233.84,123.57 234.31,123.57 234.39,123.48 234.39,123.27 234.59,123.08 235.17,123.08 235.36,123.27 235.36,123.48 235.45,123.57 235.87,123.57 235.96,123.48 235.96,123.27 236.15,123.08 236.73,123.08 236.93,123.27 236.93,123.48 237.01,123.57 237.43,123.57 237.52,123.48 237.52,123.27 237.72,123.08 238.29,123.08 238.49,123.27 238.49,123.48 238.58,123.57 240.71,123.57 v2(240.9,123.38)
  BOTTOM w0.102: v2(240.9,123.38) 241.05,123.53 241.33,123.53 241.64,123.84 241.64,125.31 242.69,126.36 242.69,127.54 242.45,127.78 242.45,128.13 UG6.BP22
  BOTTOM w0.14: C646.2 157.5,161.19 157.5,161.53 v1(157.39,161.63)
INT_DP0_D2#_C: length 7.8
  BOTTOM w0.079: 157.56,156.76 157.56,156.74 157.64,156.66 157.64,155.28 158.08,154.84 158.08,153.83 157.86,153.62 157.78,153.62 157.7,153.69 157.7,153.88 U42.AK41
  BOTTOM w0.14: 157.56,156.76 157.56,160.4 C646.1
INT_DP0_D2_C: length 7.8
  BOTTOM w0.079: 157.88,156.76 157.88,156.74 157.8,156.66 157.8,155.34 158.23,154.91 158.23,153.77 U42.AK40
  BOTTOM w0.14: 157.88,156.76 157.88,160.37 C647.1
INT_DP0_D3: length 159.2
  TOP w0.14: v1(156.14,159.35) 156.14,158.03 C51.2
  IN1 w0.086: v1(156.14,159.35) 156.25,159.46 156.35,159.56 156.35,160.21 155.61,160.96 155.61,162.68 155.84,162.91 156.49,162.91 156.72,162.69 156.72,161.25 157.54,160.43 157.54,159.83 157.63,159.74 158.06,159.74 158.25,159.93 158.8,159.93 158.9,160.02 158.9,160.34 159.27,160.71 167.03,160.71 167.39,161.08 169.46,161.08 169.66,160.88 169.66,159.93 169.74,159.85 170.06,159.85 170.26,159.65 170.26,159.22 170.34,159.13 170.72,159.13 170.81,159.22 170.81,159.39 171.01,159.59 171.61,159.59 171.78,159.41 171.78,159.22 171.87,159.13 172.31,159.13 172.4,159.22 172.4,159.31 172.59,159.51 173.31,159.51 173.5,159.31 173.5,158.08 173.61,157.97 173.97,157.97 174.08,158.08 174.08,158.98 174.28,159.18 175.52,159.18 175.75,158.95 175.75,158.17 175.84,158.09 176.34,158.09 176.48,158.23 176.48,158.79 176.67,158.98 178.1,158.98 178.3,158.79 178.3,157.9 178.38,157.81 178.81,157.81 178.9,157.9 178.9,159.01 179.1,159.21 179.64,159.21 179.89,158.96 179.89,158.04 179.97,157.96 180.44,157.96 180.64,157.76 180.64,157.01 180.72,156.92 181.14,156.92 181.23,157.01 181.23,157.95 181.43,158.14 181.99,158.14 182.2,157.93 182.2,156.83 182.29,156.74 183.14,156.74 183.82,156.07 183.82,154.3 183.62,154.11 182.93,154.11 182.82,154 182.82,153.61 182.92,153.51 183.72,153.51 183.93,153.31 183.93,152.71 183.73,152.51 183.05,152.51 182.96,152.42 182.96,151.96 183.05,151.87 184.59,151.87 184.79,151.67 184.79,151.1 184.6,150.9 183.05,150.9 182.96,150.81 182.96,150.2 188.79,144.37 188.79,129.94 195.64,123.09 195.64,118.38 198.73,115.28 202.23,115.28 204.77,117.83 204.77,121.71 205.31,122.25 207.91,122.25 208.99,121.18 223.74,121.18 224,121.43 233.78,121.43 234.96,122.61 240.68,122.61 241.37,123.3 241.37,124.31 241.58,124.52 241.9,124.52 v2(242.09,124.71)
  BOTTOM w0.102: v2(242.09,124.71) 242.27,124.53 242.42,124.53 242.92,125.04 242.92,127.55 243.06,127.69 243.06,128.06 243.26,128.26 UG6.BP20
INT_DP0_D3#: length 159.1
  TOP w0.14: v1(156.87,159.34) 156.74,159.34 156.46,159.07 156.46,157.97 156.6,157.83 C52.2
  IN1 w0.086: v2(242.09,124.04) 241.8,124.33 241.66,124.33 241.56,124.23 241.56,123.22 240.76,122.42 235.04,122.42 233.85,121.24 224.07,121.24 223.82,120.99 208.91,120.99 207.83,122.07 205.39,122.07 204.96,121.63 204.96,117.75 202.31,115.1 198.65,115.1 195.45,118.3 195.45,123.01 188.6,129.86 188.6,144.29 182.77,150.12 182.77,150.89 182.97,151.09 184.52,151.09 184.61,151.18 184.61,151.59 184.51,151.68 182.97,151.68 182.77,151.88 182.77,152.5 182.97,152.7 183.65,152.7 183.74,152.79 183.74,153.23 183.65,153.32 182.84,153.32 182.63,153.54 182.63,154.08 182.85,154.29 183.54,154.29 183.63,154.38 183.63,155.99 183.06,156.56 182.21,156.56 182.01,156.75 182.01,157.85 181.91,157.96 181.5,157.96 181.42,157.87 181.42,156.93 181.22,156.74 180.64,156.74 180.45,156.93 180.45,157.68 180.36,157.77 179.89,157.77 179.7,157.97 179.7,158.89 179.56,159.02 179.17,159.02 179.09,158.94 179.09,157.82 178.89,157.63 178.31,157.63 178.11,157.82 178.11,158.71 178.02,158.8 176.75,158.8 176.66,158.71 176.66,158.15 176.41,157.9 175.76,157.9 175.56,158.1 175.56,158.87 175.44,158.99 174.36,158.99 174.27,158.9 174.27,158 174.05,157.79 173.53,157.79 173.32,158 173.32,159.23 173.23,159.32 172.67,159.32 172.58,159.23 172.58,159.14 172.39,158.95 171.79,158.95 171.59,159.14 171.59,159.34 171.53,159.4 171.09,159.4 171,159.31 171,159.14 170.8,158.95 170.27,158.95 170.07,159.14 170.07,159.57 169.98,159.66 169.67,159.66 169.47,159.86 169.47,160.8 169.38,160.89 167.47,160.89 167.11,160.52 159.35,160.52 159.08,160.26 159.08,159.94 158.88,159.74 158.33,159.74 158.14,159.55 157.55,159.55 157.35,159.75 157.35,160.35 156.53,161.17 156.53,162.61 156.42,162.72 155.92,162.72 155.8,162.6 155.8,161.03 156.54,160.29 156.54,159.55 156.75,159.34 v1(156.87,159.34)
  BOTTOM w0.102: v2(242.09,124.04) 242.09,124.23 242.19,124.33 242.51,124.33 243.13,124.95 243.13,127.47 243.26,127.6 243.26,127.92 243.36,128.02 UG6.BR20
INT_DP0_D3#_C: length 7.6
  TOP w0.102: v2(157.35,151.66) 157.35,151.48 157.25,151.37 157.07,151.37 156.64,151.8 156.64,153.24 156.38,153.51 156.38,154.96 156.44,155.02 156.44,155.03
  TOP w0.14: 156.44,155.03 156.44,156.15 156.36,156.23 156.36,157.24 156.5,157.38 C52.1
  BOTTOM w0.079: U42.AL37 157.31,151.66 v2(157.35,151.66)
INT_DP0_D3_C: length 7.6
  TOP w0.102: v2(157.37,151.01) 157.21,151.17 156.98,151.17 156.44,151.71 156.44,153.16 156.18,153.42 156.18,154.94 156.12,155 156.12,155.03
  TOP w0.14: 156.12,155.03 156.12,156.02 156.04,156.1 156.04,157.28 C51.1
  BOTTOM w0.079: v2(157.37,151.01) 157.31,151.01 U42.AL36
INT_DP1_AUXN: length 152
  TOP w0.14: C47.2 154.77,159.2 154.77,159.5 154.49,159.77 154.49,161.06 v1(154.3,161.25)
  IN4 w0.086: v1(233.05,119.29) 233.2,119.29 233.36,119.13 233.36,118.92 233.25,118.82 232.69,118.82 232.15,119.36 205.64,119.36 202.27,115.99 199.05,115.99 196.9,118.14 196.9,125.22 191.57,130.55 191.57,145.76 184.66,152.67 184.66,155.91 182.77,157.79 179.28,157.79 178.61,158.46 176.02,158.46 175.32,159.17 174.63,159.17 174.22,159.57 174.22,159.66 173.45,160.43 173.45,160.76 171.45,162.77 170.42,162.77 169.62,163.57 167.78,163.57 167.52,163.83 164.98,163.83 164.76,164.05 154.6,164.05 154.19,163.65 154.19,162.21 154.51,161.89 154.51,161.47 v1(154.3,161.25)
  BOTTOM w0.102: 250.5,120.49 250.53,120.52 RG159.1 250.53,120.96 250.35,121.15 250.35,122.31 249.99,122.67 249.99,126.25 249.76,126.48 249.76,126.88 249.45,127.19 249.45,127.55 249.75,127.85 UG6.BR11
  BOTTOM w0.14: 250.5,120.49 250.38,120.37 250.38,119.79 249.95,119.36 247.2,119.36 243.26,115.41 237.38,115.41 236.78,116.02 235.47,116.02 233.32,118.16 233.32,119.02 v1(233.05,119.29)
INT_DP1_AUXN_C: length 8.8
  TOP w0.102: v2(155.08,151.65) 155.08,151.54 155.23,151.38 155.38,151.38 155.62,151.62 155.62,152.3 155.16,152.76 155.16,154.95 155.1,155 155.1,155.03
  TOP w0.14: C47.1 154.76,158.52 154.9,158.38 154.9,155.62 155.1,155.42 155.1,155.03
  BOTTOM w0.102: v2(155.08,151.65) 155.07,151.65 154.76,151.34 U42.AR37
INT_DP1_AUXP: length 152
  TOP w0.14: C48.2 155.08,159.19 155.08,159.63 154.81,159.9 154.81,161.05 v1(155.02,161.25)
  IN4 w0.086: v1(233.95,119.29) 233.67,119.29 233.55,119.17 233.55,118.84 233.33,118.63 232.61,118.63 232.07,119.17 205.72,119.17 202.35,115.8 198.97,115.8 196.71,118.06 196.71,125.14 191.38,130.48 191.38,145.68 184.47,152.59 184.47,155.83 182.69,157.61 179.2,157.61 178.54,158.27 175.94,158.27 175.24,158.98 174.55,158.98 174.03,159.49 174.03,159.59 173.27,160.36 173.27,160.69 171.37,162.58 170.35,162.58 169.54,163.38 167.7,163.38 167.45,163.64 164.91,163.64 164.68,163.86 154.68,163.86 154.38,163.57 154.38,162.29 154.7,161.97 154.7,161.42 154.7,161.34 154.79,161.25 v1(155.02,161.25)
  BOTTOM w0.102: UG6.BP11 249.45,128.42 249.45,127.84 249.24,127.64 249.24,127.11 249.55,126.8 249.55,126.4 249.79,126.17 249.79,122.59 250.14,122.23 250.14,121.15 249.98,120.98 RG158.1 249.98,120.49
  BOTTOM w0.14: v1(233.95,119.29) 233.64,118.98 233.64,118.29 235.6,116.33 236.91,116.33 237.51,115.73 243.13,115.73 247.07,119.67 249.82,119.67 250.06,119.92 250.06,120.39 249.98,120.47 249.98,120.49
INT_DP1_AUXP_C: length 8.8
  TOP w0.102: v2(155.07,151.02) 155.23,151.18 155.46,151.18 155.82,151.54 155.82,152.39 155.36,152.84 155.36,154.95 155.42,155 155.42,155.03
  TOP w0.14: 155.42,155.03 155.42,155.55 155.22,155.75 155.22,158.44 C48.1
  BOTTOM w0.102: U42.AR36 154.74,150.69 v2(155.07,151.02)
INT_DP1_D0: length 152.8
  TOP w0.14: v1(156.56,167.26) 156.81,167.01 156.81,166.27 157.28,165.8 157.28,163.68 156.45,162.85 156.45,161.48 157.58,160.34 157.58,159.22 C45.2
  IN4 w0.086: v1(156.56,167.26) 156.8,167.5 156.8,167.7 157.06,167.97 163.26,167.97 163.46,167.77 163.46,167.62 163.55,167.53 163.97,167.53 164.06,167.62 164.06,167.77 164.25,167.97 165.64,167.97 166.1,167.5 166.57,167.5 166.77,167.3 166.77,167.2 166.85,167.11 167.38,167.11 167.77,167.5 169.49,167.5 169.68,167.3 169.68,166.68 169.8,166.56 170.06,166.56 170.32,166.82 171.53,166.82 171.82,166.52 171.82,166.49 172,166.32 172,166.01 172.13,165.88 172.73,165.88 172.99,165.62 175.11,163.49 178.84,163.49 178.94,163.6 178.94,164.13 179.14,164.32 179.72,164.32 179.91,164.13 179.91,163.6 180,163.51 180.42,163.51 180.51,163.6 180.51,164.13 180.7,164.32 181.28,164.32 181.48,164.13 181.48,163.6 181.56,163.51 182.85,163.51 183.34,163.02 183.5,163.02 183.77,163.28 184.05,163.28 184.45,162.87 184.45,162.59 184.17,162.31 184.17,162.19 184.5,161.85 184.77,161.85 185.04,162.12 185.37,162.12 186.62,160.87 186.62,160.45 186.28,160.11 186.28,159.88 186.52,159.64 186.75,159.64 187.08,159.97 187.35,159.97 187.76,159.56 187.76,159.28 187.43,158.95 187.43,158.83 188.73,157.54 188.73,156.71 188.52,156.51 188.4,156.51 188.31,156.42 188.31,156 188.4,155.91 188.6,155.91 188.8,155.71 188.8,155.14 188.6,154.94 188.4,154.94 188.31,154.85 188.31,154.43 188.4,154.35 188.6,154.35 188.8,154.14 188.8,153.52 195.43,146.89 195.43,133.42 195.22,133.2 194.61,133.2 194.47,133.06 194.47,132.56 194.57,132.45 195.2,132.45 195.43,132.22 195.43,131.79 194.86,131.21 194.86,130.98 200.21,125.62 202.88,125.62 204.54,123.96 207.66,123.96 207.83,123.79 213.16,123.79 214.05,122.89 223.56,122.89 223.65,122.98 223.65,123.77 223.84,123.97 224.42,123.97 224.62,123.77 224.62,122.98 224.7,122.89 225.13,122.89 225.21,122.98 225.21,123.76 225.41,123.96 225.99,123.96 226.18,123.76 226.18,122.98 226.27,122.89 226.69,122.89 226.78,122.98 226.78,123.83 226.97,124.03 227.55,124.03 227.75,123.83 227.75,122.98 227.83,122.89 228.25,122.89 228.34,122.98 228.34,123.75 228.54,123.94 229.11,123.94 229.31,123.75 229.31,122.98 229.4,122.89 231.53,122.89 231.86,123.22 231.86,123.35 231.5,123.7 231.5,123.98 231.91,124.39 232.19,124.39 232.55,124.03 232.67,124.03 232.97,124.33 232.97,124.45 232.61,124.81 232.61,125.09 233.02,125.5 233.3,125.5 233.65,125.14 233.78,125.14 234.07,125.44 234.07,125.56 233.72,125.92 233.72,126.2 234.13,126.61 234.4,126.61 234.76,126.25 234.88,126.25 235.18,126.55 235.18,126.67 234.82,127.03 234.82,127.3 235.23,127.71 235.51,127.71 235.87,127.35 235.99,127.35 239.51,130.87 239.51,132.09 239.75,132.34 240.17,132.34 240.3,132.46 v2(240.3,132.57)
  BOTTOM w0.102: v2(240.3,132.57) UG6.BJ25
INT_DP1_D0#: length 152.8
  TOP w0.14: v1(157.34,167.26) 157.13,167.04 157.13,166.4 157.6,165.93 157.6,163.55 156.77,162.72 156.77,161.61 157.9,160.47 157.9,159.22 C46.2
  IN4 w0.086: v1(157.34,167.26) 157.07,167.26 156.99,167.35 156.99,167.62 157.14,167.78 163.19,167.78 163.27,167.69 163.27,167.54 163.47,167.34 164.05,167.34 164.24,167.54 164.24,167.69 164.33,167.78 165.56,167.78 166.03,167.31 166.49,167.31 166.58,167.23 166.58,167.12 166.78,166.92 167.46,166.92 167.85,167.31 169.41,167.31 169.49,167.23 169.49,166.61 169.73,166.37 170.14,166.37 170.4,166.63 171.45,166.63 171.64,166.44 171.64,166.42 171.81,166.24 171.81,165.93 172.05,165.69 172.65,165.69 175.04,163.3 178.92,163.3 179.13,163.52 179.13,164.05 179.22,164.14 179.64,164.14 179.73,164.05 179.73,163.52 179.92,163.32 180.5,163.32 180.7,163.52 180.7,164.05 180.78,164.14 181.2,164.14 181.29,164.05 181.29,163.52 181.49,163.32 182.77,163.32 183.26,162.83 183.58,162.83 183.84,163.09 183.97,163.09 184.27,162.79 184.27,162.67 183.98,162.39 183.98,162.11 184.42,161.67 184.85,161.67 185.11,161.93 185.29,161.93 186.43,160.79 186.43,160.53 186.09,160.19 186.09,159.8 186.44,159.45 186.83,159.45 187.16,159.78 187.28,159.78 187.58,159.48 187.58,159.36 187.25,159.03 187.25,158.75 188.54,157.46 188.54,156.78 188.45,156.69 188.32,156.69 188.13,156.5 188.13,155.92 188.32,155.72 188.52,155.72 188.61,155.64 188.61,155.22 188.52,155.13 188.32,155.13 188.13,154.93 188.13,154.35 188.32,154.16 188.52,154.16 188.61,154.06 188.61,153.44 195.24,146.81 195.24,133.49 195.14,133.39 194.53,133.39 194.28,133.14 194.28,132.48 194.5,132.26 195.12,132.26 195.24,132.14 195.24,131.87 194.67,131.29 194.67,130.9 200.14,125.43 202.8,125.43 204.46,123.77 207.58,123.77 207.76,123.6 213.08,123.6 213.97,122.71 223.64,122.71 223.83,122.9 223.83,123.69 223.92,123.78 224.34,123.78 224.43,123.69 224.43,122.9 224.63,122.71 225.2,122.71 225.4,122.9 225.4,123.68 225.49,123.77 225.91,123.77 225.99,123.68 225.99,122.9 226.19,122.71 226.77,122.71 226.96,122.9 226.96,123.75 227.05,123.84 227.47,123.84 227.56,123.75 227.56,122.9 227.75,122.71 228.33,122.71 228.53,122.9 228.53,123.67 228.61,123.76 229.04,123.76 229.12,123.67 229.12,122.9 229.32,122.71 231.61,122.71 232.05,123.15 232.05,123.42 231.69,123.78 231.69,123.9 231.99,124.2 232.11,124.2 232.47,123.85 232.75,123.85 233.15,124.25 233.15,124.53 232.8,124.89 232.8,125.01 233.1,125.31 233.22,125.31 233.58,124.95 233.85,124.95 234.26,125.36 234.26,125.64 233.9,126 233.9,126.12 234.2,126.42 234.32,126.42 234.68,126.06 234.96,126.06 235.37,126.47 235.37,126.75 235.01,127.1 235.01,127.23 235.31,127.52 235.43,127.52 235.79,127.17 236.07,127.17 239.69,130.79 239.69,132.01 239.83,132.15 240.2,132.15 240.31,132.04 v2(240.31,131.88)
  BOTTOM w0.102: UG6.BK25 239.95,131.61 240.22,131.88 v2(240.31,131.88)
INT_DP1_D0#_C: length 7.9
  TOP w0.102: 157.72,155.03 157.72,155 157.66,154.95 157.66,152.21 157.8,152.08 158.02,152.08 158.14,152.2 v2(158.14,152.31)
  TOP w0.14: 157.72,155.03 157.72,157.28 157.8,157.36 157.8,158.41 157.94,158.55 C46.1
  BOTTOM w0.079: v2(158.14,152.31) 158.08,152.31 U42.AK38
INT_DP1_D0_C: length 7.9
  TOP w0.102: 157.4,155.03 157.4,155 157.46,154.95 157.46,152.13 157.71,151.87 157.9,151.87 v2(158.11,151.66)
  TOP w0.14: 157.4,155.03 157.4,157.41 157.48,157.49 157.48,158.43 C45.1
  BOTTOM w0.079: U42.AK37 157.78,151.34 v2(158.11,151.66)
INT_DP1_D1: length 153.6
  TOP w0.14: v1(158.01,166.51) 158.3,166.22 158.3,162.9 158.83,162.37 158.83,158.05 C53.2
  IN4 w0.086: v2(241.01,131.16) 241.01,131.32 241.09,131.41 241.3,131.41 241.38,131.33 241.38,129 240.82,128.44 239.82,128.44 239.08,129.18 238.74,129.18 238.31,128.75 238.31,128.47 238.55,128.23 238.55,128.11 238.24,127.81 238.12,127.81 237.88,128.04 237.61,128.04 237.2,127.63 237.2,127.36 237.43,127.12 237.43,127 237.14,126.7 237.01,126.7 236.78,126.94 236.5,126.94 236.09,126.53 236.09,126.25 236.33,126.01 236.33,125.89 236.03,125.59 235.91,125.59 235.67,125.83 235.39,125.83 234.98,125.42 234.98,125.14 235.22,124.91 235.22,124.78 234.92,124.49 234.8,124.49 234.56,124.72 234.28,124.72 233.88,124.31 233.88,124.04 234.11,123.8 234.11,123.68 233.81,123.38 233.69,123.38 233.46,123.61 233.18,123.61 232.77,123.21 232.77,122.93 233.01,122.69 233.01,122.57 232.67,122.24 230.73,122.24 230.53,122.04 230.53,121.58 230.45,121.49 230.04,121.49 229.94,121.59 229.94,122.04 229.74,122.24 229.17,122.24 228.97,122.04 228.97,121.58 228.88,121.49 228.49,121.49 228.38,121.6 228.38,122.04 228.18,122.24 227.6,122.24 227.41,122.04 227.41,121.58 227.32,121.49 226.9,121.49 226.81,121.58 226.81,122.04 226.61,122.24 211.97,122.24 211.88,122.32 211.88,122.51 211.69,122.7 211.11,122.7 210.91,122.51 210.91,122.32 210.83,122.24 210.41,122.24 210.32,122.32 210.32,122.53 210.12,122.73 209.55,122.73 209.35,122.53 209.35,122.32 209.26,122.24 208.84,122.24 208.75,122.32 208.75,122.58 208.56,122.78 207.98,122.78 207.78,122.58 207.78,122.32 207.7,122.24 207.28,122.24 207.19,122.32 207.19,122.82 206.99,123.01 206.42,123.01 206.22,122.82 206.22,122.32 206.13,122.24 205.33,122.24 202.61,124.96 199.94,124.96 193.73,131.18 193.73,133.81 193.92,134 194.51,134 194.78,134.26 194.78,135.62 194.58,135.81 194.29,135.81 194.2,135.9 194.2,136.32 194.29,136.41 194.58,136.41 194.78,136.6 194.78,137.18 194.58,137.38 194.29,137.38 194.2,137.46 194.2,137.89 194.29,137.97 194.58,137.97 194.78,138.17 194.78,138.75 194.58,138.94 194.29,138.94 194.2,139.03 194.2,139.45 194.29,139.54 194.58,139.54 194.78,139.73 194.78,140.31 194.58,140.51 194.29,140.51 194.2,140.59 194.2,141.01 194.29,141.1 194.58,141.1 194.78,141.3 194.78,141.88 194.58,142.07 194.29,142.07 194.2,142.16 194.2,142.58 194.29,142.67 194.58,142.67 194.78,142.86 194.78,143.44 194.58,143.64 194.29,143.64 194.2,143.72 194.2,144.14 194.29,144.23 194.58,144.23 194.78,144.43 194.78,145 194.58,145.2 194.29,145.2 194.2,145.29 194.2,145.71 194.29,145.79 194.58,145.79 194.78,145.99 194.78,146.61 187.66,153.73 187.66,156.97 187.87,157.19 187.87,157.47 187.46,157.87 187.19,157.87 186.94,157.63 186.82,157.63 186.52,157.93 186.52,158.05 186.74,158.27 186.74,158.55 186.33,158.96 186.06,158.96 185.83,158.74 185.71,158.74 185.41,159.04 185.41,159.16 185.63,159.37 185.63,159.65 185.22,160.06 184.94,160.06 184.73,159.84 184.6,159.84 184.31,160.14 184.31,160.26 184.57,160.53 184.57,160.8 184.16,161.21 183.88,161.21 183.62,160.95 183.5,160.95 183.2,161.25 183.2,161.37 183.49,161.66 183.49,161.94 183.08,162.35 182.8,162.35 182.51,162.06 182.39,162.06 181.61,162.84 174.77,162.84 172.46,165.15 170.82,165.15 170.44,165.54 169.85,165.54 168.93,166.46 166.22,166.46 165.8,166.87 162.99,166.87 162.55,167.31 158.7,167.31 158.5,167.12 158.5,166.63 158.38,166.51 v1(158.01,166.51)
  BOTTOM w0.102: UG6.BL23 v2(241.01,131.16)
INT_DP1_D1#: length 153.5
  TOP w0.14: C54.2 159.14,158.05 159.14,162.5 158.61,163.03 158.61,166.22 v1(158.91,166.51)
  IN4 w0.086: v1(158.91,166.51) 158.69,166.73 158.69,167.04 158.77,167.13 162.48,167.13 162.91,166.69 165.73,166.69 166.14,166.27 168.85,166.27 169.77,165.35 170.36,165.35 170.75,164.96 172.38,164.96 174.69,162.65 181.53,162.65 182.31,161.87 182.59,161.87 182.88,162.16 183,162.16 183.3,161.86 183.3,161.74 183.01,161.45 183.01,161.17 183.42,160.76 183.7,160.76 183.96,161.03 184.08,161.03 184.38,160.73 184.38,160.6 184.12,160.34 184.12,160.06 184.53,159.66 184.8,159.66 185.02,159.87 185.14,159.87 185.44,159.57 185.44,159.45 185.23,159.24 185.23,158.96 185.63,158.55 185.91,158.55 186.14,158.77 186.26,158.77 186.56,158.47 186.56,158.35 186.33,158.13 186.33,157.85 186.74,157.44 187.02,157.44 187.26,157.69 187.38,157.69 187.68,157.39 187.68,157.27 187.47,157.05 187.47,153.66 194.59,146.54 194.59,146.07 194.5,145.98 194.21,145.98 194.01,145.79 194.01,145.21 194.21,145.01 194.5,145.01 194.59,144.93 194.59,144.5 194.5,144.42 194.21,144.42 194.01,144.22 194.01,143.64 194.21,143.45 194.5,143.45 194.59,143.36 194.59,142.94 194.5,142.85 194.21,142.85 194.01,142.66 194.01,142.08 194.21,141.88 194.5,141.88 194.59,141.8 194.59,141.38 194.5,141.29 194.21,141.29 194.01,141.09 194.01,140.52 194.21,140.32 194.5,140.32 194.59,140.23 194.59,139.81 194.5,139.72 194.21,139.72 194.01,139.53 194.01,138.95 194.21,138.75 194.5,138.75 194.59,138.67 194.59,138.25 194.5,138.16 194.21,138.16 194.01,137.96 194.01,137.39 194.21,137.19 194.5,137.19 194.59,137.1 194.59,136.68 194.5,136.6 194.21,136.6 194.01,136.4 194.01,135.82 194.21,135.62 194.5,135.62 194.59,135.54 194.59,134.34 194.43,134.19 193.84,134.19 193.54,133.89 193.54,131.1 199.86,124.78 202.53,124.78 205.26,122.05 206.21,122.05 206.41,122.25 206.41,122.74 206.49,122.83 206.92,122.83 207,122.74 207,122.25 207.2,122.05 207.78,122.05 207.97,122.25 207.97,122.51 208.06,122.59 208.48,122.59 208.57,122.51 208.57,122.25 208.76,122.05 209.34,122.05 209.54,122.25 209.54,122.46 209.62,122.54 210.05,122.54 210.13,122.46 210.13,122.25 210.33,122.05 210.91,122.05 211.1,122.25 211.1,122.43 211.19,122.51 211.61,122.51 211.7,122.43 211.7,122.25 211.89,122.05 226.54,122.05 226.62,121.96 226.62,121.5 226.82,121.3 227.4,121.3 227.59,121.5 227.59,121.96 227.68,122.05 228.1,122.05 228.19,121.96 228.19,121.53 228.41,121.3 228.96,121.3 229.16,121.5 229.16,121.96 229.24,122.05 229.67,122.05 229.75,121.96 229.75,121.51 229.96,121.3 230.53,121.3 230.72,121.5 230.72,121.96 230.81,122.05 232.75,122.05 233.19,122.49 233.19,122.77 232.96,123.01 232.96,123.13 233.26,123.43 233.38,123.43 233.61,123.19 233.89,123.19 234.3,123.6 234.3,123.88 234.06,124.11 234.06,124.24 234.36,124.53 234.48,124.53 234.72,124.3 235,124.3 235.41,124.71 235.41,124.98 235.17,125.22 235.17,125.34 235.47,125.64 235.59,125.64 235.83,125.4 236.11,125.4 236.51,125.81 236.51,126.09 236.28,126.33 236.28,126.45 236.58,126.75 236.7,126.75 236.94,126.51 237.21,126.51 237.62,126.92 237.62,127.2 237.39,127.43 237.39,127.56 237.68,127.86 237.81,127.86 238.04,127.62 238.32,127.62 238.74,128.03 238.74,128.31 238.5,128.55 238.5,128.67 238.82,128.99 239,128.99 239.74,128.25 240.89,128.25 241.57,128.92 241.57,131.41 241.38,131.6 241.12,131.6 241.01,131.7 v2(241.01,131.86)
  BOTTOM w0.102: UG6.BK23 v2(241.01,131.86)
INT_DP1_D1#_C: length 7.4
  TOP w0.102: v2(158.93,151.67) 158.91,151.65 158.8,151.65 158.7,151.75 158.7,152.09 159.04,152.43 159.04,153.82 159.25,154.03 159.25,154.95 159.31,155 159.31,155.03
  TOP w0.14: 159.31,155.03 159.31,155.41 159.03,155.69 159.03,157.34 159.13,157.44 159.31,157.44 C54.1
  BOTTOM w0.14: v2(158.93,151.67) 158.89,151.7 158.65,151.7 158.5,151.56 158.5,151.36 U42.AJ37
INT_DP1_D1_C: length 7.4
  TOP w0.102: 158.99,155.03 158.99,155 159.05,154.95 159.05,154.11 158.84,153.91 158.84,152.52 158.5,152.18 158.5,151.7 158.59,151.49 158.71,151.28 v2(158.91,151.04)
  TOP w0.14: C53.1 158.72,157.12 158.72,155.55 158.99,155.28 158.99,155.03
  BOTTOM w0.14: U42.AJ36 158.87,151.04 v2(158.91,151.04)
INT_DP1_D2: length 151
  IN4 w0.086: v2(242.38,131.87) 242.38,131.64 242.25,131.5 241.98,131.5 241.79,131.3 241.79,128.87 240.83,127.92 239.28,127.92 232.2,120.83 226.17,120.83 226.08,120.92 226.08,121.32 225.89,121.51 225.31,121.51 225.11,121.32 225.11,120.92 225.03,120.83 224.6,120.83 224.52,120.92 224.52,121.39 224.32,121.58 223.74,121.58 223.55,121.39 223.55,120.92 223.46,120.83 223.04,120.83 222.95,120.92 222.95,121.39 222.76,121.58 222.18,121.58 221.98,121.39 221.98,120.92 221.9,120.83 221.48,120.83 221.39,120.92 221.39,121.39 221.19,121.58 220.61,121.58 220.42,121.39 220.42,120.92 220.33,120.83 219.91,120.83 219.82,120.92 219.82,121.39 219.63,121.58 219.05,121.58 218.85,121.39 218.85,120.92 218.77,120.83 218.35,120.83 218.26,120.92 218.26,121.39 218.06,121.58 217.49,121.58 217.29,121.39 217.29,120.92 217.2,120.83 216.78,120.83 216.69,120.92 216.69,121.39 216.5,121.58 215.92,121.58 215.72,121.39 215.72,120.92 215.64,120.83 215.17,120.83 215.08,120.92 215.08,121.39 214.89,121.58 214.31,121.58 214.11,121.39 214.11,120.92 214.03,120.83 213.61,120.83 213.52,120.92 213.52,121.39 213.32,121.58 212.75,121.58 212.55,121.39 212.55,120.92 212.46,120.83 212.04,120.83 211.96,120.92 211.96,121.39 211.76,121.58 211.18,121.58 210.98,121.39 210.98,120.92 210.9,120.83 210.48,120.83 210.39,120.92 210.39,121.39 210.19,121.58 209.71,121.58 209.52,121.39 209.52,120.97 209.38,120.83 209.11,120.83 209.02,120.92 209.02,121.35 208.79,121.58 208.32,121.58 208.12,121.39 208.12,121 208,120.88 207.77,120.88 207.65,121 207.65,121.38 207.45,121.58 204.99,121.58 202.26,124.31 199.67,124.31 193.07,130.9 193.07,134.27 193.16,134.36 193.35,134.36 193.55,134.56 193.55,135.13 193.35,135.33 193.16,135.33 193.07,135.42 193.07,135.88 193.17,135.98 193.35,135.98 193.55,136.17 193.55,136.75 193.35,136.95 193.16,136.95 193.07,137.03 193.07,137.45 193.16,137.54 193.35,137.54 193.55,137.74 193.55,138.32 193.35,138.51 193.17,138.51 193.07,138.61 193.07,139.02 193.16,139.11 193.35,139.11 193.55,139.3 193.55,139.88 193.35,140.08 193.16,140.08 193.07,140.16 193.07,140.58 193.16,140.67 193.35,140.67 193.55,140.87 193.55,145.64 192.89,146.29 192.89,146.51 193.29,146.9 193.29,147.18 192.8,147.67 192.52,147.67 192.08,147.23 191.96,147.23 191.66,147.53 191.66,147.65 192.1,148.09 192.1,148.37 191.69,148.78 191.41,148.78 190.97,148.33 190.85,148.33 190.55,148.63 190.55,148.76 190.99,149.2 190.99,149.47 190.58,149.88 190.3,149.88 189.86,149.44 189.74,149.44 189.44,149.74 189.44,149.86 189.88,150.3 189.88,150.58 189.48,150.99 189.2,150.99 188.76,150.55 188.63,150.55 188.34,150.85 188.34,150.97 188.78,151.41 188.78,151.69 188.37,152.1 188.09,152.1 187.65,151.66 187.53,151.66 187.23,151.95 187.23,152.08 187.67,152.52 187.67,152.8 187,153.46 187,156.52 181.34,162.18 178.42,162.18 178.22,161.98 178.22,161.91 178.14,161.82 177.84,161.82 177.76,161.91 177.76,161.98 177.56,162.18 177.11,162.18 176.91,161.98 176.91,161.87 176.83,161.78 176.53,161.78 176.44,161.87 176.44,161.98 176.25,162.18 174.46,162.18 172.56,164.08 170.96,164.08 170.17,164.88 169.58,164.88 168.7,165.76 165.99,165.76 165.53,166.22 164.59,166.22 164.19,165.83 163.7,165.83 163.63,165.9 163.16,165.9 162.88,166.18 162.43,166.18 162.15,165.9 160.98,165.9 160.79,166.09 160.79,166.32 161.05,166.59 v1(161.21,166.59)
  BOTTOM w0.102: v2(242.38,131.87) 242.38,131.89 UG6.BJ22
  BOTTOM w0.14: v1(161.21,166.59) 160.92,166.29 160.92,166.07 160.59,165.75 160.05,165.75 159.59,165.29 159.59,162.09 C641.2
INT_DP1_D2#: length 150.9
  IN4 w0.086: v1(160.31,166.59) 160.6,166.29 160.6,166.02 160.91,165.71 162.23,165.71 162.51,165.99 162.8,165.99 163.08,165.71 163.55,165.71 163.62,165.64 164.27,165.64 164.66,166.03 165.45,166.03 165.91,165.57 168.62,165.57 169.5,164.69 170.09,164.69 170.88,163.89 172.48,163.89 174.38,161.99 176.17,161.99 176.26,161.91 176.26,161.79 176.45,161.6 176.9,161.6 177.1,161.79 177.1,161.91 177.19,161.99 177.48,161.99 177.57,161.91 177.57,161.83 177.76,161.63 178.21,161.63 178.41,161.83 178.41,161.91 178.5,161.99 181.26,161.99 186.81,156.44 186.81,153.38 187.48,152.72 187.48,152.6 187.04,152.15 187.04,151.88 187.45,151.47 187.73,151.47 188.17,151.91 188.29,151.91 188.59,151.61 188.59,151.49 188.15,151.05 188.15,150.77 188.56,150.36 188.83,150.36 189.28,150.8 189.4,150.8 189.7,150.5 189.7,150.38 189.26,149.94 189.26,149.66 189.66,149.25 189.94,149.25 190.38,149.69 190.5,149.69 190.8,149.4 190.8,149.27 190.36,148.83 190.36,148.56 190.77,148.15 191.05,148.15 191.49,148.59 191.61,148.59 191.91,148.29 191.91,148.17 191.47,147.73 191.47,147.45 191.88,147.04 192.16,147.04 192.6,147.48 192.72,147.48 193.1,147.1 193.1,146.98 192.71,146.58 192.71,146.21 193.36,145.56 193.36,140.95 193.27,140.86 193.08,140.86 192.89,140.66 192.89,140.09 193.08,139.89 193.27,139.89 193.36,139.8 193.36,139.38 193.27,139.3 193.08,139.3 192.89,139.1 192.89,138.53 193.09,138.32 193.27,138.32 193.36,138.24 193.36,137.82 193.27,137.73 193.09,137.73 192.89,137.53 192.89,136.96 193.08,136.76 193.27,136.76 193.36,136.67 193.36,136.25 193.27,136.17 193.09,136.17 192.89,135.96 192.89,135.34 193.08,135.14 193.27,135.14 193.36,135.06 193.36,134.63 193.27,134.55 193.08,134.55 192.89,134.35 192.89,130.83 199.59,124.12 202.19,124.12 204.91,121.39 207.37,121.39 207.46,121.3 207.46,120.92 207.69,120.69 208.08,120.69 208.31,120.92 208.31,121.31 208.39,121.39 208.71,121.39 208.83,121.27 208.83,120.84 209.03,120.65 209.46,120.65 209.71,120.89 209.71,121.31 209.79,121.39 210.12,121.39 210.2,121.31 210.2,120.84 210.4,120.65 210.98,120.65 211.17,120.84 211.17,121.31 211.26,121.39 211.68,121.39 211.77,121.31 211.77,120.84 211.96,120.65 212.54,120.65 212.74,120.84 212.74,121.31 212.82,121.39 213.25,121.39 213.33,121.31 213.33,120.84 213.53,120.65 214.11,120.65 214.3,120.84 214.3,121.31 214.39,121.39 214.81,121.39 214.9,121.31 214.9,120.84 215.09,120.65 215.72,120.65 215.91,120.84 215.91,121.31 216,121.39 216.42,121.39 216.51,121.31 216.51,120.84 216.7,120.65 217.28,120.65 217.48,120.84 217.48,121.31 217.56,121.39 217.99,121.39 218.07,121.31 218.07,120.84 218.27,120.65 218.85,120.65 219.04,120.84 219.04,121.31 219.13,121.39 219.55,121.39 219.64,121.31 219.64,120.84 219.83,120.65 220.41,120.65 220.61,120.84 220.61,121.31 220.69,121.39 221.11,121.39 221.2,121.31 221.2,120.84 221.4,120.65 221.97,120.65 222.17,120.84 222.17,121.31 222.26,121.39 222.68,121.39 222.77,121.31 222.77,120.84 222.96,120.65 223.54,120.65 223.74,120.84 223.74,121.31 223.82,121.39 224.24,121.39 224.33,121.31 224.33,120.84 224.53,120.65 225.1,120.65 225.3,120.84 225.3,121.24 225.39,121.32 225.81,121.32 225.89,121.24 225.89,120.84 226.09,120.65 232.28,120.65 239.36,127.73 240.91,127.73 241.97,128.79 241.97,131.23 242.06,131.31 242.24,131.31 v2(242.4,131.16)
  BOTTOM w0.102: UG6.BK22 242.4,131.17 v2(242.4,131.16)
  BOTTOM w0.14: v1(160.31,166.59) 160.6,166.29 160.6,166.21 160.46,166.07 159.92,166.07 159.27,165.42 159.27,162.14 C640.2
INT_DP1_D2#_C: length 9.7
  BOTTOM w0.079: 158.4,156.76 158.4,156.74 158.48,156.66 158.48,155.35 158.97,154.86 158.97,154.31 158.82,154.16 158.82,153.16 158.75,153.09 158.6,153.09 158.52,153.16 U42.AJ40
  BOTTOM w0.14: C640.1 159.24,161.44 159.38,161.3 159.38,160.86 159.13,160.62 159.13,159.98 158.4,159.24 158.4,156.76
INT_DP1_D2_C: length 9.7
  BOTTOM w0.079: U42.AJ39 158.98,153.1 158.98,154.09 159.13,154.24 159.13,154.92 158.63,155.42 158.63,156.66 158.71,156.74 158.71,156.76
  BOTTOM w0.14: 158.71,156.76 158.71,159.11 159.45,159.85 159.45,160.49 159.69,160.73 159.69,161.35 C641.1
INT_DP1_D3: length 152.8
  IN4 w0.086: v2(242.4,129.77) 242.4,130.02 242.48,130.11 242.63,130.11 242.89,129.84 243.53,129.84 243.73,129.64 243.73,129.34 243.54,129.16 242.7,129.16 242.19,128.64 242.19,128.32 242.37,128.13 242.37,128.01 242.07,127.71 241.95,127.71 241.76,127.9 241.49,127.9 240.63,127.03 240.5,127.03 240.28,127.26 239.55,127.26 239.31,127.02 239.31,126.74 240.2,125.85 240.2,125.61 240,125.41 239.79,125.41 238.89,126.32 238.61,126.32 238.2,125.91 238.2,125.63 239.76,124.07 239.76,123.85 239.55,123.63 239.36,123.63 237.78,125.21 237.5,125.21 237.09,124.8 237.09,124.52 237.98,123.64 237.98,123.47 237.7,123.2 237.58,123.2 236.67,124.1 236.39,124.1 235.95,123.66 235.95,123.38 236.28,123.06 236.28,122.93 235.98,122.64 235.86,122.64 235.53,122.96 235.25,122.96 232.47,120.18 205.54,120.18 204.95,119.59 204.62,119.59 204.37,119.85 204.37,120.2 204.77,120.6 204.77,120.88 202.2,123.45 198.82,123.45 198.09,122.72 197.96,122.72 197.67,123.02 197.67,123.14 198.5,123.97 198.5,124.37 198.19,124.68 197.7,124.68 197.56,124.83 197.56,125.49 192.42,130.63 192.42,140.85 192.89,141.33 192.89,143.75 192.7,143.95 192.31,143.95 192.23,144.04 192.23,144.46 192.31,144.54 192.7,144.54 192.89,144.74 192.89,145.36 186.35,151.91 186.35,153.07 186.15,153.27 185.4,153.27 185.32,153.35 185.32,153.77 185.41,153.86 186.15,153.86 186.35,154.06 186.35,154.64 186.15,154.83 185.44,154.83 185.32,154.96 185.32,155.34 185.4,155.43 186.15,155.43 186.35,155.62 186.35,156.25 185.51,157.08 184.95,157.08 184.74,156.87 184.62,156.87 184.32,157.17 184.32,157.29 184.53,157.5 184.53,157.78 184.12,158.19 183.84,158.19 183.63,157.98 183.51,157.98 183.21,158.28 183.21,158.4 183.42,158.61 183.42,158.89 183.01,159.3 182.74,159.3 182.53,159.09 182.41,159.09 182.11,159.39 182.11,159.51 182.32,159.72 182.32,159.99 181.91,160.4 181.63,160.4 181.42,160.19 181.3,160.19 181,160.49 181,160.62 181.21,160.82 181.21,161.1 180.78,161.53 179.72,161.53 179.59,161.4 179.39,161.4 179.06,161.07 175.87,161.07 175.79,161.16 175.79,161.33 175.59,161.53 174.96,161.53 174.76,161.33 174.76,160.63 174.61,160.48 174.34,160.48 174.17,160.65 174.17,161.32 173.97,161.52 173.62,161.52 171.72,163.42 170.7,163.42 169.89,164.22 169.18,164.22 168.7,164.71 166.13,164.71 165.67,165.17 163.3,165.17 162.83,164.71 161.65,164.71 161.46,164.9 161.46,165.1 161.58,165.22 v1(161.95,165.22)
  BOTTOM w0.102: v2(242.4,129.77) 242.4,129.95 242.22,130.12 UG6.BM22
  BOTTOM w0.14: C650.2 160.89,160.82 160.89,162.23 160.61,162.51 160.61,163.5 161.53,164.42 161.53,165.05 161.7,165.22 v1(161.95,165.22)
INT_DP1_D3#: length 152.8
  IN4 w0.086: v2(242.4,130.47) 242.58,130.3 242.7,130.3 242.97,130.03 243.61,130.03 243.91,129.72 243.91,129.27 243.62,128.97 242.78,128.97 242.37,128.57 242.37,128.39 242.56,128.21 242.56,127.93 242.15,127.52 241.87,127.52 241.69,127.71 241.56,127.71 240.7,126.85 240.42,126.85 240.2,127.07 239.63,127.07 239.5,126.94 239.5,126.82 240.38,125.93 240.38,125.53 240.07,125.22 239.71,125.22 238.81,126.13 238.69,126.13 238.39,125.83 238.39,125.71 239.95,124.15 239.95,123.77 239.62,123.44 239.28,123.44 237.7,125.02 237.58,125.02 237.28,124.72 237.28,124.6 238.16,123.72 238.16,123.4 237.78,123.01 237.5,123.01 236.59,123.92 236.47,123.92 236.14,123.58 236.14,123.46 236.46,123.14 236.46,122.86 236.06,122.45 235.78,122.45 235.45,122.78 235.33,122.78 232.55,119.99 205.62,119.99 205.03,119.41 204.54,119.41 204.18,119.77 204.18,120.28 204.58,120.68 204.58,120.8 202.12,123.26 198.9,123.26 198.16,122.53 197.89,122.53 197.48,122.94 197.48,123.22 198.31,124.05 198.31,124.29 198.11,124.5 197.62,124.5 197.37,124.75 197.37,125.42 192.23,130.55 192.23,140.93 192.7,141.41 192.7,143.68 192.62,143.76 192.23,143.76 192.04,143.96 192.04,144.54 192.23,144.73 192.62,144.73 192.7,144.82 192.7,145.29 186.16,151.83 186.16,152.99 186.07,153.08 185.32,153.08 185.13,153.28 185.13,153.84 185.33,154.05 186.07,154.05 186.16,154.14 186.16,154.56 186.07,154.64 185.36,154.64 185.13,154.88 185.13,155.42 185.32,155.61 186.07,155.61 186.16,155.7 186.16,156.17 185.43,156.89 185.03,156.89 184.82,156.69 184.54,156.69 184.13,157.09 184.13,157.37 184.34,157.58 184.34,157.7 184.04,158 183.92,158 183.71,157.79 183.44,157.79 183.03,158.2 183.03,158.48 183.23,158.69 183.23,158.81 182.94,159.11 182.81,159.11 182.61,158.9 182.33,158.9 181.92,159.31 181.92,159.59 182.13,159.79 182.13,159.92 181.83,160.21 181.71,160.21 181.5,160.01 181.22,160.01 180.81,160.42 180.81,160.69 181.02,160.9 181.02,161.02 180.71,161.34 179.8,161.34 179.67,161.21 179.47,161.21 179.13,160.88 175.79,160.88 175.6,161.08 175.6,161.25 175.51,161.34 175.04,161.34 174.95,161.25 174.95,160.55 174.69,160.29 174.26,160.29 173.98,160.57 173.98,161.25 173.89,161.33 173.55,161.33 171.64,163.23 170.62,163.23 169.82,164.04 169.11,164.04 168.62,164.52 166.06,164.52 165.59,164.98 163.38,164.98 162.91,164.52 161.57,164.52 161.27,164.82 161.27,165 v1(161.05,165.22)
  BOTTOM w0.102: v2(242.4,130.47) UG6.BL22
  BOTTOM w0.14: C649.2 160.57,160.71 160.57,162.1 160.29,162.38 160.29,163.63 161.22,164.55 161.22,165.05 v1(161.05,165.22)
INT_DP1_D3#_C: length 8
  BOTTOM w0.079: U42.AG41 159.22,153.87 159.22,153.76 159.32,153.66 159.43,153.66 159.58,153.8 159.58,154.1 159.35,154.32 159.35,156.66 159.27,156.74 159.27,156.76
  BOTTOM w0.14: 159.27,156.76 159.27,158.68 160.06,159.47 160.41,159.47 160.61,159.67 160.61,159.95 160.47,160.09 C649.1
INT_DP1_D3_C: length 8
  BOTTOM w0.079: 159.59,156.76 159.59,156.74 159.51,156.66 159.51,154.39 159.74,154.16 159.74,153.74 U42.AG40
  BOTTOM w0.14: C650.1 160.93,159.85 160.93,159.53 160.54,159.15 160.19,159.15 159.59,158.55 159.59,156.76
INT_DP2_AUXN: length 152.4
  IN4 w0.086: v1(154.78,162.45) 155,162.68 155.88,162.68 155.98,162.69 158.59,163.07 159.97,163.21 163.61,163.21 166.46,162.64 169.15,162.64 169.5,162.5 170.43,161.57 171.13,161.57 173.38,159.32 173.38,159.22 174.5,158.1 176.81,157.14 177.8,157.14 181.04,155.8 181.93,154.91 181.93,154.21 190.71,145.42 190.71,130.22 196.06,124.87 196.06,117.79 198.7,115.14 202.62,115.14 205.93,118.45 230.02,118.45 232.54,117.95 233.72,117.95 234.28,118.51 234.28,118.71 234.73,119.16 234.73,120.53 235.13,120.93 235.72,120.93 236.35,121.57 238.26,122.36 240.71,122.36 241.56,123.2 241.56,125.3 242.32,126.06 242.32,126.79 245.78,130.25 245.78,130.92 246.49,131.63 246.49,132.12 246.23,132.39 246.23,132.79 247.08,133.64 249.3,133.64 249.53,133.4 249.53,133 249.95,132.58 249.95,132.33 250.26,132.03 250.63,132.03 v2(250.83,131.83)
  BOTTOM w0.102: v2(250.83,131.83) 250.76,131.83 UG6.BK10
  BOTTOM w0.14: C634.2 150.38,162.33 150.58,162.53 150.58,162.74 RG113.1 150.35,163.15 150.57,163.37 150.57,164.17 150.87,164.47 151.28,164.64 153.78,164.64 155.19,164.36 155.76,163.79 155.76,163.13 155.26,162.63 154.96,162.63 v1(154.78,162.45)
INT_DP2_AUXN_C: length 12.4
  BOTTOM w0.102: U42.AR40 154.68,153.11 154.76,153.03 154.87,153.03 154.98,153.14 154.98,154.16 155.14,154.33 155.14,154.63 154.84,154.93 154.84,156.7 154.78,156.76
  BOTTOM w0.14: 154.78,156.76 154.78,156.99 153.46,158.31 152.14,158.31 150.67,159.78 150.67,161.69 150.48,161.88 C634.1
INT_DP2_AUXP: length 152.4
  IN4 w0.086: v2(250.81,132.56) 250.84,132.56 250.93,132.47 250.93,132.34 250.81,132.22 250.33,132.22 250.14,132.41 250.14,132.66 249.72,133.08 249.72,133.48 249.38,133.83 247,133.83 246.04,132.87 246.04,132.31 246.31,132.04 246.31,131.71 245.6,131 245.6,130.33 242.13,126.87 242.13,126.14 241.37,125.38 241.37,123.28 240.63,122.54 238.22,122.54 236.24,121.73 235.64,121.12 235.05,121.12 234.55,120.61 234.55,119.24 234.09,118.78 234.09,118.59 233.64,118.14 232.56,118.14 230.04,118.64 205.85,118.64 202.54,115.33 198.78,115.33 196.25,117.87 196.25,124.95 190.9,130.3 190.9,145.5 182.11,154.29 182.11,154.99 181.15,155.96 177.84,157.33 176.85,157.33 174.61,158.26 173.57,159.3 173.57,159.39 171.2,161.76 170.51,161.76 169.61,162.66 169.19,162.83 166.48,162.83 163.63,163.4 159.95,163.4 158.67,163.27 155.87,162.86 154.71,162.86 154.62,162.95 154.62,163.14 v1(154.78,163.3)
  BOTTOM w0.102: v2(250.81,132.56) 250.75,132.62 250.36,132.62 250.26,132.51 250.26,132.33 250.37,132.22 UG6.BJ10
  BOTTOM w0.14: v1(154.78,163.3) 154.78,163.09 154.92,162.95 155.13,162.95 155.45,163.26 155.45,163.65 155.03,164.07 153.75,164.33 151.34,164.33 151.05,164.21 150.89,164.04 150.89,163.37 151.11,163.15 RG114.1 150.89,162.74 150.89,162.56 151.12,162.33 C635.2
INT_DP2_AUXP_C: length 12.4
  BOTTOM w0.102: 155.1,156.76 155.02,156.68 155.02,155 155.32,154.7 155.32,154.25 155.16,154.09 155.16,153.06 154.94,152.85 154.76,152.85 154.68,152.78 U42.AR39
  BOTTOM w0.14: C635.1 150.99,161.57 150.99,159.91 152.27,158.63 153.59,158.63 155.1,157.12 155.1,156.76
INT_DP2_D0: length 159.1
  TOP w0.14: C58.2 160.59,156.93 160.59,157.24 160.87,157.53 v1(160.96,157.53)
  IN4 w0.086: v2(246.59,125.29) 246.59,125.49 246.5,125.57 245.54,125.57 244.7,124.73 244.7,122.03 244.2,121.54 244.2,120.45 241.74,117.99 241.74,117.54 240.71,116.52 240.71,115.67 238.26,113.22 231.65,113.22 231.46,113.42 231.46,113.86 231.37,113.95 230.95,113.95 230.86,113.86 230.86,113.42 230.67,113.22 230.09,113.22 229.89,113.42 229.89,113.97 229.8,114.06 229.41,114.06 229.3,113.95 229.3,113.42 229.1,113.22 228.52,113.22 228.33,113.42 228.33,113.86 228.19,114 227.87,114 227.73,113.86 227.73,113.42 227.54,113.22 226.96,113.22 226.76,113.42 226.76,113.92 226.68,114.01 226.25,114.01 226.17,113.92 226.17,113.42 225.97,113.22 225.39,113.22 225.2,113.42 225.2,114.02 225.11,114.11 224.69,114.11 224.6,114.02 224.6,113.42 224.41,113.22 223.83,113.22 223.63,113.42 223.63,114.02 223.55,114.11 223.13,114.11 223.04,114.02 223.04,113.42 222.84,113.22 222.26,113.22 222.07,113.42 222.07,114.02 221.98,114.11 221.56,114.11 221.47,114.02 221.47,113.42 221.28,113.22 220.7,113.22 220.5,113.42 220.5,114.02 220.42,114.11 220,114.11 219.91,114.02 219.91,113.42 219.71,113.22 219.14,113.22 218.94,113.42 218.94,114.02 218.85,114.11 218.43,114.11 218.35,114.02 218.35,113.42 218.15,113.22 217.57,113.22 217.37,113.42 217.37,114.02 217.29,114.11 216.87,114.11 216.78,114.02 216.78,113.42 216.58,113.22 216.01,113.22 215.81,113.42 215.81,114.02 215.72,114.11 215.3,114.11 215.22,114.02 215.22,113.42 215.02,113.22 204.41,113.22 203.71,112.52 197.61,112.52 193.44,116.7 193.44,123.6 188.09,128.94 188.09,142.84 184.68,146.24 184.56,146.24 184.33,146.01 184.06,146.01 183.65,146.42 183.65,146.7 183.88,146.93 183.88,147.05 183.24,147.68 183.12,147.68 182.74,147.3 182.46,147.3 182.05,147.71 182.05,147.99 182.43,148.37 182.43,148.49 182.14,148.79 182.01,148.79 181.63,148.41 181.35,148.41 180.94,148.81 180.94,149.09 181.33,149.48 181.33,149.6 180.59,150.34 179.64,150.34 176.57,153.4 175.89,153.4 175.77,153.52 173.9,153.52 172.8,154.61 172.68,154.61 172.09,154.02 172.03,153.96 171.75,153.96 171.34,154.37 171.34,154.65 171.99,155.3 171.99,155.42 171.7,155.72 171.57,155.72 170.92,155.07 170.64,155.07 170.23,155.48 170.23,155.75 170.89,156.41 170.89,156.53 170.59,156.83 170.47,156.83 169.81,156.17 169.53,156.17 169.12,156.58 169.12,156.86 169.78,157.52 169.78,157.64 169.48,157.94 169.36,157.94 168.7,157.28 168.43,157.28 168.02,157.69 168.02,157.97 168.67,158.62 168.67,158.74 168.17,159.25 164.8,159.25 163.52,157.97 160.64,157.97 160.55,157.88 160.55,157.55 160.64,157.47 160.9,157.47 v1(160.96,157.53)
  BOTTOM w0.102: UG6.BR16 246.38,127.89 246.38,127.7 246.59,127.49 246.59,126.94 245.9,126.25 245.9,125.81 246.12,125.59 246.47,125.59 246.59,125.47 v2(246.59,125.29)
