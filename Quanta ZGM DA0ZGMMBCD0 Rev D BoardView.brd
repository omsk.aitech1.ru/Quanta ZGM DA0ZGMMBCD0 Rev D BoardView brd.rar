# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BSTAUX1: length 0.9
  TOP w0.14: PC245.2 v1(238.77,42.63)
BT_EN: length 134.4
  TOP w0.14: v1(190.48,62.85) 190.51,62.85 192.36,64.7 192.36,65.37 192.04,65.69 189.1,65.69 188.84,65.94 R474.1
  IN3 w0.089: v1(270.99,73.88) 272.83,73.88 273.73,72.97 273.73,66.16 272.63,65.06 272.63,64.3 272.22,63.88 270.95,63.88 270.35,63.28 270.35,61.87 270.86,61.36 270.86,59.91 269.75,58.8 264.97,58.8 263.43,57.26 262.35,57.26 259.89,54.8 257.86,54.8 257.55,55.11 251.55,55.11 250.89,55.77 246.69,55.77 246.03,55.11 239.52,55.11 238.39,53.99 238.39,53.46 238.01,53.09 237.02,53.09 236.23,52.3 235.46,52.3 235.09,52.67 229.99,52.67 229.24,51.93 227.88,51.93 227.64,52.17 224.6,52.17 222.93,50.5 222.71,50.5 221.69,49.48 220.66,49.48 219.94,50.2 218.61,50.2 217.88,49.46 215.37,49.46 215.17,49.26 215.17,47.95 214.76,47.55 212.71,47.55 212.47,47.78 209.34,47.78 209.23,47.9 204.85,47.9 203.57,46.62 198.68,46.62 198.47,46.82 195.64,46.82 194.52,47.94 193.35,47.94 192.69,48.6 190.73,48.6 189.11,50.22 v1(189.11,50.52)
  BOTTOM w0.14: v1(189.11,50.52) 189.11,51.12 188.96,51.26 188.96,53.67 188.29,54.35 188.29,54.84 187.46,55.66 187.46,60.06 188.62,61.22 188.89,61.22 190.48,62.82 v1(190.48,62.85) ; R947.2 271.95,74.4 271.43,73.88 v1(270.99,73.88)
BT_EN_R: length 4.9
  BOTTOM w0.14: R938.1 272.41,75.84 272.57,75.68 272.76,75.68 272.86,75.58 R943.1 R947.1 273.07,74.4 273.3,74.62 v1(273.73,74.62) 274.11,74.24 CN12.54
BT_OFF_PCH#: length 71.3
  IN2 w0.089: v1(230.49,65.65) 231.43,65.65 232.62,64.46 233.41,64.46 235.12,62.76 238.87,62.76 239.01,62.62 247.9,62.62 248.57,61.95 250.59,61.95 252.97,64.33 252.97,67.52 256.63,71.18 261.68,71.18 261.83,71.34 263.79,71.34 265.57,69.56 267.11,69.56 267.47,69.2 268.53,69.2 268.86,69.53 268.86,69.9 268.56,70.2 267.74,70.2 267.59,70.36 267.08,70.36 266.35,71.1 266.35,72.23 269.27,75.15 270.96,75.15 v1(271.03,75.22)
  BOTTOM w0.102: U49.AW35 220.6,62.61 221.97,63.98 222.39,63.98 222.76,64.35 223.46,64.35 224.3,65.19 225.47,65.19 225.78,65.5 227.8,65.5 227.99,65.32 228.69,65.32 R984.1 228.89,65.31 229.08,65.12 229.9,65.12 230.42,65.65 v1(230.49,65.65)
  BOTTOM w0.14: R943.2 271.1,75.16 v1(271.03,75.22) v1(271.03,76.02)
BV_REF: length 19.9
  TOP w0.14: PR18.1 232.18,214.85 v1(232.84,214.85) ; PR5.2 PR4.1 224.74,216.47 224.34,216.07 223.08,216.07 v1(222.68,215.67) 222.68,214.77 PR26.1 224.05,213.4 PR32.2
  IN4 w0.086: v1(222.68,215.67) 223.61,215.67 223.98,215.3 225.2,215.3 226,216.1 228.74,216.1 230,214.85 v1(232.84,214.85)
  BOTTOM w0.14: PC283.1 222.92,215.67 v1(222.68,215.67)
C10_WAKE: length 166.5
  IN2 w0.089: v1(121.06,143.9) 121.54,143.42 121.54,142.9 121.07,142.42 121.07,140.69 114.55,134.18 113.28,134.18 112.96,133.86 112.96,126.79 111.93,125.75 111.93,124.25 112.6,123.58 123.44,123.58 125.66,121.36 179.39,121.36 194.17,106.59 196.72,106.59 197.08,106.22 197.08,106.21 197.74,105.55 197.74,104.27 198.32,103.69 198.72,103.69 199.83,102.58 200.85,102.58 201.51,101.92 201.51,99.99 201.84,99.66 201.84,95.34 203.8,93.38 203.8,89.87 203.86,89.8 203.86,88.58 206.41,86.04 207.07,86.04 207.39,85.71 211.41,85.71 212.94,87.24 v1(213.46,87.24)
  BOTTOM w0.102: 216.38,82.93 216.38,82.42 215.51,81.55 215.51,78.85 215.4,78.75 215.4,78.25 U49.AJ4
  BOTTOM w0.14: R804.2 121.83,143.52 121.39,143.52 121.06,143.86 v1(121.06,143.9) ; 216.38,82.93 216.38,85 216.19,85.2 216.19,85.63 215.94,85.88 215.37,85.88 215.1,86.15 215.1,86.95 TP133.1 215.16,87.73 214.68,88.22 213.84,88.22 213.54,87.91 213.54,87.31 v1(213.46,87.24)
C10_WAKE_CPU: length 5.4
  BOTTOM w0.102: 126.74,143.45 126.95,143.45 127.21,143.19 U42.CU23
  BOTTOM w0.14: 126.74,143.45 125.99,144.2 125.62,144.2 125.36,143.95 125.36,143.43 v1(124.48,142.55) 124.13,142.55 R804.1
C_INT_DP_AUXN: length 61.2
  TOP w0.14: v1(18.67,3.12) 18.39,3.4 18.39,4.17 19.02,4.79 19.02,5.29 Q72.6 19.02,5.38 19.02,6.19 19.23,6.41 19.23,6.76 C561.1 19.23,6.97 19.23,7.47 R677.2 19.22,7.69 19.22,8.61 18.61,9.22 18.35,9.22 18.25,9.31 ESD1.2 ESD1.9
  IN1 w0.086: v1(17.3,17.41) 16.91,17.02 16.45,17.02 15.99,16.56 15.99,13.73 14.93,12.67 14.93,9.31 14.77,9.14 14.77,6.84 16.88,4.73 16.88,2.49 17.18,2.18 18.07,2.18 18.32,2.43 18.32,2.78 v1(18.67,3.12)
  IN2 w0.089: v1(18.67,3.12) 18.67,3.31 18.52,3.45 18.28,3.45 18.17,3.34 18.17,2.58 18.41,2.34 18.69,2.34 19.31,2.96 19.31,4.84 18.93,5.21 18.93,6.73 21.33,9.12 23.31,9.12 27.12,12.94 27.12,21.75 26.1,22.77 25.67,22.77 25.5,22.6 v2(25.5,22.5)
  BOTTOM w0.14: U56.25 24.85,22.88 25.06,22.67 25.34,22.67 v2(25.5,22.5) 25.64,22.64 25.88,22.64 R1185.2 ; v1(17.3,17.41) 17.01,17.12 16.43,17.12 16.29,17.26 CN24.18
C_INT_DP_AUXP: length 59.8
  TOP w0.14: ESD1.10 ESD1.1 18.26,8.82 18.35,8.9 18.48,8.9 18.9,8.48 18.9,7.68 R676.1 18.91,7.47 18.91,6.97 C560.1 18.92,6.74 18.92,6.54 18.7,6.32 18.7,4.93 18.07,4.3 18.07,4.03 Q71.6 18.07,3.94 18.07,3.43 v1(17.77,3.12)
  IN1 w0.086: v1(17.3,16.51) 16.98,16.83 16.53,16.83 16.17,16.48 16.17,13.65 15.12,12.59 15.12,9.23 14.95,9.07 14.95,6.91 17.06,4.8 17.06,2.57 17.26,2.37 17.99,2.37 18.13,2.51 18.13,2.76 v1(17.77,3.12)
  IN2 w0.089: v1(17.77,3.12) 17.95,2.94 17.95,2.49 18.32,2.12 18.78,2.12 19.53,2.87 19.53,4.93 19.15,5.3 19.15,6.64 21.42,8.91 23.4,8.91 27.34,12.85 27.34,21.84 26.19,22.98 25.61,22.98 v2(25.49,23.1)
  BOTTOM w0.14: U56.24 24.9,23.28 25.19,22.99 25.38,22.99 v2(25.49,23.1) 25.63,22.96 25.82,22.96 R1184.2 ; v1(17.3,16.51) 17.01,16.8 16.42,16.8 16.28,16.66 CN24.16
C_OUT_DP_TXN0: length 16.9
  IN1 w0.086: v1(19.29,15.73) 19.05,15.96 19.05,17.88 18.75,18.18 17.99,18.18 17.91,18.26 17.91,19.08 17.69,19.29 17.13,19.29 16.94,19.1 16.94,18.26 16.85,18.18 15.36,18.18 15.06,17.88 15.06,14.54 14.13,13.61 12.9,13.61 CN24.5
  BOTTOM w0.14: v1(19.29,15.73) 19.03,15.98 19.03,16.9 D74.2 18.99,17.1 18.99,17.82 C861.1
C_OUT_DP_TXN1: length 16.9
  TOP w0.14: CN24.11 13.19,15.32 14,15.32 14.47,14.85 14.67,14.85 14.89,15.08 14.89,15.78 15.22,16.1 15.9,16.1 16.24,15.76 16.24,15.34 16.38,15.2 17.26,15.2 17.59,14.88 17.59,14.09 17.75,13.93 18.19,13.93 18.33,14.07 18.33,14.88 18.65,15.2 20.36,15.2 20.69,14.88 20.69,14.32 v1(20.85,14.16)
  BOTTOM w0.14: v1(20.85,14.16) 20.71,14.3 20.71,15.43 21.08,15.8 21.08,16.87 D76.2 21.05,17.12 21.05,17.81 C865.1
C_OUT_DP_TXN2: length 16.5
  TOP w0.14: CN24.17 13.85,17.62 14.02,17.79 14.32,17.79 14.53,17.58 14.53,17.25 14.67,17.11 14.95,17.11 16.28,18.44 20.55,18.44 21.12,17.87 21.12,16.2 22.25,15.07 22.5,15.07 22.86,15.44 22.86,15.64 22.72,15.78 v1(22.55,15.78)
  BOTTOM w0.14: C863.1 22.82,18.03 22.95,17.89 22.95,17.22 D77.2 22.89,16.8 22.89,15.92 22.75,15.78 v1(22.55,15.78)
C_OUT_DP_TXN3: length 15.8
  BOTTOM w0.14: CN24.12 16.25,15.46 16.53,15.18 17.67,15.18 18,14.85 18,13.54 18.14,13.4 24.11,13.4 25.05,14.33 25.05,16.72 24.8,16.98 D79.2 25.01,17.19 25.01,17.9 24.89,18.02 C866.1
C_OUT_DP_TXP0: length 16.8
  IN1 w0.086: CN24.3 14.21,13.42 15.25,14.46 15.25,17.8 15.44,17.99 16.93,17.99 17.12,18.18 17.12,19.02 17.21,19.1 17.62,19.1 17.72,19 17.72,18.18 17.91,17.99 18.68,17.99 18.87,17.8 18.87,15.49 18.78,15.41 18.47,15.41 18.39,15.49 v1(18.39,15.73)
  BOTTOM w0.14: v1(18.39,15.73) 18.57,15.73 18.71,15.87 18.71,16.81 D73.2 18.67,17.1 18.67,17.83 C862.1
C_OUT_DP_TXP1: length 16.9
  TOP w0.14: CN24.9 13.19,15 13.87,15 14.34,14.53 14.8,14.53 15.21,14.95 15.21,15.65 15.35,15.79 15.77,15.79 15.92,15.63 15.92,15.21 16.25,14.89 17.13,14.89 17.27,14.75 17.27,13.96 17.62,13.61 18.32,13.61 18.65,13.94 18.65,14.75 18.79,14.89 20.23,14.89 20.37,14.75 20.37,14.3 20.23,14.16 v1(19.94,14.16)
  BOTTOM w0.14: C868.1 20.73,17.82 20.73,17.07 D75.2 20.76,16.84 20.76,15.93 20.39,15.56 20.39,14.34 20.21,14.16 v1(19.94,14.16)
C_OUT_DP_TXP2: length 16.5
  TOP w0.102: CN24.15 13.46,16.76 13.51,16.71 14.21,16.71
  TOP w0.14: 14.21,16.71 14.3,16.8 15.08,16.8 16.41,18.12 20.42,18.12 20.8,17.74 20.8,16.07 22.12,14.75 22.63,14.75 23.18,15.31 23.18,15.51 v1(23.45,15.78)
  BOTTOM w0.14: v1(23.45,15.78) 23.21,16.02 23.21,16.91 D78.2 23.27,17.92 C864.1
C_OUT_DP_TXP3: length 15.8
  BOTTOM w0.14: CN24.10 17.54,14.86 17.68,14.72 17.68,13.41 18.01,13.08 24.25,13.08 25.37,14.2 25.37,16.73 25.4,16.76 D80.2 25.33,17.05 25.33,17.91 C867.1
C_OUT_EDP_TXN0: length 2.1
  BOTTOM w0.14: C585.1 271.79,209.51 271.79,210.53 272,210.74 U36.33
C_OUT_EDP_TXN1: length 2
  BOTTOM w0.14: U36.30 273.2,210.76 273.27,210.69 273.27,209.51 C583.1
C_OUT_EDP_TXN2: length 2.2
  BOTTOM w0.14: C587.1 275.91,209.52 275.91,210.37 275.6,210.68 U36.24
C_OUT_EDP_TXN3: length 2.3
  BOTTOM w0.14: C589.1 277.38,209.52 277.38,210.41 276.8,211 U36.21
C_OUT_EDP_TXP0: length 2.1
  BOTTOM w0.14: C584.1 271.37,209.52 271.37,210.7 271.6,210.93 U36.34
C_OUT_EDP_TXP1: length 2
  BOTTOM w0.14: U36.31 272.8,210.57 272.85,210.51 272.85,209.52 C582.1
C_OUT_EDP_TXP2: length 2.1
  BOTTOM w0.14: U36.25 275.2,210.49 275.49,210.2 275.49,209.46 C586.1
C_OUT_EDP_TXP3: length 2.2
  BOTTOM w0.14: C588.1 276.96,209.45 276.96,210.24 276.4,210.81 U36.22
C_TX0_HDMI+: length 1.6
  TOP w0.14: U27.29 41.23,56.06 41.19,56.02 41.19,55.14 R601.1
C_TX0_HDMI-: length 1.7
  TOP w0.14: R600.1 40.77,55.31 40.77,56.02 40.73,56.06 U27.28
C_TX1_HDMI+: length 1.7
  TOP w0.14: U27.32 42.73,56.21 42.69,56.16 42.69,55.17 R603.1
C_TX1_HDMI-: length 1.7
  TOP w0.14: U27.31 42.23,56.17 42.27,56.14 42.27,55.28 R602.1
C_TX2_HDMI+: length 1.7
  TOP w0.14: U27.35 44.23,56.06 44.19,56.02 44.19,55.18 R605.1
C_TX2_HDMI-: length 1.7
  TOP w0.14: U27.34 43.73,56.06 43.77,56.02 43.77,55.26 R604.1
C_TXC_HDMI+: length 1.7
  TOP w0.14: U27.26 39.73,56.2 39.69,56.16 39.69,55.58 39.58,55.47 39.58,55.22 R599.1
C_TXC_HDMI-: length 1.7
  TOP w0.14: R598.1 39.16,55.22 39.16,55.64 39.27,55.75 39.27,56.15 39.23,56.19 U27.25
CAD_SNK: length 19.1
  TOP w0.14: R668.1 v1(25.91,15.43) 26.63,15.43 26.98,15.08 26.98,14.62 26.06,13.7 U34.2 22.94,13.7 22.29,13.05 R670.1 21.63,13.05 21.36,12.78 Q67.2 18.51,12.78 18.29,12.56 18.29,10.97 18.14,10.82 ESD1.5 ESD1.6 16.65,10.82 16.51,10.95 16.51,11.22 v1(16.79,11.5)
  BOTTOM w0.14: CN24.4 16.37,13.06 16.95,12.48 16.95,11.66 v1(16.79,11.5)
CAD_SNK_R_DP: length 12.1
  TOP w0.14: U34.4 23.73,14.35 23.87,14.49 23.87,15.1 R668.2 25,16.23 25,17.98 25.26,18.24 25.87,18.24 26.29,18.66 26.29,19.4 25.97,19.72 24.7,19.72 24.52,19.54 R664.2 23.93,19.54 23.8,19.42 R667.1 23.42,19.74 v1(23.96,20.28)
  BOTTOM w0.14: v1(23.96,20.28) 23.62,20.63 U56.29
CAP+: length 2.9
  TOP w0.14: C471.2 315.12,61.94 315.05,61.94 314.15,62.84 U20.23
CAP-: length 1.9
  TOP w0.14: U20.24 314.55,62.92 314.89,62.57 315.69,62.57 C471.1
CATERR#: length 14.5
  TOP w0.102: 176.99,149.7 172.62,149.7 171.98,150.34 v2(171.98,150.36)
  TOP w0.14: 176.99,149.7 182.12,149.7 TP14.1 184.03,147.46 183.93,147.36 R102.1
  BOTTOM w0.102: v2(171.98,150.36) 171.89,150.36 U42.H36
CCD_PWR:
  vias: v1(267.21,185.89)
CFG0: length 8.4
  BOTTOM w0.079: 169.32,155.36 169.32,154.34 169.56,154.11 169.56,152.52 169.38,152.35 169,152.35 168.86,152.21 168.86,151.05 U42.N36
  BOTTOM w0.14: TP107.1 170.96,157.09 169.32,155.45 169.32,155.36
CFG1: length 4
  TOP w0.14: R93.1 TP7.1 169.63,153.09 169.63,151.58 169.63,151.57 v2(169.63,151.01)
  BOTTOM w0.102: v2(169.63,151.01) 169.3,151.34 U42.M37
CFG2: length 1.6
  TOP w0.102: v2(169.62,150.36) 168.96,151.03 R99.1
  BOTTOM w0.102: U42.M35 169.59,150.36 v2(169.62,150.36)
CFG3: length 2.7
  TOP w0.102: TP8.1 170.84,152.07 v2(170.43,151.67)
  TOP w0.14: TP8.1 170.84,153.25 170.82,153.27 R96.1
  BOTTOM w0.079: U42.L37 170.36,151.67 v2(170.43,151.67)
CFG4: length 8.7
  BOTTOM w0.079: U42.N39 168.03,153.1 168.03,154.17 168.09,154.23 168.09,155.46
  BOTTOM w0.14: v1(167.14,159.6) 167.2,159.54 R768.1 168.05,159.46 168.9,158.61 168.9,156.45 168.09,155.64 168.09,155.46
CFG5: length 5.7
  TOP w0.14: v2(170.42,149.71) 170.03,150.1 170.03,151.83 169.94,151.91 169.94,153.74 R94.1
  BOTTOM w0.102: v2(170.42,149.71) 170.47,149.71 U42.J35
CFG6: length 8
  BOTTOM w0.079: U42.J38 171.08,152.27 171.08,153.53 171.29,153.73 171.29,154.1 171.48,154.29 171.48,154.88 171.76,155.16
  BOTTOM w0.14: R780.1 174.89,157.2 174.08,156.4 172.99,156.4 171.76,155.16
CFG7: length 9.3
  BOTTOM w0.079: U42.M38 169.61,151.99 169.74,152.11 169.74,154.29 169.57,154.46 169.57,154.95 169.87,155.24
  BOTTOM w0.14: 169.87,155.24 169.87,155.6 171.43,157.16 171.43,159.18 171.07,159.54 R770.1
CFG8: length 12.8
  BOTTOM w0.079: 171.97,155.03 171.76,154.82 171.76,154.25 171.89,154.12 171.89,153.85 171.69,153.65 171.46,153.65 171.24,153.43 171.24,151.78 U42.J37
  BOTTOM w0.14: TP90.1 173.76,159.94 174.6,159.1 175.26,159.1 175.54,158.83 175.54,158.39 175.29,158.14 175.29,157.17 174.26,156.14 173.08,156.14 171.97,155.03
CFG9: length 2
  TOP w0.102: R97.1 168.7,153.15 v2(168.89,152.96) 168.89,152.27 TP9.1
  BOTTOM w0.079: U42.M39 169.22,152.64 v2(168.89,152.96)
CFG10: length 7.2
  BOTTOM w0.079: 168.37,155.46 168.37,154.26 168.21,154.1 168.21,153.57 U42.N40
  BOTTOM w0.14: 168.37,155.46 168.37,155.58 169.19,156.4 169.19,158.37 TP97.1 169.69,158.9 R769.1
CFG11: length 7.9
  BOTTOM w0.079: U42.L40 170.32,153.58 170.32,154.25 170.59,154.52 170.59,155.26 170.55,155.3
  BOTTOM w0.14: TP95.1 173.27,158.48 173.27,157.82 173.08,157.63 R779.1 172.69,157.63 170.55,155.49 170.55,155.3
CFG12: length 4.2
  BOTTOM w0.14: U42.N41 168.72,154.16 168.72,155.59 169.69,156.56 TP106.1
CFG13: length 7
  BOTTOM w0.079: U42.J41 170.8,154.14 171.07,154.41 171.07,155.22
  BOTTOM w0.14: TP99.1 174.15,158.49 174.15,157.4 173.62,156.88 172.73,156.88 171.07,155.22
CFG14: length 4.6
  BOTTOM w0.079: U42.L41 170.03,154.24 170.41,154.62 170.41,155.08 170.26,155.23
  BOTTOM w0.14: 170.26,155.23 170.26,155.6 171.98,157.32 R778.1
CFG15: length 11
  BOTTOM w0.079: U42.J40 170.8,153.51 171.1,153.81 171.1,154.13 171.32,154.36 171.32,155.08 171.47,155.23
  BOTTOM w0.14: 171.47,155.23 172.88,156.64 173.93,156.64 174.43,157.14 174.43,158.88 173.82,159.49 173.29,159.49 172.27,160.5 TP87.1
CFG16: length 6.8
  BOTTOM w0.079: U42.L39 170.03,152.64 170.49,153.1 170.49,154.14 170.79,154.45 170.79,155.34
  BOTTOM w0.14: TP108.1 173.25,157.16 172.61,157.16 170.79,155.34
CFG17: length 5.8
  BOTTOM w0.14: TP98.1 170.4,158.31 170.4,156.92 169.05,155.57 169.05,154.16 U42.M41
CFG_RCOMP: length 6.6
  BOTTOM w0.254: R794.1 179.91,153.54 179.69,153.32 179.32,153.32 178.62,152.62 178.62,150.8 177.31,149.5 U42.A34
CHA_SA0: length 4.9
  TOP w0.14: v1(187.04,82.76) 187.03,82.74 187.03,79.83 R297.1 187.02,79.8 R298.2
  BOTTOM w0.14: JDIM2.256 187.03,82.74 v1(187.04,82.76)
CHA_SA1: length 8.1
  TOP w0.14: v1(187.66,84.67) 188.27,84.67 189.06,83.88 R237.1 189.28,84.08 189.49,84.29 189.91,84.29 R238.2
  BOTTOM w0.14: v1(187.66,84.67) 188.34,84.67 188.88,84.14 188.88,83.15 188.03,82.3 JDIM2.260
CHA_SA2: length 26
  TOP w0.14: v1(167.02,80.06) 167.63,80.67 171.74,80.67 172.19,80.22 178.28,80.22 178.5,80 182.22,80 183.15,79.07 R316.2 183.73,79.19 184.05,79.52 185.04,79.52 R296.1
  IN3 w0.089: v1(167.02,80.06) 166.07,81.01 166.07,82.31 v1(165,83.38)
  BOTTOM w0.14: v1(165,83.38) 165,83.32 164.53,82.85 JDIM2.166
CHB_SA0: length 6.8
  TOP w0.14: R120.2 187.32,99.53 R122.1 188.34,99.53 v1(188.77,99.1)
  BOTTOM w0.14: JDIM1.256 187.08,98.82 187.71,99.45 188.42,99.45 v1(188.77,99.1)
CHB_SA1: length 5.4
  TOP w0.14: R135.1 R131.2 187.55,98.77 188.24,98.77 188.57,98.44 v1(188.8,98.44)
  BOTTOM w0.14: JDIM1.260 188.08,96.87 188.32,97.12 188.8,97.12 189.11,97.42 189.11,98.14 v1(188.8,98.44)
CHB_SA2: length 5.6
  TOP w0.203: R137.2 R134.1 164.45,98.31 165.17,99.04 v1(165.48,99.04)
  BOTTOM w0.14: v1(165.48,99.04) 164.58,98.13 JDIM1.166
CLK_CPU_BCLKN: length 103.7
  IN4 w0.086: v1(200.31,79.44) 200.31,79.29 200.41,79.18 200.66,79.18 201.02,79.54 201.02,80.2 198.14,83.08 198.14,95.03 199.41,96.31 199.41,101.64 197.53,103.53 197.53,104.24 197.22,104.55 196.81,104.55 195.33,106.03 195.33,109.56 191.16,113.72 191.16,122.54 185.09,128.61 185.09,139.99 184.89,140.18 184.89,140.44 185.08,140.64 185.08,140.76 184.78,141.06 184.66,141.06 184.41,140.8 184.15,140.8 183.75,141.19 183.75,141.45 184.01,141.71 184.01,141.83 183.71,142.13 183.59,142.13 183.33,141.87 183.07,141.87 182.68,142.27 182.68,142.53 182.93,142.79 182.93,142.91 182.64,143.21 182.51,143.21 182.29,142.98 181.96,142.98 181.63,143.31 181.63,143.63 181.86,143.86 181.86,143.98 181.56,144.28 181.44,144.28 181.24,144.09 180.99,144.09 180.59,144.48 180.59,144.74 180.78,144.94 180.78,145.06 180.49,145.36 180.36,145.36 180.1,145.09 179.81,145.09 179.46,145.44 179.46,145.76 179.71,146.01 179.71,146.13 179.41,146.43 179.29,146.43 179.06,146.2 178.72,146.2 178.39,146.53 178.39,146.84 178.63,147.09 178.63,147.21 178.34,147.51 178.21,147.51 177.95,147.24 177.69,147.24 177.29,147.63 177.29,147.89 177.56,148.16 177.56,148.28 177.26,148.58 177.14,148.58 176.87,148.31 176.61,148.31 176.22,148.71 176.22,148.97 176.49,149.24 176.49,149.36 176.19,149.66 176.06,149.66 175.87,149.46 173.28,149.46 173.1,149.65 173.1,150.17 173.33,150.4 174.86,150.4 174.95,150.48 174.95,150.74 v2(174.71,150.97)
  BOTTOM w0.102: v1(200.31,79.44) 200.13,79.26 199.35,79.26 198.78,78.69 198.78,78.1 199.04,77.84 199.63,77.84 201.59,75.88 U49.A9 ; v2(174.71,150.97) 174.36,150.61 U42.D36
CLK_CPU_BCLKP: length 103.6
  IN4 w0.086: v1(200.13,78.78) 200.37,79.02 200.73,79.02 201.18,79.47 201.18,80.27 198.3,83.15 198.3,94.96 199.58,96.24 199.58,101.71 197.69,103.59 197.69,104.31 197.28,104.71 196.87,104.71 195.49,106.1 195.49,109.63 191.32,113.79 191.32,122.61 185.25,128.68 185.25,140.05 185.06,140.25 185.06,140.37 185.25,140.57 185.25,140.83 184.85,141.22 184.6,141.22 184.34,140.97 184.22,140.97 183.92,141.26 183.92,141.39 184.17,141.64 184.17,141.9 183.78,142.3 183.52,142.3 183.26,142.04 183.14,142.04 182.84,142.34 182.84,142.46 183.1,142.72 183.1,142.98 182.7,143.37 182.45,143.37 182.22,143.14 182.03,143.14 181.8,143.38 181.8,143.56 182.02,143.79 182.02,144.05 181.63,144.45 181.37,144.45 181.18,144.25 181.05,144.25 180.76,144.55 180.76,144.67 180.95,144.87 180.95,145.13 180.55,145.52 180.3,145.52 180.03,145.25 179.87,145.25 179.62,145.5 179.62,145.69 179.87,145.94 179.87,146.2 179.48,146.6 179.22,146.6 178.99,146.37 178.79,146.37 178.55,146.6 178.55,146.77 178.8,147.02 178.8,147.28 178.4,147.67 178.15,147.67 177.88,147.4 177.76,147.4 177.46,147.7 177.46,147.82 177.73,148.09 177.73,148.35 177.33,148.75 177.07,148.75 176.8,148.48 176.68,148.48 176.38,148.77 176.38,148.9 176.65,149.17 176.65,149.43 176.25,149.82 176,149.82 175.8,149.63 173.35,149.63 173.27,149.71 173.27,150.1 173.4,150.23 174.93,150.23 175.12,150.42 175.12,150.74 v2(175.35,150.97)
  BOTTOM w0.102: U49.B8 201.79,75.96 199.71,78.04 199.12,78.04 198.98,78.18 198.98,78.6 199.44,79.06 199.85,79.06 v1(200.13,78.78) ; v2(175.35,150.97) 175.01,150.63 U42.C36
CLK_DPLL_NSCCLKN: length 105
  TOP w0.14: R92.1 184.99,154.67 186.34,154.67 188.32,152.69 188.32,147.4 185.13,144.2 184.79,144.2 v1(184.61,144.02)
  IN4 w0.086: v1(184.61,144.02) 184.85,144.26 185.15,144.26 185.48,143.93 185.48,143.54 185,143.06 185,142.63 185.3,142.33 185.64,142.33 186.09,142.78 186.26,142.78 186.54,142.5 186.54,142.38 186.02,141.87 186.02,141.61 186.35,141.28 186.35,129.15 192.29,123.21 192.42,123.08 192.42,114.34 197.4,109.36 197.4,106.28 197.82,105.86 199.27,105.86 200.35,104.78 200.35,103.78 201.7,102.42 201.7,98.26 200.71,97.26 200.71,95.81 199.4,94.51 199.4,86.69 199.95,86.14 200.51,86.14 201.4,85.25 201.97,85.25 202.27,84.95 202.27,82.7 201.84,82.27 201.46,82.27 200.7,83.03 200.48,83.03 200.39,83.12 v1(200.39,83.26)
  BOTTOM w0.102: U49.D8 202.94,75.91 202.55,75.53 201.98,75.53 201.81,75.36 201.36,75.36 200.78,75.93 199.48,75.93 198.37,77.04 198.37,81.47 199.93,83.04 200.17,83.04 v1(200.39,83.26)
CLK_DPLL_NSCCLKN_C: length 11.5
  TOP w0.14: v2(174.71,152.85) 174.87,153 174.87,153.37 175.19,153.7 176.19,153.7 176.34,153.54 176.96,153.54 177.17,153.76 182.89,153.76 183.19,154.06 183.19,154.27 183.65,154.73 184.13,154.73 R92.2
  BOTTOM w0.102: v2(174.71,152.85) 174.71,152.75 U42.D39
CLK_DPLL_NSCCLKP: length 105
  TOP w0.14: v1(184.61,144.88) 184.61,144.61 184.76,144.47 185.01,144.47 188.06,147.51 188.06,152.58 186.23,154.4 184.9,154.4 184.76,154.26 R95.1
  IN4 w0.086: v1(184.61,144.88) 184.61,144.51 184.7,144.43 185.21,144.43 185.64,144 185.64,143.47 185.17,143 185.17,142.7 185.37,142.49 185.57,142.49 186.02,142.94 186.33,142.94 186.7,142.57 186.7,142.31 186.19,141.8 186.19,141.68 186.52,141.35 186.52,129.22 192.41,123.33 192.59,123.15 192.59,114.41 197.56,109.43 197.56,106.34 197.89,106.02 199.34,106.02 200.51,104.85 200.51,103.85 201.87,102.49 201.87,98.19 200.87,97.19 200.87,95.75 199.57,94.44 199.57,86.76 200.02,86.31 200.58,86.31 201.47,85.41 202.04,85.41 202.43,85.02 202.43,82.63 201.91,82.1 201.39,82.1 200.63,82.87 200.46,82.87 200.3,82.71 200.3,82.54 v1(200.39,82.45)
  BOTTOM w0.102: v1(200.39,82.45) 200.46,82.51 200.46,82.7 200.32,82.83 200.02,82.83 198.58,81.39 198.58,77.13 199.56,76.14 200.87,76.14 201.45,75.56 201.73,75.56 201.9,75.73 202.47,75.73 202.59,75.85 U49.C8
CLK_DPLL_NSCCLKP_C: length 11.5
  TOP w0.14: v2(175.35,152.85) 175.27,152.85 175.13,152.99 175.13,153.26 175.3,153.43 176.08,153.43 176.23,153.28 177.07,153.28 177.28,153.49 183,153.49 183.08,153.57 183.45,153.95 183.45,154.16 183.76,154.46 184.14,154.46 184.31,154.29 R95.2
  BOTTOM w0.102: v2(175.35,152.85) 175.35,152.74 U42.C39
CLK_PCIE_LANN: length 132.7
  IN1 w0.086: v1(315.57,85.83) 315.23,86.17 315.23,86.68 314.67,87.24 312.37,87.24 311.73,86.6 311.25,86.6 311,86.86 307.83,86.86 307.41,87.27 305.55,87.27 304.84,86.56 303.43,86.56 302.97,87.02 302.65,87.02 302.36,87.32 301.88,87.32 301.55,86.99 301.55,83.4 299.38,81.23 298.67,81.23 298.48,81.04 296.52,81.04 296.33,80.85 291.1,80.85 290.02,79.77 286.34,79.77 284.79,78.21 283.15,78.21 282.15,77.21 282.15,76.39 281.34,75.59 279.46,75.59 278.64,74.77 277.95,74.77 276.87,73.68 276.87,72.63 273.6,69.36 273.6,66.98 271.88,65.27 271.27,65.27 270.04,64.04 270.04,62 269.73,61.68 269.42,61.68 268.89,61.16 268.89,60.75 267.88,59.74 266.41,59.74 265.88,59.21 261.35,59.21 260.94,58.8 253.43,58.8 251.77,60.47 248.03,60.47 247.55,60.95 241.45,60.95 229.77,72.63 229.27,72.63 228.87,73.03 227.12,73.03 226.9,73.24 223.98,73.24 221.71,75.52 220.67,75.52 220.45,75.73 219.71,75.73 218.42,74.44 215.47,74.44 214.96,74.94 214.53,74.94 214.37,75.1 v1(214.37,75.25)
  BOTTOM w0.102: v1(214.37,75.25) 214.17,75.05 213.78,75.05 U49.AE9
  BOTTOM w0.14: CN10.5 316.1,84.41 316.01,84.33 315.72,84.33 315.26,84.79 315.26,85.52 v1(315.57,85.83)
CLK_PCIE_LANP: length 132.6
  IN1 w0.086: v1(314.72,85.83) 315.07,86.18 315.07,86.61 314.6,87.08 312.44,87.08 311.8,86.44 311.19,86.44 310.93,86.69 307.76,86.69 307.34,87.11 305.62,87.11 304.91,86.4 303.36,86.4 302.9,86.86 302.59,86.86 302.29,87.15 301.95,87.15 301.71,86.92 301.71,83.33 299.44,81.07 298.74,81.07 298.55,80.87 296.59,80.87 296.4,80.69 291.16,80.69 290.08,79.6 286.41,79.6 284.85,78.05 283.22,78.05 282.31,77.14 282.31,76.32 281.41,75.42 279.53,75.42 278.71,74.6 278.02,74.6 277.03,73.62 277.03,72.56 273.77,69.29 273.77,66.91 271.95,65.1 271.34,65.1 270.21,63.97 270.21,61.93 269.79,61.52 269.48,61.52 269.05,61.09 269.05,60.68 267.95,59.58 266.48,59.58 265.94,59.04 261.42,59.04 261.01,58.64 253.36,58.64 251.7,60.3 247.96,60.3 247.48,60.78 241.38,60.78 229.7,72.47 229.2,72.47 228.81,72.86 227.05,72.86 226.83,73.08 223.91,73.08 221.64,75.35 220.6,75.35 220.38,75.57 219.78,75.57 218.49,74.27 215.4,74.27 214.89,74.78 214.56,74.78 v1(214.36,74.58)
  BOTTOM w0.102: v1(214.36,74.58) 213.49,74.58 U49.AE11
  BOTTOM w0.14: v1(314.72,85.83) 315,85.56 315,84.68 315.61,84.06 316.05,84.06 316.2,83.91 CN10.6
CLK_PCIE_SSD1N: length 137.5
  IN4 w0.086: v1(210.16,72.15) 210.16,72.29 210.28,72.41 210.49,72.41 210.68,72.22 210.68,71.93 209.58,70.83 208.25,70.83 207.45,71.62 206.9,71.62 206.39,71.11 203.89,71.11 202.24,72.76 199.44,72.76 194.89,68.2 188.82,68.2 188.08,67.46 186.15,67.46 186.03,67.59 182.33,67.59 181.99,67.24 170.8,67.24 170.34,67.7 163.62,67.7 163.25,68.07 156.94,68.07 156.61,67.74 155.26,67.74 154.81,67.29 152.62,67.29 151.83,66.5 150.82,66.5 149.41,65.09 148.74,65.09 147.21,63.56 141.67,63.56 139.4,61.29 135.72,61.29 133.86,59.43 129.75,59.43 129.24,58.92 129.24,58.34 128.99,58.08 v1(128.77,58.08)
  BOTTOM w0.102: U49.V15 209.94,72.53 210.16,72.31 v1(210.16,72.15)
  BOTTOM w0.14: v1(128.77,58.08) 128.99,58.08 129.2,58.3 129.2,59.04 123.84,64.4 123.84,79.36 123.29,79.91 121.34,79.91 118.59,82.66 118.59,85.94 118.8,86.15 118.8,86.58 118.9,86.67 118.9,90.26 118.14,91.02 115.59,91.02 113.91,89.34 113.4,89.34 113.26,89.2 R854.1
CLK_PCIE_SSD1N_R: length 3.7
  BOTTOM w0.14: R854.2 112.56,89.24 111.94,89.24 111.05,88.35 110.62,88.35 110.5,88.23 CN6.53
CLK_PCIE_SSD1P: length 137.5
  IN4 w0.086: v1(210.25,72.8) 210.25,72.68 210.36,72.57 210.56,72.57 210.84,72.29 210.84,71.86 209.65,70.66 208.18,70.66 207.39,71.46 206.97,71.46 206.46,70.95 203.82,70.95 202.17,72.59 199.51,72.59 194.95,68.04 188.89,68.04 188.15,67.29 186.08,67.29 185.96,67.42 182.4,67.42 182.05,67.08 170.73,67.08 170.27,67.54 163.55,67.54 163.18,67.9 157.01,67.9 156.68,67.57 155.33,67.57 154.88,67.13 152.69,67.13 151.9,66.34 150.89,66.34 149.48,64.93 148.81,64.93 147.28,63.4 141.74,63.4 139.46,61.13 135.79,61.13 133.93,59.26 129.82,59.26 129.41,58.86 129.41,58.29 v1(129.62,58.08)
  BOTTOM w0.102: v1(210.25,72.8) 209.82,73.23 U49.V13
  BOTTOM w0.14: v1(129.62,58.08) 129.47,58.23 129.47,59.15 124.11,64.51 124.11,79.47 123.4,80.17 121.45,80.17 118.86,82.77 118.86,85.82 119.07,86.03 119.07,86.47 119.16,86.56 119.16,90.37 118.25,91.29 115.48,91.29 113.8,89.61 113.4,89.61 R850.1
CLK_PCIE_SSD1P_R: length 3.7
  BOTTOM w0.14: CN6.55 110.49,88.73 110.61,88.61 110.94,88.61 111.83,89.5 112.56,89.5 R850.2
CLK_PCIE_SSDN: length 124.1
  IN1 w0.086: v1(211.14,75.12) 210.92,75.34 210.79,75.34 210.67,75.22 210.67,74.58 210.79,74.46 210.79,73.47 210.84,73.43 210.84,71.95 210.4,71.51 209.93,71.51 209.81,71.63 209.26,71.63 209.13,71.76 208.94,71.76 208.45,71.27 207.68,71.27 207.45,71.5 207,71.5 206.12,72.38 205.13,72.38 204.55,71.79 203.14,71.79 202.58,72.35 200.08,72.35 199.93,72.2 199.93,69.72 199.37,69.16 199.37,67.26 198.97,66.86 198.61,66.86 197.66,65.91 197.66,65.56 196.86,64.75 196.86,64.24 195.68,63.06 195.09,63.06 193.04,61.01 191.48,61.01 190.53,61.96 187.92,61.96 186.87,60.91 184.52,60.91 184.3,61.13 180.75,61.13 180.51,61.37 174.89,61.37 174.68,61.16 171.79,61.16 171.62,61.33 168.5,61.33 166.47,59.3 166.26,59.3 165.93,58.97 164.48,58.97 164.14,59.31 160.75,59.31 159.83,60.24 157.27,60.24 156.98,60.53 150.41,60.53 149.38,59.5 148.92,59.5 147.98,58.56 141.96,58.56 141.64,58.88 134.46,58.88 134.14,58.56 124.15,58.56 122.78,57.19 121.54,57.19 121.36,57.37 121.36,57.85 121.14,58.07 v1(120.96,58.07)
  BOTTOM w0.102: v1(211.14,75.12) 210.89,74.86 U49.Y11
  BOTTOM w0.14: v1(120.96,58.07) 121.26,58.37 121.26,59.39 122.19,60.31 122.19,61.96 119.58,64.57 113.81,64.57 113.07,63.83 112.86,63.83 R992.1
CLK_PCIE_SSDN_R: length 2.9
  BOTTOM w0.14: CN13.53 110.46,63.18 110.58,63.3 111.12,63.3 111.65,63.82 111.94,63.82 R992.2
CLK_PCIE_SSDP: length 124.1
  IN1 w0.086: v1(210.98,75.84) 210.95,75.82 210.95,75.62 210.83,75.51 210.72,75.51 210.51,75.29 210.51,74.51 210.62,74.4 210.62,73.41 210.67,73.36 210.67,72.02 210.33,71.68 210,71.68 209.88,71.79 209.32,71.79 209.2,71.92 208.87,71.92 208.38,71.44 207.75,71.44 207.52,71.67 207.06,71.67 206.19,72.54 205.06,72.54 204.48,71.96 203.2,71.96 202.65,72.51 200.01,72.51 199.76,72.27 199.76,69.79 199.2,69.23 199.2,67.33 198.9,67.03 198.54,67.03 197.49,65.98 197.49,65.62 196.69,64.82 196.69,64.31 195.61,63.23 195.02,63.23 192.98,61.18 191.55,61.18 190.6,62.12 187.86,62.12 186.81,61.07 184.59,61.07 184.37,61.29 180.82,61.29 180.58,61.53 174.82,61.53 174.61,61.33 171.86,61.33 171.69,61.5 168.43,61.5 166.4,59.47 166.19,59.47 165.86,59.14 164.55,59.14 164.21,59.48 160.82,59.48 159.89,60.4 157.34,60.4 157.05,60.69 150.34,60.69 149.31,59.66 148.85,59.66 147.91,58.72 142.03,58.72 141.71,59.04 134.39,59.04 134.07,58.72 124.08,58.72 122.72,57.36 121.61,57.36 121.52,57.44 121.52,57.78 v1(121.81,58.07)
  BOTTOM w0.102: v1(210.98,75.84) 210.95,75.82 210.95,75.67 U49.Y9
  BOTTOM w0.14: R988.1 112.88,64.1 112.96,64.1 113.7,64.83 119.69,64.83 122.45,62.07 122.45,60.2 121.53,59.28 121.53,58.35 v1(121.81,58.07)
CLK_PCIE_SSDP_R: length 2.9
  BOTTOM w0.14: R988.2 111.91,64.09 111.54,64.09 111.01,63.56 110.6,63.56 110.48,63.68 CN13.55
CLK_PCIE_WLANN: length 103.6
  IN4 w0.086: v1(214.69,72.91) 214.97,72.63 216.76,72.63 216.97,72.84 218.57,72.84 219.92,71.49 221.37,71.49 221.56,71.67 222.93,71.67 223.21,71.39 227.13,71.39 229.24,69.28 229.24,60.59 229.73,60.1 230.28,60.1 231.26,59.12 231.76,59.12 232.39,58.49 232.39,58.31 234.29,56.41 234.29,56.05 235.47,54.87 235.75,54.87 236.87,53.74 236.87,52.88 237.53,52.23 241.46,52.23 243.31,50.38 249.57,50.38 250,50.81 254.19,50.81 255.02,51.63 261.41,51.63 263.39,53.62 267.99,53.62 268.43,53.18 269.53,53.18 271.29,54.95 273.94,54.95 276.51,57.51 276.76,57.51 278.14,58.89 278.14,59.14 278.78,59.78 278.78,61.75 279.54,62.52 279.54,67.79 279.9,68.15 279.9,68.63 279.81,68.71 278.77,68.71 278.58,68.9 278.58,69.46 278.77,69.64 279.81,69.64 280.03,69.85 280.03,70.55 280.21,70.74 280.46,70.74 280.55,70.82 280.55,71.76 v1(280.27,72.04)
  BOTTOM w0.102: U49.AG13 214.65,72.91 v1(214.69,72.91)
  BOTTOM w0.14: v1(280.27,72.04) 280.51,72.28 280.51,72.61 280.8,72.9 282.13,72.9 282.22,72.99 CN12.49
CLK_PCIE_WLANP: length 103.6
  IN4 w0.086: v1(214.67,72.13) 214.67,72.36 214.77,72.47 216.83,72.47 217.04,72.67 218.5,72.67 219.85,71.32 221.44,71.32 221.63,71.51 222.86,71.51 223.14,71.22 227.06,71.22 229.07,69.21 229.07,60.52 229.67,59.93 230.21,59.93 231.19,58.95 231.69,58.95 232.22,58.42 232.22,58.24 234.13,56.34 234.13,55.98 235.41,54.7 235.68,54.7 236.71,53.68 236.71,52.81 237.46,52.06 241.4,52.06 243.25,50.21 249.64,50.21 250.07,50.64 254.26,50.64 255.09,51.47 261.47,51.47 263.46,53.45 267.92,53.45 268.36,53.02 269.6,53.02 271.36,54.78 274.01,54.78 276.58,57.35 276.83,57.35 278.3,58.82 278.3,59.07 278.94,59.71 278.94,61.69 279.7,62.45 279.7,67.72 280.07,68.08 280.07,68.7 279.88,68.88 278.83,68.88 278.75,68.97 278.75,69.39 278.83,69.47 279.88,69.47 280.19,69.79 280.19,70.49 280.28,70.57 280.53,70.57 280.71,70.76 280.71,71.76 v1(281.01,72.06)
  BOTTOM w0.102: U49.AG15 214.27,72.53 v1(214.67,72.13)
  BOTTOM w0.14: CN12.47 282.21,72.49 282.07,72.64 280.91,72.64 280.77,72.5 280.77,72.3 v1(281.01,72.06)
CLK_PCIE_WWANN: length 109.6
  IN1 w0.086: v1(208.69,79.66) 208.69,79.87 208.78,79.96 209,79.96 209.32,80.28 210.42,80.28 210.69,80.55 212.36,80.55 213.25,81.45 213.77,81.45 213.91,81.59 215.82,81.59 216.07,81.84 217.9,81.84 218.05,81.69 220.95,81.69 221.24,81.4 224.02,81.4 224.2,81.22 224.7,81.22 225.99,79.93 230.2,79.93 231.54,78.6 231.54,77.39 232.85,76.07 235.1,76.07 236.08,75.09 236.43,75.09 237.63,73.89 241.04,73.89 241.34,74.19 246.1,74.19 247.5,75.59 247.8,75.59 252.54,80.33 252.54,83.1 253.57,84.13 263.72,84.13 264.01,83.84 275.7,83.84 275.85,83.98 281.45,83.98 283.37,85.9 286.37,85.9 287.13,85.15 288.47,85.15 288.69,85.37 292.12,85.37 292.81,86.06 295.06,86.06 295.3,86.3 295.3,86.53 295.4,86.63 v1(295.58,86.63)
  BOTTOM w0.102: U49.V4 210.02,78.34 209.98,78.38 209.98,78.42 209.78,78.62 209.78,79.04 210.06,79.32 210.06,79.95 209.81,80.2 209.1,80.2 208.69,79.79 v1(208.69,79.66)
  BOTTOM w0.14: R890.2 297.81,83.69 295.79,83.69 295.09,84.39 295.09,85.28 295.33,85.52 295.33,86.37 v1(295.58,86.63)
CLK_PCIE_WWANP: length 109.5
  IN1 w0.086: v1(294.82,86.63) 295.02,86.63 295.14,86.51 295.14,86.37 294.99,86.23 292.74,86.23 292.05,85.54 288.62,85.54 288.4,85.31 287.2,85.31 286.44,86.07 283.3,86.07 281.38,84.15 275.78,84.15 275.63,84 264.08,84 263.79,84.29 253.5,84.29 252.37,83.16 252.37,80.4 247.73,75.75 247.43,75.75 246.03,74.36 241.28,74.36 240.97,74.05 237.7,74.05 236.49,75.26 236.15,75.26 235.17,76.24 232.92,76.24 231.7,77.46 231.7,78.67 230.27,80.1 226.06,80.1 224.77,81.38 224.27,81.38 224.09,81.56 221.31,81.56 221.02,81.86 218.11,81.86 217.97,82 216,82 215.75,81.75 213.84,81.75 213.7,81.61 213.18,81.61 212.29,80.71 210.62,80.71 210.35,80.44 209.26,80.44 208.93,80.12 208.69,80.12 v1(208.51,80.3)
  BOTTOM w0.102: U49.W3 210.09,78.6 209.98,78.7 209.98,78.96 210.26,79.24 210.26,80.03 209.89,80.4 209.02,80.4 208.81,80.2 208.61,80.2 v1(208.51,80.3)
  BOTTOM w0.14: R900.2 297.9,83.43 295.67,83.43 294.82,84.28 294.82,85.39 295.06,85.63 295.06,86.39 v1(294.82,86.63)
CLK_VGA_N: length 103.4
  TOP w0.102: v2(236.1,131.87) 236.31,132.08 236.5,132.08 236.64,131.94 236.64,130.75 238.63,128.76 238.63,127.2 238.6,127.17
  TOP w0.14: 238.6,127.17 238.6,125.5 238.01,124.91 238.01,124.49 238.47,124.03 238.47,123.83 238.21,123.57 238.01,123.57 237.4,124.18 236.86,124.18 236.53,123.85 236.53,123.32 237.14,122.7 237.14,122.48 236.89,122.23 236.69,122.23 236.22,122.71 235.27,122.71 234.39,121.83 233.92,121.83 230.44,118.35 230.44,116.82 225.75,112.12 211.36,112.12 210.72,111.49 210.72,109.32 211.39,108.65 211.39,103.76 210.84,103.2 210.84,101.14 205.74,96.04 200.53,96.04 200.04,95.56 200.04,95.35 199.9,95.21 198.85,95.21 198.55,94.92 198.55,94.42 198.85,94.12 199.9,94.12 200.04,93.98 200.04,93.7 199.9,93.56 198.85,93.56 198.55,93.27 198.55,92.77 198.85,92.47 199.9,92.47 200.04,92.33 200.04,92.05 199.9,91.91 199.7,91.91 199.41,91.61 199.41,91.11 199.7,90.82 199.9,90.82 200.04,90.68 200.04,88.9 201.17,87.77 201.76,87.77 204.66,84.87 204.66,84.1 205.37,83.39 205.37,79.28 206.49,78.17 208.24,78.17 209.17,77.24 209.17,75.65 209.47,75.35 209.94,75.35 v1(210.07,75.22)
  BOTTOM w0.102: U49.V11 209.64,74.8 v1(210.07,75.22) ; v2(236.1,131.87) UG6.BK30
CLK_VGA_P: length 103.4
  TOP w0.102: 238.87,127.14 238.83,127.17 238.83,128.84 236.85,130.83 236.85,132.02 236.59,132.28 236.37,132.28 v2(236.1,132.56)
  TOP w0.14: v1(210,75.87) 209.75,75.62 209.58,75.62 209.43,75.76 209.43,77.35 208.35,78.43 206.6,78.43 205.64,79.39 205.64,83.5 204.93,84.21 204.93,84.98 201.87,88.04 201.29,88.04 200.31,89.02 200.31,90.79 200.01,91.09 199.81,91.09 199.67,91.22 199.67,91.5 199.81,91.64 200.01,91.64 200.31,91.94 200.31,92.44 200.01,92.74 198.96,92.74 198.82,92.88 198.82,93.16 198.96,93.29 200.01,93.29 200.31,93.59 200.31,94.09 200.01,94.39 198.96,94.39 198.82,94.53 198.82,94.81 198.96,94.95 200.01,94.95 200.31,95.24 200.31,95.45 200.64,95.78 205.85,95.78 211.1,101.03 211.1,103.09 211.66,103.65 211.66,108.76 210.99,109.43 210.99,111.38 211.47,111.86 225.86,111.86 230.71,116.71 230.71,118.24 234.03,121.57 234.5,121.57 235.38,122.44 236.11,122.44 236.58,121.97 237,121.97 237.41,122.37 237.41,122.81 236.8,123.43 236.8,123.74 236.97,123.91 237.29,123.91 237.9,123.3 238.32,123.3 238.74,123.72 238.74,124.14 238.27,124.6 238.27,124.8 238.87,125.39 238.87,127.14
  BOTTOM w0.102: UG6.BJ30 236.43,132.22 v2(236.1,132.56) ; U49.U9 209.55,75.41 v1(210,75.87)
CLR_CMOS: length 82.3
  TOP w0.14: v1(231.81,51.35) 231.81,52.3 230.8,53.31 v1(230.8,53.46) ; U23.19 168.6,64.1 168.82,63.89 168.82,63.2 v1(169.01,63)
  IN2 w0.089: v1(169.01,63) 169.46,62.55 170.72,62.55 170.92,62.35 172.04,62.35 172.33,62.06 173.21,62.06 174.12,62.97 174.45,62.97 175.16,62.26 180.31,62.26 181.42,63.36 181.75,63.36 181.99,63.13 181.99,62.73 183.48,61.24 183.48,59.73 184.95,58.26 185.81,58.26 187.9,56.16 189.91,56.16 191.84,54.24 191.84,53.93 196.93,48.84 201.02,48.84 201.56,49.38 208.09,49.38 208.29,49.18 214.58,49.18 216.96,51.57 227.08,51.57 228,50.65 231.13,50.65 231.81,51.33 v1(231.81,51.35)
  BOTTOM w0.14: v1(231.81,51.35) 231.81,51.03 232.34,50.5 Q113.2 ; R1064.2 232.74,53.06 Q112.2 231.63,52.79 230.97,53.46 v1(230.8,53.46)
CNV_BRI_DT: length 80.2
  IN4 w0.086: v1(267.66,61.16) 267.38,61.16 267.08,60.86 266.66,60.86 266.3,61.22 260.96,61.22 258.74,58.99 256.86,58.99 256.52,59.33 246.05,59.33 243.39,61.99 240.75,61.99 237.65,65.1 237.65,68.03 237.06,68.62 237.06,74.95 234.72,77.29 234.12,77.29 232.43,78.98 232.43,79.08 230.58,80.92 228.67,80.92 227.74,81.86 v1(227.74,83.06)
  BOTTOM w0.14: v1(267.66,61.16) 267.95,61.45 267.95,61.71 268.5,62.26 268.5,63.86 267.77,64.59 267.77,65.2 266.98,65.99 266.98,67.64 268.86,69.52 269.66,69.52 269.74,69.6 R959.1 270.16,69.51 271.05,69.51 271.27,69.73 R960.2 271.7,69.49 274.37,69.49 274.62,69.74 CN12.36 ; v1(227.74,83.06) 227.52,83.28 227.52,83.72 226.44,84.8 224,84.8 R878.1
CNV_BRI_DT_C: length 8.1
  BOTTOM w0.102: U49.AV3 220.36,78.94 220.36,79.7 220.87,80.2 221.36,80.2 222.76,81.61 222.76,83.11 222.8,83.15
  BOTTOM w0.14: R878.2 222.8,84.56 222.8,83.15
CNV_BRI_RSP: length 81.4
  IN4 w0.086: v1(225.67,83.21) 225.67,83.09 226.09,82.66 226.09,79.67 228.3,77.46 228.83,77.46 229.12,77.17 231.66,77.17 233.05,75.77 233.47,75.77 235.66,73.58 235.66,68.04 236.24,67.45 236.24,64.52 240.17,60.59 242.22,60.59 245.94,56.87 248.61,56.87 248.85,57.11 253.64,57.11 254.26,57.73 256.14,57.73 256.27,57.59 259.47,57.59 260.74,58.86 261.82,58.86 261.92,58.96 264.63,58.96 265.12,59.46 268.05,59.46 269.14,60.54 269.74,60.54 270.08,60.89 270.13,60.89 v1(270.24,61)
  BOTTOM w0.102: U49.AV4 220.44,78.06 220.59,77.91 220.82,77.91 221.15,78.23 221.15,79.01 220.97,79.18 220.97,79.45 221.12,79.59 221.61,79.59 223.5,81.49 223.5,82.61 223.63,82.74 223.98,82.74 R914.1
  BOTTOM w0.14: v1(270.24,61) 270.24,61.37 270.65,61.77 270.65,66.22 271.78,67.35 271.93,67.35 R978.2 ; R914.1 224.31,82.65 224.46,82.8 225,82.8 225.41,83.21 v1(225.67,83.21)
CNV_BRI_RSP_R: length 6.2
  BOTTOM w0.14: CN12.22 276.39,66.24 276.56,66.41 276.56,67.2 276.33,67.43 274.3,67.43 v1(273.78,66.9) 272.83,66.9 R978.1
CNV_MFUART2_RXD: length 150.3
  TOP w0.14: v1(233.44,76.74) 233.44,77.26 232.93,77.77 225.37,77.77 223.7,76.1 223.7,76.04 223.33,75.67 222.73,75.67 222.57,75.51 R352.1
  IN2 w0.089: v1(311.52,81.27) 312.55,80.24 315.65,80.24 316.19,80.78 318.05,80.78 318.51,81.24 318.51,86.74 316.26,88.98 313.98,88.98 313.63,89.32 311.23,89.32 308.46,92.1 308.46,92.64 308.11,92.99 305.63,92.99 305.06,93.56 298.48,93.56 298.3,93.74 295.88,93.74 293.47,91.33 293.47,89.2 292.02,87.75 288.35,87.75 287.69,87.08 283.97,87.08 281.09,84.2 276.58,84.2 276.22,83.84 272.75,80.36 272.75,78.47 273.22,78 273.52,78 273.72,77.8 273.72,77.32 272.73,76.33 272.73,72.87 v1(272.71,72.85)
  IN3 w0.089: v1(233.44,76.74) 234.01,77.31 236.48,77.31 237.32,76.46 241.76,76.46 244.42,73.8 244.42,70.89 242.95,69.42 242.95,67.47 245.04,65.38 250.83,65.38 251.76,66.31 252.14,66.31 254.75,68.92 262.47,68.92 264.07,70.52 269.93,70.52 271.15,71.73 271.53,71.73 272.65,72.85 v1(272.71,72.85)
  BOTTOM w0.14: R928.1 310.76,78.03 311.44,78.71 311.44,79.59 311.64,79.79 311.64,81.15 v1(311.52,81.27) ; v1(272.71,72.85) 272.82,72.74 CN12.48
CNV_MFUART2_RXD_C: length 4.5
  TOP w0.14: R352.2 222.12,75.51 221.98,75.65 221.66,75.65 221.51,75.5 v1(220.92,75.5) 220.4,75.5 219.81,76.09 219.08,76.09 v1(218.98,75.98)
  BOTTOM w0.102: U49.AU9 219.32,75.64 v1(218.98,75.98)
CNV_MFUART2_TXD: length 153.1
  IN2 w0.089: v1(311.07,80.56) 311.83,79.81 315.83,79.81 316.37,80.35 318.23,80.35 319,81.11 319,88.93 317.09,90.84 314.56,90.84 313.52,89.81 311.51,89.81 309.12,92.2 309.12,93.26 307.14,95.25 304.65,95.25 303.4,93.99 298.78,93.99 298.58,94.2 295.72,94.2 293.04,91.51 293.04,89.38 291.84,88.18 287.47,88.18 286.88,87.59 283,87.59 280.29,84.88 275.45,84.88 273.1,82.53 270.11,82.53 269.67,82.09 269.67,79.8 270.83,78.64 270.83,75.92 270.57,75.66 268.37,75.66 268.23,75.52 264.49,75.52 263.87,74.9 261.66,74.9 260.78,74.02 260.53,74.02 v1(260.26,74.28) 259.99,74.02 257.25,74.02 256.33,73.1 254.48,73.1 254.04,73.53 252.52,73.53 247.19,78.86 235.29,78.86 232.08,82.07 229.62,82.07 229.15,82.53 229.15,82.7 228.52,83.33 v1(228.33,83.33)
  BOTTOM w0.102: v1(228.33,83.33) 228.25,83.25 228.25,82.4 R916.1
  BOTTOM w0.14: CN12.46 274.31,72.24 274.16,72.39 272.28,72.39 271.71,71.82 270.72,71.82 270.47,71.56 269.93,71.56 269.71,71.78 265.12,71.78 264.42,71.08 263.54,71.08 261.71,72.91 261.71,73.37 260.79,74.28 v1(260.26,74.28) ; R925.1 310.76,78.79 311.07,79.1 311.07,80.53 311.07,80.53 v1(311.07,80.56)
CNV_MFUART2_TXD_C: length 10
  TOP w0.14: v1(226.06,81.24) 225.85,81.46 v1(225.38,81.46)
  IN4 w0.086: v1(225.38,81.46) 225.38,79.49 223.6,77.71 221.89,77.71 v1(221.85,77.75)
  BOTTOM w0.102: v1(221.85,77.75) 221.8,77.8 U49.BA5 ; v1(225.38,81.46) 226.12,82.2 227.18,82.2 227.28,82.1 R916.2
CNV_PA_BLANKING: length 149.8
  TOP w0.14: R371.1 222.57,74.73 223.23,75.39 223.44,75.39 223.98,75.93 223.98,75.98 225.49,77.49 232.56,77.49 v1(232.86,77.19)
  IN2 w0.089: v1(311.48,81.91) 312.37,81.02 312.37,80.68 312.63,80.43 315.57,80.43 316.11,80.97 317.97,80.97 318.29,81.28 318.29,86.69 316.19,88.79 313.9,88.79 313.56,89.13 311.15,89.13 309.62,90.67 306.4,90.67 305.53,91.54 305.53,92.82 304.98,93.37 298.26,93.37 298.1,93.54 296.01,93.54 293.66,91.18 293.66,89.12 292.1,87.56 288.49,87.56 287.82,86.89 284.05,86.89 281.14,83.98 276.63,83.98 274.73,82.07 274.73,78.06 272.95,76.27 272.95,73.37 273.11,73.21 273.11,72.5 v1(272.53,71.92)
  IN3 w0.089: v1(272.53,71.92) 272.03,71.92 271.65,71.54 271.22,71.54 270.01,70.33 264.14,70.33 262.55,68.73 254.83,68.73 252.17,66.07 251.79,66.07 250.91,65.19 244.96,65.19 242.76,67.39 242.76,69.5 244.23,70.97 244.23,73.72 241.69,76.27 237.24,76.27 236.4,77.12 235.27,77.12 234.5,76.34 233.28,76.34 232.79,76.82 232.79,77.13 v1(232.86,77.19)
  BOTTOM w0.14: v1(272.53,71.92) 272.72,72.11 273.72,72.11 274.09,71.74 CN12.44 ; v1(311.48,81.91) 311.48,81.88 311.06,81.46 311.06,81.2 310.6,80.74 310.6,79.92 310.76,79.76 R920.1
CNV_PA_BLANKING_C: length 3.1
  TOP w0.14: R371.2 221.77,74.55 221.49,74.83 v1(221.49,74.84)
  BOTTOM w0.102: U49.AU8 220.06,75.71 220.53,75.71 221.4,74.84 v1(221.49,74.84)
CNV_RF_RESET#: length 63.9
  TOP w0.14: R491.1 273.31,63.91 273.07,63.66 271.64,63.66 271.32,63.99 U26.1 269.05,63.99 268.74,63.67 R500.1 269.23,63.18 269.39,63.34 U26.2 270.64,63.34 271.06,62.91 271.06,62.32 270.27,61.52 268.9,61.52 268.7,61.71 267.37,61.71 v1(266.93,61.28)
  IN2 w0.089: v1(266.93,61.28) 266.93,61.17 266.02,60.26 263.56,60.26 261.82,58.52 253.38,58.52 253.29,58.43 245.96,58.43 245.63,58.1 244.32,58.1 243.4,57.17 241.63,57.17 240.17,58.63 239.4,58.63 237.5,60.53 233.97,60.53 232.89,61.61 231.36,61.61 231.34,61.59 229.88,61.59 228.96,60.67 224.2,60.67 v1(222.03,62.84)
  BOTTOM w0.102: U49.BA33 221.7,63.14 222,62.84 v1(222.03,62.84)
CNV_RF_RESET_L: length 4.1
  TOP w0.14: U26.4 272.98,62.69 273.12,62.83 273.12,63.06 R491.2 273.8,63.46 274.09,63.17 v1(274.09,62.96)
  BOTTOM w0.14: v1(274.09,62.96) 274.36,63.24 CN12.10
CNV_RGI_DT: length 80.7
  IN4 w0.086: v1(227.05,83.05) 227.23,82.87 227.23,81.7 228.48,80.46 230.39,80.46 231.95,78.89 231.95,78.8 233.93,76.82 234.53,76.82 236.59,74.75 236.59,68.43 237.18,67.84 237.18,64.9 240.56,61.52 243.2,61.52 245.85,58.86 256.32,58.86 256.66,58.52 258.93,58.52 261.16,60.75 265.39,60.75 265.75,60.39 267.66,60.39 267.92,60.65 v1(268.4,61.13)
  BOTTOM w0.14: v1(268.4,61.13) 268.51,61.24 268.51,61.53 269.02,62.05 269.02,64.07 268.29,64.81 268.29,65.41 267.5,66.21 267.5,67.42 269.08,69 269.57,69 269.74,68.83 R967.1 270.15,68.99 271.05,68.99 271.27,68.77 R968.2 271.66,68.97 274.15,68.97 274.37,68.74 CN12.32 ; v1(227.05,83.05) 227.28,83.27 227.28,83.62 226.34,84.56 224.27,84.56 R889.1
CNV_RGI_DT_C: length 6.8
  BOTTOM w0.102: 223.02,82.92 223.02,81.57 221.44,80 220.95,80 220.57,79.61 220.57,78.8 U49.AW3
  BOTTOM w0.14: R889.2 223.08,83.82 223.08,82.98 223.02,82.92
CNV_RGI_RSP: length 81.2
  IN4 w0.086: v1(226.33,83.1) 226.56,82.88 226.56,79.86 228.49,77.93 229.03,77.93 229.32,77.64 231.85,77.64 233.25,76.24 233.66,76.24 236.12,73.77 236.12,68.24 236.71,67.65 236.71,64.71 240.37,61.05 243,61.05 246.72,57.34 248.42,57.34 248.66,57.58 253.45,57.58 254.07,58.2 256.33,58.2 256.47,58.06 259.28,58.06 260.55,59.33 261.63,59.33 261.73,59.43 264.35,59.43 264.84,59.93 267.86,59.93 268.94,61.01 v1(269.55,61.01)
  BOTTOM w0.102: U49.AW4 220.68,78.27 220.94,78.53 220.94,78.93 220.77,79.1 220.77,79.53 221.04,79.8 221.53,79.8 223.3,81.57 223.3,82.7 223.55,82.94 223.82,82.94 R897.1
  BOTTOM w0.14: v1(269.55,61.01) 269.55,61.4 270.09,61.94 270.09,66.4 271.66,67.97 271.88,67.97 R971.2 ; R897.1 224.32,83.26 224.53,83.05 224.9,83.05 225.14,83.29 225.14,83.49 225.3,83.65 226.09,83.65 226.33,83.41 v1(226.33,83.1)
CNV_RGI_RSP_R: length 6.1
  BOTTOM w0.14: CN12.34 276.32,69.24 276.55,69.01 276.55,68.28 276.22,67.95 273.91,67.95 v1(273.56,68.29) R971.1
CNV_WR_CLK_DN: length 97.2
  IN4 w0.086: v1(278.46,66.7) 278.11,67.05 277.9,67.05 277.47,67.48 277.47,68.48 277.33,68.63 277.15,68.63 277,68.48 277,67.67 276.82,67.49 276.01,67.49 275.56,67.04 275.56,60.42 274.31,59.17 274.31,58.74 274,58.43 273.48,58.43 273.19,58.14 273.19,57.62 272.67,57.11 269.78,57.11 268.37,55.7 262.34,55.7 260.37,53.73 252.01,53.73 251.42,53.14 249.61,53.14 249.02,53.73 243.33,53.73 240.71,56.35 240.27,56.35 239.81,55.88 239.13,55.88 238.9,56.11 238.9,56.73 238.71,56.92 238.59,56.92 238.08,56.41 237.71,56.41 237.29,56.82 237.29,57.12 237.8,57.62 237.8,57.75 237.2,58.34 237.08,58.34 236.54,57.8 236.28,57.8 235.96,58.12 235.96,58.38 236.74,59.16 236.74,59.28 236.45,59.58 236.32,59.58 235.6,58.85 235.23,58.85 234.74,59.33 234.74,59.67 235.13,60.05 235.13,60.18 234.9,60.4 234.78,60.4 234.54,60.16 234.27,60.16 233.97,60.46 233.97,60.73 234.78,61.53 234.78,61.69 232.54,63.93 232.54,64.83 232.73,65.03 232.73,65.77 232.38,66.12 232.38,67.25 232.73,67.6 232.73,68.7 232.46,68.98 232.46,69.71 232.73,69.99 232.73,70.46 230.72,72.47 229.36,72.47 229.07,72.75 229.07,73.05 228.92,73.2 228.6,73.2 228.37,72.98 226.21,72.98 226,73.19 226,73.5 v1(225.82,73.68)
  BOTTOM w0.102: U49.BC12 222.69,74.17 222.83,74.03 223.16,74.03 223.32,74.19 223.89,74.19 224.09,74.38 225.11,74.38 225.36,74.63 225.79,74.63 226.04,74.39 226.04,73.89 v1(225.82,73.68) ; v1(278.46,66.7) 278.79,67.03 280.25,67.03 281.14,66.14 281.96,66.14 282.11,65.99 CN12.21
CNV_WR_CLK_DP: length 97.2
  IN4 w0.086: v1(278.46,67.55) 278.12,67.21 277.97,67.21 277.64,67.55 277.64,68.55 277.39,68.79 277.08,68.79 276.84,68.55 276.84,67.74 276.75,67.65 275.94,67.65 275.39,67.11 275.39,60.49 274.15,59.24 274.15,58.81 273.93,58.6 273.42,58.6 273.03,58.21 273.03,57.69 272.61,57.27 269.71,57.27 268.3,55.87 262.27,55.87 260.3,53.89 251.94,53.89 251.35,53.31 249.68,53.31 249.09,53.89 243.4,53.89 240.78,56.51 240.2,56.51 239.74,56.05 239.2,56.05 239.07,56.18 239.07,56.8 238.78,57.08 238.52,57.08 238.01,56.57 237.77,56.57 237.45,56.89 237.45,57.05 237.96,57.55 237.96,57.81 237.27,58.51 237.01,58.51 236.47,57.97 236.35,57.97 236.13,58.19 236.13,58.31 236.91,59.09 236.91,59.35 236.52,59.74 236.26,59.74 235.53,59.02 235.3,59.02 234.91,59.4 234.91,59.6 235.29,59.98 235.29,60.24 234.97,60.56 234.71,60.56 234.48,60.32 234.34,60.32 234.14,60.52 234.14,60.66 234.94,61.47 234.94,61.76 232.71,64 232.71,64.77 232.9,64.96 232.9,65.84 232.55,66.19 232.55,67.18 232.9,67.53 232.9,68.77 232.62,69.05 232.62,69.65 232.9,69.92 232.9,70.53 230.79,72.63 229.42,72.63 229.24,72.82 229.24,73.11 228.98,73.37 228.53,73.37 228.3,73.14 226.28,73.14 226.16,73.26 226.16,73.48 226.37,73.68 v1(226.63,73.68)
  BOTTOM w0.102: v1(278.46,67.55) 278.77,67.23 280.34,67.23 281.23,66.34 281.96,66.34 282.11,66.49 CN12.23 ; U49.BD12 223.15,74.39 223.8,74.39 224,74.59 225.03,74.59 225.28,74.84 225.87,74.84 226.24,74.47 226.24,73.81 226.37,73.68 v1(226.63,73.68)
CNV_WR_LANE0_DN: length 97.4
  IN4 w0.086: v1(224.69,72.38) 224.86,72.38 224.95,72.3 224.95,72.01 225.16,71.79 226.58,71.79 226.76,71.98 226.76,72.33 226.85,72.42 227.27,72.42 227.36,72.33 227.36,71.98 227.54,71.79 228.58,71.79 228.66,71.71 228.66,71.61 228.85,71.43 229.41,71.43 229.59,71.61 229.59,71.71 229.67,71.79 229.68,71.79 230.5,71.79 231.82,70.47 231.82,69.42 231.74,69.33 231.29,69.33 231.05,69.09 231.05,68.71 231.31,68.45 231.59,68.45 231.68,68.37 231.68,67.95 231.59,67.86 231.41,67.86 231.23,67.68 231.23,67.25 231.41,67.07 231.61,67.07 231.69,66.98 231.69,65.3 231.82,65.17 231.82,62.9 232.01,62.72 232.59,62.72 232.68,62.63 232.68,62.34 232.59,62.25 232.01,62.25 231.82,62.07 231.82,61.36 232.3,60.88 232.56,60.88 233.57,61.89 233.69,61.89 233.9,61.68 233.9,61.55 233.07,60.73 233.07,60.44 233.77,59.74 233.77,59.41 237.17,56.01 237.21,56.01 238.3,54.92 241.24,54.92 243.46,52.7 244.91,52.7 245,52.62 245,52.16 245.21,51.95 245.74,51.95 245.92,52.13 245.92,52.72 246.11,52.9 246.83,52.9 246.96,52.78 246.96,52.16 247.18,51.94 247.7,51.94 247.88,52.12 247.88,52.79 248.03,52.94 248.51,52.94 248.96,52.49 252.24,52.49 252.84,53.1 260.63,53.1 262.6,55.07 268.72,55.07 270.13,56.47 272.94,56.47 274.94,58.48 274.94,58.91 276.19,60.16 276.19,66.57 276.41,66.79 277.09,66.79 277.3,66.58 277.3,65.92 277.67,65.55 278.54,65.55 v1(278.83,65.26)
  BOTTOM w0.102: CN12.15 282.11,64.49 281.96,64.64 281.03,64.64 280.11,65.56 279.13,65.56 v1(278.83,65.26) ; U49.BC13 222.31,73.45 222.69,73.45 222.81,73.33 223.71,73.33 224.09,72.96 224.81,72.96 224.93,72.85 224.93,72.51 224.8,72.38 v1(224.69,72.38)
CNV_WR_LANE0_DP: length 97.5
  IN4 w0.086: v1(225.5,72.38) 225.41,72.47 225.2,72.47 225.11,72.38 225.11,72.07 225.23,71.96 226.51,71.96 226.6,72.05 226.6,72.4 226.78,72.58 227.34,72.58 227.52,72.4 227.52,72.05 227.61,71.96 228.65,71.96 228.83,71.78 228.83,71.68 228.92,71.59 229.34,71.59 229.42,71.68 229.42,71.78 229.61,71.96 230.57,71.96 231.99,70.54 231.99,69.35 231.81,69.17 231.36,69.17 231.22,69.03 231.22,68.78 231.38,68.62 231.66,68.62 231.84,68.44 231.84,67.88 231.66,67.7 231.48,67.7 231.4,67.61 231.4,67.32 231.48,67.23 231.68,67.23 231.85,67.05 231.85,65.37 231.99,65.23 231.99,62.97 232.07,62.88 232.66,62.88 232.84,62.7 232.84,62.27 232.66,62.08 232.07,62.08 231.99,62 231.99,61.43 232.37,61.05 232.49,61.05 233.5,62.05 233.76,62.05 234.06,61.74 234.06,61.49 233.24,60.66 233.24,60.51 233.94,59.81 233.94,59.48 237.24,56.18 237.27,56.18 238.37,55.08 241.31,55.08 243.53,52.87 244.98,52.87 245.16,52.69 245.16,52.23 245.28,52.12 245.67,52.12 245.76,52.2 245.76,52.79 246.04,53.07 246.9,53.07 247.12,52.84 247.12,52.23 247.25,52.1 247.63,52.1 247.72,52.19 247.72,52.86 247.96,53.1 248.58,53.1 249.03,52.66 252.17,52.66 252.77,53.26 260.56,53.26 262.53,55.23 268.66,55.23 270.06,56.64 272.87,56.64 274.78,58.55 274.78,58.98 276.02,60.22 276.02,66.64 276.34,66.96 277.16,66.96 277.46,66.65 277.46,65.99 277.74,65.71 278.47,65.71 v1(278.83,66.07)
  BOTTOM w0.102: CN12.17 282.11,64.99 281.96,64.84 281.12,64.84 280.2,65.76 279.14,65.76 v1(278.83,66.07) ; U49.BD13 222.89,73.54 223.8,73.54 224.17,73.17 224.9,73.17 225.13,72.93 225.13,72.55 225.29,72.38 v1(225.5,72.38)
