# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TBT_SBU2_P1_CON_S: length 7.7
  TOP w0.079: 36.4,94.45 36.42,94.44 36.42,94.37 37.49,93.29 37.49,92.7 U9.L10
  TOP w0.14: v1(34.13,95.54) 34.47,95.21 35.64,95.21 36.23,94.62 36.4,94.45
  BOTTOM w0.14: R1219.2 32.64,96.23 33.15,95.72 33.96,95.72 v1(34.13,95.54)
TBT_SBU2_P2_CON: length 29
  TOP w0.14: v1(15.66,80.42) 15.46,80.23 15.22,80.23 15.06,80.39 R285.1 14.63,80.39 14.5,80.26 14.23,80.26 13.93,79.96 13.93,79.77 13.81,79.65 13.72,79.65 13.67,79.7 D22.1 13.21,79.7 12.91,80.01 12.06,80.01 11.6,79.54 10.64,79.54 9.82,78.73 9.63,78.73 9.32,79.04 9.32,79.24 v1(9.93,79.85)
  BOTTOM w0.14: R1221.1 23.47,79.49 23.59,79.38 23.59,78.36 24.02,77.93 24.66,77.93 25.56,77.02 25.56,74.63 25.22,74.29 24.76,74.29 21.3,77.76 18.72,77.76 18.17,78.31 18.17,78.94 17.01,80.1 15.93,80.1 15.66,80.38 v1(15.66,80.42) ; CN9.A8 v1(9.93,79.85)
TBT_SBU2_P2_CON_S: length 13.8
  TOP w0.079: 30.64,77.9 30.65,77.9 30.72,77.83 30.99,77.83 32.9,75.92 32.9,75.48 32.68,75.26 U16.L10
  TOP w0.14: 30.64,77.9 30.62,77.92 29.87,77.92 v1(29.59,78.19)
  IN1 w0.086: v1(23.37,80.48) 23.61,80.72 23.61,80.98 23.88,81.24 24.64,81.24 24.9,80.99 25.33,80.99 27.19,79.12 27.19,78.82 27.83,78.18 29.58,78.18 v1(29.59,78.19)
  BOTTOM w0.14: R1221.2 23.24,80.35 v1(23.37,80.48)
TBTA_HPD: length 0.6
  TOP w0.14: R184.1 R185.1
TBTA_HPD_C: length 2.5
  TOP w0.14: R184.2 64.75,89.55 62.88,89.55 62.56,89.23 U11.G1
TBTA_RX1_N: length 24
  TOP w0.14: v1(29.2,92.67) 29.47,92.94 arc(29.53,92.98) 29.59,92.99 29.62,92.99 arc(29.68,92.98) 29.74,92.94 C227.2
  BOTTOM w0.14: CN5.A10 9.48,94.85 arc(9.54,94.86) 9.6,94.9 9.61,94.92 arc(9.67,94.95) 9.73,94.97 9.83,94.97 arc(9.99,95) 10.12,95.09 10.17,95.14 arc(10.29,95.31) 10.33,95.52 10.33,95.96 arc(10.51,96.4) 10.95,96.58 11.74,96.58 arc(11.9,96.55) 12.04,96.46 R834.2 arc(12.26,96.55) 12.49,96.6 21.13,96.6 arc(21.57,96.51) 21.93,96.27 25.05,93.15 arc(25.28,93) 25.55,92.95 28.73,92.95 arc(28.9,92.91) 29.05,92.82 v1(29.2,92.67)
TBTA_RX1_P: length 24
  TOP w0.14: v1(29.2,93.52) 29.38,93.33 arc(29.46,93.28) 29.56,93.26 29.59,93.26 arc(29.69,93.28) 29.78,93.33 C219.2
  BOTTOM w0.14: v1(29.2,93.52) 29.03,93.36 arc(28.88,93.25) 28.69,93.21 25.55,93.21 arc(25.38,93.25) 25.24,93.34 22.12,96.46 arc(21.67,96.76) 21.13,96.87 12.51,96.87 arc(12.27,96.91) R829.2 11.96,96.94 arc(11.86,96.87) 11.74,96.85 10.95,96.85 arc(10.32,96.59) 10.06,95.96 10.06,95.52 arc(10.04,95.41) 9.98,95.33 9.93,95.27 arc(9.89,95.24) 9.83,95.23 9.7,95.23 arc(9.64,95.25) 9.59,95.28 9.57,95.3 arc(9.51,95.34) 9.45,95.35 CN5.A11
TBTA_RX2_N: length 26
  TOP w0.14: C270.2 29.83,87.16 arc(29.67,87.06) 29.49,87.02 29.32,87.02 arc(28.92,87.1) 28.59,87.32 27.66,88.25 27.66,88.25 arc(23.1,91.3) 17.72,92.37 17.32,92.37 arc(15.35,91.98) 13.69,90.87 12.36,89.53 12.28,89.45 arc(12.19,89.39) 12.08,89.37 arc(12,89.39) 11.94,89.43 R183.2 11.77,89.52 arc(11.61,89.41) 11.42,89.37 11.22,89.37 arc(11.01,89.41) 10.84,89.53 9.89,90.48 arc(9.46,90.77) 8.95,90.87 8.56,90.87 arc(8.37,90.91) v2(8.2,91.02)
  BOTTOM w0.14: CN5.B10 8.12,91.1 v2(8.2,91.02)
TBTA_RX2_P: length 26
  TOP w0.14: C281.2 29.82,86.63 arc(29.69,86.72) 29.53,86.75 29.32,86.75 arc(28.82,86.85) 28.4,87.14 27.47,88.06 arc(23,91.05) 17.72,92.1 17.32,92.1 arc(15.46,91.73) 13.88,90.68 12.46,89.26 arc(12.4,89.21) 12.35,89.17 arc(12.23,89.12) 12.11,89.1 arc(11.98,89.06) 11.87,88.98 R194.2 11.77,88.97 arc(11.63,89.07) 11.45,89.1 11.22,89.1 arc(10.91,89.17) 10.65,89.34 9.7,90.29 arc(9.35,90.52) 8.95,90.6 8.55,90.6 arc(8.36,90.57) v2(8.2,90.46)
  BOTTOM w0.14: v2(8.2,90.46) 8.06,90.6 CN5.B11
TBTA_SSRX1_N: length 4.4
  TOP w0.079: U9.J11 36.68,91.42 arc(36.57,91.35) 36.43,91.32 36.16,91.32 arc(36.09,91.34) 36.02,91.38 36.01,91.39 arc(35.94,91.44) 35.86,91.45 35.48,91.45 35.43,91.4 35.41,91.4
  TOP w0.14: 35.41,91.4 35.35,91.4 arc(35.2,91.43) 35.06,91.52 34.66,91.92 arc(34.54,92.1) 34.5,92.31 arc(34.5,92.32) 34.5,92.33 34.5,92.62 arc(34.49,92.69) 34.45,92.75 34.25,92.95 arc(34.2,92.98) 34.15,92.99 34.03,92.99 arc(33.95,92.98) 33.89,92.93 R170.1
TBTA_SSRX1_N_C: length 3
  TOP w0.14: C227.1 30.64,92.86 arc(30.79,92.96) 30.97,93 31.54,93 arc(31.61,92.98) 31.68,92.94 D11.1 31.83,92.94 arc(31.9,92.99) 31.98,93 32.63,93 arc(32.83,92.96) 33,92.85 R170.2
TBTA_SSRX1_P: length 4.4
  TOP w0.079: U9.J12 36.43,91.54 arc(36.54,91.65) 36.43,91.77 36.21,91.77 arc(36.12,91.75) 36.04,91.7 36.03,91.69 arc(35.96,91.64) 35.87,91.62 35.48,91.62 35.43,91.67 35.41,91.67
  TOP w0.14: R161.1 33.83,93.36 arc(33.94,93.28) 34.07,93.26 34.15,93.26 arc(34.31,93.23) 34.44,93.14 34.64,92.94 arc(34.73,92.79) 34.77,92.62 34.77,92.31 arc(34.79,92.2) 34.85,92.11 35.25,91.71 arc(35.3,91.68) 35.35,91.67 35.41,91.67
TBTA_SSRX1_P_C: length 3
  TOP w0.14: R161.2 32.99,93.38 arc(32.88,93.3) 32.74,93.27 32,93.27 arc(31.91,93.29) 31.84,93.34 D9.1 31.66,93.33 arc(31.59,93.28) 31.49,93.26 30.93,93.26 arc(30.77,93.29) 30.63,93.39 C219.1
TBTA_SSRX2_N: length 4.6
  TOP w0.079: U9.C11 36.68,88.89 arc(36.57,88.97) 36.43,88.99 36.24,88.99 arc(36.16,88.98) 36.09,88.93 36.08,88.92 arc(36.01,88.88) 35.93,88.86 35.48,88.86 35.43,88.91 35.41,88.91
  TOP w0.14: R201.1 33.87,87.1 arc(33.97,87.04) 34.09,87.02 arc(34.18,87.05) 34.27,87.11 34.27,87.11 arc(34.39,87.29) 34.43,87.51 34.43,87.83 arc(34.47,88.04) 34.59,88.22 35.24,88.87 arc(35.28,88.9) 35.34,88.91 35.41,88.91
TBTA_SSRX2_N_C: length 3
  TOP w0.14: C270.1 30.64,87.15 arc(30.78,87.06) 30.94,87.03 31.52,87.03 arc(31.6,87.05) 31.67,87.09 D17.1 31.84,87.09 arc(31.91,87.04) 32,87.02 32.66,87.02 arc(32.85,87.06) 33,87.16 R201.2
TBTA_SSRX2_P: length 4.6
  TOP w0.079: 35.41,88.64 35.43,88.64 35.48,88.69 35.85,88.69 arc(35.94,88.67) 36.01,88.62 36.02,88.61 arc(36.1,88.56) 36.18,88.55 36.43,88.55 arc(36.54,88.66) 36.43,88.78 U9.C12
  TOP w0.14: 35.41,88.64 35.39,88.64 34.78,88.03 arc(34.72,87.94) 34.7,87.84 34.7,87.51 arc(34.64,87.19) 34.46,86.92 arc(34.3,86.81) 34.11,86.76 arc(33.95,86.72) 33.81,86.63 33.63,86.45 R205.1
TBTA_SSRX2_P_C: length 3
  TOP w0.14: C281.1 30.63,86.62 arc(30.78,86.73) 30.96,86.76 31.51,86.76 arc(31.6,86.75) 31.67,86.7 D19.1 31.83,86.69 arc(31.9,86.74) 31.98,86.75 32.7,86.75 arc(32.86,86.72) 33,86.63 R205.2
TBTA_SSTX1_N: length 3.6
  TOP w0.079: U9.G11 36.68,90.5 arc(36.57,90.43) 36.43,90.4 36.18,90.4 arc(36.1,90.42) 36.03,90.46 36.02,90.47 arc(35.96,90.52) 35.88,90.53 35.48,90.53 35.43,90.48 35.41,90.48
  TOP w0.14: 35.41,90.48 35.06,90.48 arc(34.79,90.53) 34.56,90.69 34.34,90.91 arc(34.25,90.97) 34.14,90.99 34.11,90.99 arc(33.99,90.97) 33.9,90.91 R179.1
TBTA_SSTX1_N_C: length 3
  TOP w0.14: C243.1 30.64,90.83 arc(30.76,90.91) 30.9,90.93 31.51,90.93 arc(31.59,90.92) 31.67,90.87 D13.1 31.84,90.87 arc(31.92,90.92) 32.01,90.94 32.7,90.94 arc(32.86,90.91) 33,90.82 R179.2
TBTA_SSTX1_P: length 3.6
  TOP w0.079: 35.41,90.75 35.43,90.75 35.48,90.7 35.84,90.7 arc(35.95,90.72) 36.04,90.78 arc(36.09,90.82) 36.14,90.85 arc(36.18,90.86) 36.22,90.86 36.43,90.86 arc(36.47,90.85) 36.51,90.83 arc(36.54,90.7) 36.43,90.62 U9.G12
  TOP w0.14: R176.1 33.81,91.35 arc(33.91,91.28) 34.02,91.26 34.14,91.26 arc(34.35,91.22) 34.53,91.1 34.75,90.87 arc(34.89,90.78) 35.06,90.75 35.41,90.75
TBTA_SSTX1_P_C: length 3
  TOP w0.14: R176.2 33,91.35 arc(32.84,91.24) 32.66,91.21 31.96,91.21 arc(31.89,91.22) 31.83,91.26 D12.1 31.67,91.26 arc(31.61,91.22) 31.53,91.2 31,91.2 arc(30.8,91.24) 30.63,91.36 C235.1
TBTA_SSTX2_N: length 3.7
  TOP w0.079: U9.E11 36.68,89.81 arc(36.57,89.89) 36.43,89.91 36.25,89.91 arc(36.17,89.9) 36.1,89.85 36.09,89.84 arc(36.02,89.8) 35.94,89.78 35.48,89.78 35.43,89.83 35.41,89.83
  TOP w0.14: R186.1 33.9,89.1 arc(33.95,89.07) 34.01,89.05 34.04,89.05 arc(34.1,89.06) 34.15,89.1 34.72,89.66 arc(34.9,89.79) 35.12,89.83 35.41,89.83
TBTA_SSTX2_N_C: length 3.1
  TOP w0.14: C252.1 30.63,89.32 arc(30.77,89.22) 30.94,89.19 30.97,89.19 arc(30.99,89.19) 31,89.19 31.38,89.11 arc(31.47,89.1) 31.55,89.11 arc(31.61,89.13) 31.67,89.17 D14.1 31.85,89.16 arc(31.93,89.11) 32.03,89.09 32.74,89.09 arc(32.88,89.11) 33,89.19 R186.2
TBTA_SSTX2_P: length 3.7
  TOP w0.079: 35.41,89.57 35.43,89.57 35.48,89.62 35.82,89.62 arc(35.91,89.6) 35.99,89.55 36,89.54 arc(36.08,89.49) 36.17,89.47 36.42,89.47 arc(36.54,89.58) 36.42,89.7 U9.E12
  TOP w0.14: 35.41,89.57 35.12,89.57 arc(35,89.54) 34.9,89.48 34.34,88.91 arc(34.2,88.82) 34.04,88.79 34.03,88.79 arc(33.94,88.77) 33.87,88.72 R195.1
TBTA_SSTX2_P_C: length 3.1
  TOP w0.14: R195.2 33,88.66 arc(32.82,88.78) 32.62,88.82 31.95,88.82 arc(31.88,88.81) 31.82,88.77 D16.1 arc(31.68,88.78) 31.57,88.83 31.48,88.83 arc(31.46,88.83) 31.44,88.83 arc(31.38,88.84) 31.33,88.85 30.97,88.92 30.89,88.92 arc(30.78,88.9) 30.68,88.84 C259.1
TBTA_TX1_N: length 26.5
  TOP w0.14: v2(8.2,94.93) 8.24,94.96 arc(8.36,95.04) 8.5,95.07 8.65,95.07 arc(8.82,95.11) 8.96,95.2 9.69,95.93 arc(10.44,96.43) 11.33,96.61 11.75,96.61 arc(11.88,96.58) 11.99,96.51 R150.2 12.17,96.53 arc(12.26,96.59) 12.36,96.61 arc(12.36,96.61) 12.36,96.61 13.73,96.61 arc(14.3,96.72) 14.79,97.05 arc(15.86,97.74) 17.11,98.01 19.58,98.01 arc(19.96,97.98) 20.33,97.89 arc(21.29,97.46) 22.11,96.81 27.01,91.91 arc(28.05,91.21) 29.27,90.97 29.46,90.97 arc(29.66,90.93) 29.83,90.81 C243.2
  BOTTOM w0.14: CN5.B3 7.85,94.6 8.18,94.93 v2(8.2,94.93)
TBTA_TX1_P: length 26.5
  TOP w0.14: C235.2 29.82,91.34 arc(29.7,91.26) 29.56,91.24 29.28,91.24 arc(28.15,91.46) 27.2,92.1 22.3,97 arc(21.42,97.68) 20.41,98.14 arc(20,98.24) 19.58,98.27 17.1,98.27 arc(15.76,97.99) 14.6,97.24 14.6,97.24 arc(14.2,96.97) 13.73,96.87 12.36,96.87 arc(12.25,96.89) 12.16,96.95 R138.2 12,96.98 arc(11.88,96.9) 11.75,96.87 11.33,96.87 arc(10.34,96.68) 9.5,96.12 8.78,95.39 arc(8.72,95.35) 8.65,95.34 8.5,95.34 arc(8.37,95.36) 8.25,95.44 v2(8.2,95.49)
  BOTTOM w0.14: CN5.B2 7.81,95.1 8.2,95.49 v2(8.2,95.49)
TBTA_TX2_N: length 24.3
  TOP w0.14: C252.2 29.76,89.26 arc(29.69,89.2) 29.6,89.19 29.57,89.19 arc(29.48,89.2) 29.4,89.26 v1(29.18,89.48)
  BOTTOM w0.14: v1(29.18,89.48) 29.13,89.43 arc(29.03,89.35) 28.92,89.29 arc(28.89,89.28) 28.86,89.27 arc(28.77,89.25) 28.68,89.24 24.43,89.24 arc(23.96,89.29) 23.51,89.43 23.45,89.45 arc(22.78,89.79) 22.19,90.25 22.01,90.42 arc(19.86,91.86) 17.33,92.38 arc(15.82,92.16) 14.45,91.5 14.37,91.44 arc(14.31,91.4) 14.25,91.36 14.13,91.26 arc(14.07,91.21) 14.02,91.17 13.88,91.05 arc(13.83,91) 13.78,90.95 12.82,89.99 arc(12.69,89.84) 12.6,89.66 12.6,89.66 arc(12.5,89.51) 12.35,89.4 arc(12.29,89.38) 12.22,89.37 12.12,89.37 arc(12.01,89.39) 11.92,89.45 R849.2 11.71,89.45 arc(11.62,89.39) 11.51,89.37 11.32,89.37 arc(10.83,89.56) 10.58,90.03 arc(10.57,90.07) 10.56,90.11 arc(10.43,90.47) 10.21,90.77 9.81,91.17 arc(9.76,91.21) 9.7,91.25 arc(9.62,91.29) 9.53,91.32 arc(9.46,91.33) 9.4,91.34 arc(9.35,91.35) 9.3,91.35 CN5.A3
TBTA_TX2_P: length 24.3
  TOP w0.14: v1(29.18,88.63) 29.4,88.85 arc(29.48,88.9) 29.57,88.92 29.6,88.92 arc(29.69,88.9) 29.76,88.85 C259.2
  BOTTOM w0.14: CN5.A2 9.68,90.85 arc(9.75,90.84) 9.8,90.8 10.02,90.58 arc(10.2,90.34) 10.3,90.06 arc(10.31,90.03) 10.31,89.99 arc(10.65,89.36) 11.32,89.1 11.51,89.1 arc(11.63,89.08) 11.73,89.01 R856.2 11.93,89.05 arc(11.99,89.09) 12.06,89.1 12.22,89.1 arc(12.35,89.12) 12.47,89.17 arc(12.69,89.33) 12.84,89.55 arc(12.91,89.69) 13.01,89.8 13.94,90.73 arc(15.47,91.75) 17.28,92.11 arc(19.74,91.63) 21.82,90.23 22.01,90.05 arc(22.64,89.57) 23.34,89.2 23.41,89.18 arc(23.91,89.03) 24.43,88.98 28.67,88.98 arc(28.89,88.93) 29.08,88.81 29.12,88.77 arc(29.17,88.7) v1(29.18,88.63)
TBTB_HPD: length 0.6
  TOP w0.14: R208.1 R209.1
TBTB_HPD_C: length 2.9
  TOP w0.14: U11.C1 62.86,87.63 63.29,87.19 63.78,87.19 R208.2
TBTB_RX1_N: length 20.5
  TOP w0.14: v1(24.65,75.45) 24.85,75.65 arc(24.92,75.7) 25,75.71 25.03,75.71 arc(25.11,75.7) 25.18,75.65 C370.2
  BOTTOM w0.14: CN9.A10 9.43,80.85 arc(9.6,80.87) 9.75,80.91 9.76,80.92 arc(9.87,80.97) 9.98,81.05 arc(10.18,81.33) 10.25,81.66 10.25,82.07 arc(10.4,82.43) 10.77,82.59 11.81,82.59 arc(11.9,82.57) 11.98,82.52 R915.2 12.15,82.51 arc(12.23,82.56) 12.32,82.58 12.98,82.58 arc(13.57,82.47) 14.07,82.16 arc(14.29,81.98) 14.53,81.83 arc(14.88,81.66) 15.25,81.54 arc(15.53,81.49) 15.82,81.47 16.33,81.47 arc(18.34,81.07) 20.03,79.94 24.05,75.92 arc(24.22,75.81) 24.42,75.77 24.5,75.77 arc(24.61,75.73) 24.65,75.62 v1(24.65,75.45)
TBTB_RX1_P: length 20.5
  TOP w0.14: C360.2 25.17,76.02 arc(25.12,75.99) 25.06,75.98 25.03,75.98 arc(24.97,75.99) 24.92,76.02 v1(24.65,76.3)
  BOTTOM w0.14: CN9.A11 9.43,81.35 arc(9.51,81.33) 9.58,81.29 9.6,81.26 arc(9.65,81.23) 9.7,81.22 9.72,81.22 arc(9.76,81.23) 9.8,81.25 arc(9.93,81.44) 9.98,81.66 9.98,82.07 arc(10.21,82.62) 10.77,82.85 11.75,82.85 arc(11.86,82.88) 11.96,82.94 R898.2 12.18,82.94 arc(12.28,82.87) 12.4,82.85 12.98,82.85 arc(13.66,82.72) 14.25,82.36 arc(14.45,82.2) 14.66,82.06 arc(14.98,81.91) 15.31,81.8 arc(15.56,81.75) 15.82,81.74 16.33,81.74 arc(18.44,81.32) 20.22,80.13 24.24,76.11 arc(24.32,76.06) 24.42,76.04 24.51,76.04 arc(24.61,76.08) 24.65,76.18 v1(24.65,76.3)
TBTB_RX2_N: length 22.8
  TOP w0.14: C414.2 25.43,70.07 25.22,69.86 arc(25.11,69.78) 24.97,69.76 24.9,69.76 arc(24.81,69.77) 24.73,69.82 24.15,70.4 arc(23.81,70.91) 23.7,71.51 23.7,72.69 arc(23.5,73.65) 22.96,74.46 22.4,75.02 arc(21.67,75.51) 20.8,75.68 15.69,75.68 arc(15.36,75.63) 15.06,75.48 arc(14.91,75.4) 14.74,75.38 12.11,75.38 arc(12,75.4) 11.91,75.46 R350.2 11.7,75.44 arc(11.6,75.37) 11.48,75.35 11.23,75.35 arc(11.07,75.38) 10.93,75.48 10.08,76.33 arc(9.85,76.48) 9.58,76.53 9.33,76.53 arc(9.26,76.54) 9.21,76.58 9.04,76.74 arc(8.9,76.84) 8.73,76.87 8.55,76.87 arc(8.36,76.91) v2(8.2,77.02)
  BOTTOM w0.14: CN9.B10 8.01,77.1 arc(8.11,77.08) v2(8.2,77.02)
TBTB_RX2_P: length 22.8
  TOP w0.14: C430.2 25.43,69.18 25.25,69.36 arc(25.11,69.46) 24.95,69.49 24.9,69.49 arc(24.71,69.53) 24.54,69.64 23.96,70.22 arc(23.57,70.81) 23.43,71.51 23.43,72.69 arc(23.26,73.55) 22.77,74.27 22.21,74.83 arc(21.57,75.26) 20.8,75.42 15.69,75.42 arc(15.44,75.38) 15.21,75.26 arc(14.99,75.15) 14.74,75.11 11.99,75.11 R370.2 11.72,75.03 arc(11.66,75.07) 11.58,75.08 11.23,75.08 arc(10.96,75.14) 10.74,75.29 9.89,76.14 arc(9.75,76.23) 9.58,76.26 9.33,76.26 arc(9.16,76.3) 9.02,76.39 8.86,76.56 arc(8.8,76.59) 8.73,76.61 8.56,76.61 arc(8.37,76.57) v2(8.2,76.46)
  BOTTOM w0.14: CN9.B11 7.87,76.6 arc(8.05,76.56) v2(8.2,76.46)
TBTB_SSRX1_N: length 4.4
  TOP w0.079: U16.J11 32.11,74.15 arc(31.99,74.07) 31.86,74.05 31.59,74.05 arc(31.51,74.06) 31.45,74.11 31.44,74.12 arc(31.37,74.16) 31.29,74.18 30.91,74.18 30.86,74.13 30.84,74.13
  TOP w0.14: R351.1 29.32,75.66 arc(29.38,75.7) 29.45,75.72 29.58,75.72 arc(29.63,75.71) 29.68,75.68 29.88,75.48 arc(29.92,75.42) 29.93,75.35 29.93,75.06 arc(29.93,75.05) 29.93,75.04 arc(29.97,74.83) 30.09,74.65 30.49,74.25 arc(30.62,74.16) 30.78,74.13 30.84,74.13
TBTB_SSRX1_N_C: length 3
  TOP w0.14: R351.2 28.43,75.58 arc(28.26,75.69) 28.06,75.73 27.41,75.73 arc(27.33,75.72) 27.26,75.67 D28.1 27.11,75.67 arc(27.04,75.71) 26.97,75.72 26.4,75.72 arc(26.22,75.69) 26.07,75.58 C370.1
TBTB_SSRX1_P: length 4.4
  TOP w0.079: 30.84,74.4 30.86,74.4 30.91,74.35 31.29,74.35 arc(31.38,74.36) 31.46,74.42 31.47,74.43 arc(31.55,74.48) 31.64,74.5 31.85,74.5 arc(31.97,74.38) 31.85,74.27 U16.J12
  TOP w0.14: R347.1 29.26,76.08 arc(29.37,76.01) 29.5,75.99 29.58,75.99 arc(29.73,75.95) 29.87,75.87 30.07,75.67 arc(30.16,75.52) 30.2,75.35 30.2,75.04 arc(30.22,74.93) 30.28,74.84 30.68,74.44 arc(30.73,74.41) 30.78,74.4 30.84,74.4
TBTB_SSRX1_P_C: length 3
  TOP w0.14: R347.2 28.42,76.1 arc(28.3,76.03) 28.16,76 27.43,76 arc(27.34,76.02) 27.27,76.06 D27.1 27.09,76.06 arc(27.01,76.01) 26.92,75.99 26.36,75.99 arc(26.19,76.02) 26.06,76.11 C360.1
TBTB_SSRX2_N: length 4.6
  TOP w0.079: 30.84,71.64 30.86,71.64 30.91,71.59 31.35,71.59 arc(31.44,71.6) 31.5,71.65 31.52,71.66 arc(31.58,71.71) 31.66,71.72 31.86,71.72 arc(31.99,71.7) 32.11,71.62 U16.C11
  TOP w0.14: R428.1 29.3,69.83 arc(29.4,69.76) 29.51,69.75 arc(29.61,69.78) 29.7,69.84 29.7,69.84 arc(29.82,70.02) 29.86,70.23 29.86,70.56 arc(29.9,70.77) 30.02,70.95 30.67,71.6 arc(30.71,71.63) 30.76,71.64 30.84,71.64
TBTB_SSRX2_N_C: length 3
  TOP w0.14: C414.1 26.07,69.88 arc(26.2,69.79) 26.36,69.76 26.95,69.76 arc(27.03,69.77) 27.1,69.82 D35.1 27.27,69.82 arc(27.34,69.77) 27.43,69.75 28.09,69.75 arc(28.27,69.79) 28.43,69.89 R428.2
TBTB_SSRX2_P: length 4.6
  TOP w0.079: U16.C12 31.86,71.5 arc(31.97,71.39) 31.86,71.27 31.61,71.27 arc(31.52,71.29) 31.45,71.34 31.44,71.35 arc(31.36,71.4) 31.28,71.42 30.91,71.42 30.86,71.37 30.84,71.37
  TOP w0.14: R439.1 29.06,69.18 29.24,69.36 arc(29.38,69.44) 29.54,69.49 arc(29.73,69.54) 29.89,69.65 arc(30.06,69.92) 30.13,70.23 30.13,70.56 arc(30.15,70.67) 30.21,70.76 30.82,71.37 30.84,71.37
TBTB_SSRX2_P_C: length 3
  TOP w0.14: C430.1 26.06,69.35 arc(26.21,69.45) 26.39,69.49 26.94,69.49 arc(27.03,69.47) 27.1,69.43 D38.1 27.26,69.42 arc(27.33,69.47) 27.41,69.48 28.13,69.48 arc(28.29,69.45) 28.43,69.36 R439.2
TBTB_SSTX1_N: length 3.6
  TOP w0.079: U16.G11 32.11,73.23 arc(31.99,73.15) 31.86,73.13 31.61,73.13 arc(31.53,73.14) 31.46,73.19 31.45,73.2 arc(31.39,73.24) 31.31,73.26 30.91,73.26 30.86,73.21 30.84,73.21
  TOP w0.14: 30.84,73.21 30.49,73.21 arc(30.22,73.26) 29.99,73.41 29.77,73.64 arc(29.67,73.7) 29.56,73.72 29.53,73.72 arc(29.42,73.7) 29.32,73.64 R389.1
TBTB_SSTX1_N_C: length 3
  TOP w0.14: R389.2 28.43,73.55 arc(28.29,73.64) 28.13,73.67 27.44,73.67 arc(27.35,73.65) 27.27,73.6 D30.1 27.09,73.59 arc(27.02,73.64) 26.93,73.66 26.33,73.66 arc(26.19,73.63) 26.07,73.56 C388.1
TBTB_SSTX1_P: length 3.6
  TOP w0.079: 30.84,73.48 30.86,73.48 30.91,73.43 31.27,73.43 arc(31.38,73.45) 31.47,73.51 arc(31.52,73.55) 31.57,73.57 arc(31.61,73.58) 31.65,73.59 31.86,73.59 arc(31.9,73.58) 31.93,73.56 arc(31.97,73.43) 31.86,73.35 U16.G12
  TOP w0.14: R380.1 29.24,74.08 arc(29.33,74.01) 29.45,73.99 29.56,73.99 arc(29.78,73.95) 29.96,73.83 30.18,73.6 arc(30.32,73.51) 30.49,73.48 30.84,73.48
TBTB_SSTX1_P_C: length 3
  TOP w0.14: R380.2 28.42,74.08 arc(28.27,73.97) 28.09,73.94 27.39,73.94 arc(27.32,73.95) 27.26,73.99 D29.1 27.1,73.99 arc(27.04,73.94) 26.96,73.93 26.43,73.93 arc(26.23,73.97) 26.06,74.08 C383.1
TBTB_SSTX2_N: length 3.7
  TOP w0.079: U16.E11 32.11,72.54 arc(31.99,72.62) 31.86,72.64 31.67,72.64 arc(31.59,72.63) 31.53,72.58 31.52,72.57 arc(31.45,72.53) 31.37,72.51 30.91,72.51 30.86,72.56 30.84,72.56
  TOP w0.14: 30.84,72.56 30.55,72.56 arc(30.33,72.52) 30.14,72.39 29.58,71.83 arc(29.53,71.79) 29.47,71.78 29.44,71.78 arc(29.38,71.79) 29.33,71.83 R397.1
TBTB_SSTX2_N_C: length 3.1
  TOP w0.14: C396.1 26.06,72.05 arc(26.2,71.95) 26.37,71.92 26.4,71.92 arc(26.42,71.92) 26.43,71.92 26.81,71.83 arc(26.89,71.83) 26.98,71.83 arc(27.04,71.86) 27.09,71.9 D32.1 27.28,71.89 arc(27.36,71.83) 27.46,71.81 28.17,71.81 arc(28.31,71.84) 28.43,71.92 R397.2
TBTB_SSTX2_P: length 3.7
  TOP w0.079: 30.84,72.29 30.86,72.29 30.91,72.34 31.25,72.34 arc(31.34,72.33) 31.42,72.27 31.43,72.26 arc(31.5,72.21) 31.59,72.2 31.85,72.2 arc(31.96,72.31) 31.85,72.42 U16.E12
  TOP w0.14: R410.1 29.29,71.45 arc(29.37,71.5) 29.46,71.51 29.47,71.51 arc(29.63,71.55) 29.76,71.64 30.33,72.2 arc(30.43,72.27) 30.55,72.29 30.84,72.29
TBTB_SSTX2_P_C: length 3.1
  TOP w0.14: R410.2 28.43,71.39 arc(28.25,71.51) 28.04,71.55 27.37,71.55 arc(27.31,71.53) 27.25,71.5 D33.1 arc(27.1,71.51) 27,71.56 26.91,71.56 arc(26.89,71.56) 26.87,71.56 arc(26.81,71.56) 26.75,71.57 26.4,71.65 26.32,71.65 arc(26.21,71.63) 26.11,71.57 C403.1
TBTB_TX1_N: length 23.4
  TOP w0.14: v2(8.2,80.93) 8.28,81 arc(8.36,81.06) 8.45,81.07 8.55,81.07 arc(8.71,81.11) 8.84,81.19 9.93,82.29 arc(10.28,82.52) 10.68,82.6 11.66,82.6 arc(11.88,82.55) R266.2 12.24,82.59 13.07,82.59 arc(13.55,82.5) 13.96,82.22 14.17,82.01 arc(14.59,81.73) 15.08,81.64 17.61,81.64 arc(18.56,81.45) 19.37,80.91 22.55,77.72 arc(22.72,77.48) 22.77,77.18 22.77,76.96 arc(23.03,75.67) 23.76,74.58 24.47,73.87 arc(24.64,73.75) 24.85,73.71 24.87,73.71 arc(25.07,73.67) 25.24,73.56 C388.2
  BOTTOM w0.14: CN9.B3 7.75,80.6 arc(7.84,80.62) 7.92,80.67 8.16,80.91 arc(8.18,80.93) v2(8.2,80.93)
TBTB_TX1_P: length 23.4
  TOP w0.14: C383.2 25.24,74.07 arc(25.14,74) 25.03,73.98 24.85,73.98 arc(24.74,74) 24.66,74.06 23.95,74.76 arc(23.28,75.77) 23.04,76.96 23.04,77.18 arc(22.96,77.58) 22.74,77.91 19.56,81.1 arc(18.66,81.69) 17.61,81.9 15.08,81.9 arc(14.69,81.98) 14.36,82.2 14.15,82.41 arc(13.65,82.74) 13.07,82.86 12.38,82.86 arc(12.27,82.88) 12.17,82.94 R253.2 12.06,83.05 arc(11.86,82.91) 11.62,82.86 10.68,82.86 arc(10.17,82.76) 9.75,82.48 9.75,82.48 8.65,81.38 arc(8.61,81.35) 8.55,81.34 8.41,81.34 arc(8.36,81.35) 8.31,81.38 v2(8.2,81.49)
  BOTTOM w0.14: CN9.B2 7.68,81.1 arc(7.8,81.12) 7.9,81.19 8.19,81.48 arc(8.2,81.49) v2(8.2,81.49)
TBTB_TX2_N: length 20.7
  TOP w0.14: v1(24.61,72.21) 24.83,71.98 arc(24.91,71.93) 25,71.91 25.02,71.91 arc(25.11,71.93) 25.19,71.98 C396.2
  BOTTOM w0.14: v1(24.61,72.21) 24.35,71.95 arc(24.32,71.93) 24.29,71.91 24.24,71.91 arc(24.11,71.97) 24.05,72.09 24.05,72.73 arc(23.88,73.63) 23.37,74.39 22.04,75.72 arc(21.25,76.24) 20.32,76.43 18.16,76.43 arc(17.07,76.29) 16.05,75.88 15.88,75.78 arc(15.16,75.5) 14.4,75.4 12.04,75.4 arc(11.98,75.41) 11.92,75.45 R939.2 11.7,75.44 arc(11.65,75.41) 11.59,75.39 11.21,75.39 arc(10.93,75.48) 10.75,75.7 10.53,76.23 arc(10.32,76.63) 10.03,76.98 9.91,77.1 arc(9.85,77.16) 9.77,77.21 arc(9.55,77.31) 9.31,77.35 CN9.A3
TBTB_TX2_P: length 20.7
  TOP w0.14: C403.2 25.19,71.58 arc(25.11,71.63) 25.02,71.65 25,71.65 arc(24.91,71.63) 24.83,71.58 v1(24.61,71.36)
  BOTTOM w0.14: v1(24.61,71.36) 24.61,71.41 arc(24.6,71.46) 24.57,71.51 24.48,71.59 arc(24.43,71.63) 24.36,71.65 24.24,71.65 arc(23.92,71.78) 23.79,72.09 23.79,72.73 arc(23.63,73.52) 23.18,74.2 21.85,75.53 arc(21.15,76) 20.32,76.16 18.16,76.16 arc(17.13,76.03) 16.18,75.65 16.01,75.55 arc(15.23,75.24) 14.4,75.13 12.14,75.13 arc(12.02,75.11) 11.92,75.04 R945.2 11.71,75.04 arc(11.61,75.11) 11.49,75.13 11.21,75.13 arc(10.79,75.26) 10.5,75.6 10.28,76.13 arc(10.1,76.48) 9.84,76.79 9.83,76.8 arc(9.78,76.84) 9.71,76.85 CN9.A2
TCP0_AN_RBIAS: length 1.2
  TOP w0.079: v2(39.85,92.03) 40.02,92.2 U9.L4
  BOTTOM w0.14: v2(39.85,92.03) 39.98,92.16 R840.1
TCP0_AN_RSENSE: length 1.4
  TOP w0.079: U9.L5 39.56,92.37 v2(39.21,92.02)
  BOTTOM w0.14: v2(39.21,92.02) 39.53,92.34 R840.2
TCP0_AUX_DN: length 177.5
  TOP w0.14: v1(38.51,97.83) 38.61,97.73 arc(38.67,97.64) 38.69,97.54 38.69,97.41 arc(38.68,97.37) 38.68,97.33 arc(38.65,97.27) 38.6,97.21 38.6,97.21 R143.1
  IN4 w0.086: v1(38.51,97.83) 38.84,98.15 arc(38.84,98.16) 38.85,98.17 arc(38.89,98.23) 38.92,98.29 arc(39.02,98.55) 39.19,98.77 39.36,98.93 arc(39.55,99.05) 39.77,99.06 40.19,98.99 arc(40.31,98.98) 40.44,98.99 41.49,99.18 42.43,99.01 42.55,98.88 42.85,98.47 43.26,98.18 43.44,98 43.55,97.36 43.38,96.41 43.7,94.64 43.42,93.06 43.49,92.66 43.33,91.73 43.56,90.43 43.34,89.18 43.49,88.28 43.49,88.1 44.04,87.32 44.92,86.7 45.11,86.43 45.2,86.34 46.06,86.18 47.43,86.43 47.74,86.37 48.44,86.47 48.89,86.79 49.62,87.83 50.66,88.56 51.39,89.6 52.43,90.33 53.16,91.37 54.2,92.1 54.93,93.14 55.74,93.71 56.77,93.89 58.02,93.67 58.98,93.83 59.65,93.72 60.08,93.79 60.42,94.04 60.65,94.36 60.86,95.53 60.81,95.82 60.81,95.85 60.85,96.06 61.08,96.39 61.61,96.67 62.22,96.76 62.87,96.64 64.27,96.89 65.52,96.67 66.77,96.89 68.02,96.67 69.27,96.89 70.53,96.67 71.78,96.89 73.03,96.67 74.28,96.89 75.53,96.67 76.78,96.89 78.03,96.67 79.28,96.89 80.53,96.67 81.78,96.89 83.03,96.67 84.28,96.89 85.53,96.67 86.78,96.89 88.04,96.67 89.42,96.91 90.73,97.3 92.56,98.05 94.4,99.34 94.92,100.08 95.72,100.65 97.97,101.04 99.18,100.83 100.43,101.05 101.44,100.87 102.8,101.11 103.9,101.68 104.09,101.87 104.45,102.39 105.5,103.12 106.23,104.16 106.75,104.53 106.9,104.68 107.4,105.77 107.63,107.08 107.63,107.23 107.45,108.26 107.61,109.17 107.38,110.46 107.65,111.98 107.45,113.12 107.43,113.23 107.65,114.48 107.43,115.73 107.65,116.98 107.43,118.23 107.65,119.48 107.43,120.73 107.58,121.59 107.65,121.99 107.46,123.05 107.6,123.83 107.6,124.22 107.97,126.36 108.9,128.64 109.6,129.64 110.35,132.02 110.35,133.56 110.59,134.89 110.45,135.66 110.59,136.47 110.59,137.7 111.23,139.24 111.38,139.39 111.6,140.59 114.94,145.35 116.2,146.23 116.4,146.52 116.48,146.57 117.49,147.58 117.49,148.73 117.62,149.49 117.32,151.17 118,154.99 118.97,156.38 121.36,158.06 126.83,159.03 127.04,158.99 128.29,159.21 129.54,158.99 130.79,159.21 132.14,158.98 133.08,159.14 133.66,159.04 135.38,159.34 139.57,158.6 140.39,158.03 140.62,157.8 141.11,157.46 141.33,157.14 141.51,156.96 141.51,152.55 arc(141.58,152.18) 141.79,151.87 142.31,151.35 arc(142.4,151.29) 142.5,151.27 142.81,151.27 arc(142.84,151.27) 142.86,151.29 142.99,151.41 arc(143.01,151.45) 143.02,151.49 143.02,151.56 arc(143.02,151.57) 143.02,151.58 143.02,151.74 arc(143.03,151.78) 143.05,151.81 143.37,152.13 arc(143.42,152.2) 143.44,152.29 v2(143.44,152.31)
  BOTTOM w0.14: U42.BN38 143.3,152.26 arc(143.36,152.3) v2(143.44,152.31)
TCP0_AUX_DN_R: length 4.4
  TOP w0.079: U9.M8 arc(38.23,92.99) 38.24,93.08 38.24,93.69 arc(38.28,93.88) 38.39,94.04 38.71,94.36 arc(38.73,94.39) 38.74,94.43 38.74,94.86 arc(38.73,94.91) 38.7,94.96
  TOP w0.14: R143.2 38.54,96.51 38.58,96.51 38.65,96.58 38.79,96.58 38.85,96.52 38.85,96.18 arc(38.83,96.05) 38.77,95.93 arc(38.72,95.81) 38.7,95.68 38.7,94.96
TCP0_AUX_DP: length 177.4
  TOP w0.14: R144.1 39.24,96.96 arc(39.04,97.05) 38.95,97.25 38.95,97.42 arc(39.08,97.7) v1(39.36,97.83)
  IN4 w0.086: v2(143.44,151.66) 143.32,151.66 arc(143.23,151.62) 143.19,151.53 143.19,151.49 arc(143.17,151.39) 143.11,151.3 142.98,151.17 arc(142.9,151.12) 142.81,151.1 142.5,151.1 arc(142.34,151.14) 142.19,151.23 141.68,151.75 arc(141.43,152.12) 141.34,152.55 141.34,156.89 141.2,157.04 140.99,157.34 140.52,157.67 140.29,157.9 139.51,158.45 135.38,159.17 133.66,158.87 133.08,158.97 132.14,158.81 130.79,159.04 129.54,158.82 128.29,159.04 127.04,158.82 126.83,158.86 121.42,157.91 119.08,156.26 118.15,154.93 117.49,151.17 117.79,149.49 117.65,148.72 117.65,147.51 116.59,146.45 116.52,146.4 116.32,146.11 115.06,145.23 111.76,140.52 111.53,139.31 111.37,139.14 110.76,137.67 110.76,136.46 110.62,135.66 110.75,134.89 110.52,133.55 110.52,131.99 109.75,129.56 109.05,128.56 108.13,126.31 107.77,124.2 107.77,123.81 107.63,123.05 107.82,121.99 107.72,121.45 107.6,120.73 107.82,119.48 107.6,118.23 107.82,116.98 107.6,115.73 107.82,114.48 107.6,113.23 107.62,113.12 107.82,111.98 107.55,110.46 107.78,109.17 107.61,108.26 107.8,107.24 107.8,107.06 107.56,105.72 107.04,104.59 106.86,104.4 106.35,104.05 106.35,104.05 105.62,103 104.57,102.27 104.22,101.76 104,101.54 102.85,100.95 101.44,100.71 100.43,100.88 99.18,100.66 97.97,100.87 95.79,100.49 95.04,99.96 94.52,99.22 92.64,97.9 90.79,97.14 89.45,96.75 88.04,96.5 86.78,96.72 85.53,96.5 84.28,96.72 83.03,96.5 81.78,96.72 80.53,96.5 79.28,96.72 78.03,96.5 76.78,96.72 75.53,96.5 74.28,96.72 73.03,96.5 71.78,96.72 70.53,96.5 69.27,96.72 68.02,96.5 66.77,96.72 65.52,96.5 64.27,96.72 62.87,96.48 62.22,96.59 61.67,96.51 61.19,96.27 61.01,96 60.97,95.82 61.03,95.53 60.81,94.3 60.54,93.92 60.14,93.64 59.65,93.55 58.98,93.67 58.02,93.5 56.77,93.72 55.81,93.55 55.05,93.02 54.32,91.98 53.28,91.25 52.55,90.21 51.51,89.48 50.78,88.44 49.74,87.71 49.01,86.67 48.5,86.31 47.74,86.21 47.43,86.26 46.06,86.02 45.12,86.18 44.98,86.32 44.8,86.58 43.92,87.2 43.33,88.04 43.33,88.27 43.17,89.18 43.39,90.43 43.16,91.73 43.32,92.66 43.25,93.06 43.53,94.64 43.22,96.41 43.38,97.36 43.29,97.92 43.15,98.05 42.73,98.35 42.43,98.78 42.35,98.86 41.49,99.01 40.47,98.83 arc(40.31,98.82) 40.16,98.83 39.75,98.9 arc(39.6,98.89) 39.48,98.82 39.31,98.65 arc(39.17,98.46) 39.08,98.25 arc(39.03,98.15) 38.97,98.06 arc(38.95,97.91) 39.08,97.83 v1(39.36,97.83)
  BOTTOM w0.14: U42.BN37 143.03,151.49 arc(143.08,151.61) 143.21,151.66 v2(143.44,151.66)
TCP0_AUX_DP_R: length 4.4
  TOP w0.079: U9.L8 38.3,92.58 arc(38.38,92.71) 38.41,92.85 38.41,93.69 arc(38.44,93.82) 38.51,93.92 38.83,94.24 arc(38.88,94.33) 38.9,94.43 38.9,94.81 arc(38.92,94.89) 38.96,94.95
  TOP w0.14: 38.96,94.95 38.96,95.68 arc(38.97,95.74) 39,95.78 38.99,95.78 arc(39.09,95.97) 39.12,96.18 39.12,96.32 arc(39.12,96.32) 39.12,96.32 39.13,96.35 arc(39.13,96.36) 39.13,96.37 arc(39.16,96.41) 39.19,96.45 R144.2
TCP0_FLASH_BUSY#: length 5.7
  TOP w0.079: U9.A9 37.71,87.54 37.52,87.35 37.52,87.23 36.76,86.48 36.76,86.42
  TOP w0.14: R243.1 R244.1 35.82,83.88 36.15,84.21 36.15,85.81 36.76,86.42
TCP0_FLASH_CLK: length 21.1
  TOP w0.079: v2(38.56,88.74) U9.C7
  TOP w0.14: v1(51.77,92.57) 51.41,92.93 R165.2 51.16,91.37 U10.6
  IN2 w0.089: v1(51.77,92.57) 51.77,92.38 48.37,88.99 48.37,87.33 46.92,85.88 45.36,85.88 43.31,87.93 40.09,87.93 39.73,88.28 39.13,88.28 38.67,88.74 v2(38.56,88.74)
TCP0_FLASH_CS#: length 14.9
  TOP w0.079: U9.B6 39.31,88.1 39.31,87.19 v1(39.53,86.97)
  TOP w0.14: U10.1 48.64,85.07 49.28,84.44 R233.2 R232.2 48.29,84.13 47.83,84.6 v1(47.83,84.68)
  IN2 w0.089: v1(47.83,84.68) 47.09,85.41 45.16,85.41 43.12,87.46 40.02,87.46 v1(39.53,86.97)
TCP0_FLASH_DI: length 22
  TOP w0.079: U9.C6 39.2,88.75 v2(39.21,88.75)
  TOP w0.14: U10.5 52.45,92.24 52.23,92.47 R166.2 v1(52.23,93.51) 52.23,93.97 v1(52.58,94.32)
  IN2 w0.089: v2(39.21,88.75) 39.93,88.75 40.28,88.4 41.13,88.4 41.51,88.78 43.13,88.78 45.55,86.35 46.73,86.35 47.9,87.52 47.9,89.28 51.65,93.03 51.75,93.03 v1(52.23,93.51)
TCP0_FLASH_DO: length 19.3
  TOP w0.079: 41.04,86.42 41.04,86.84 40.24,87.64 40.24,88.1 U9.B4
  TOP w0.14: 41.04,86.42 41.04,86.13 41.23,85.94 41.66,85.94 42.17,85.43 42.17,84.03 42.34,83.86 42.34,83.35 42.66,83.02 44.27,83.02 v1(47.38,86.14) 48.45,87.21 49.53,87.21 49.91,86.83 U10.2 49.91,84.26 R234.2 R235.2
TCP0_FLASH_HOLD#: length 1.7
  TOP w0.14: U10.7 49.91,92.18 50.16,92.43 R164.2
TCP0_FLASH_MSTR_SLV: length 5.7
  TOP w0.079: U9.A5 39.56,87.61 39.98,87.19 39.98,86.82 39.58,86.42
  TOP w0.14: R242.1 R248.1 40.14,84.52 40.14,85.27 40,85.4 R222.2 39.75,85.69 39.5,85.94 39.5,86.34 39.58,86.42
TCP0_FLASH_SHARE_EN: length 5.1
  TOP w0.079: U9.A4 40.02,87.63 40.54,87.11 40.54,86.9 40.78,86.65 40.78,86.42
  TOP w0.14: R241.1 41.69,83.94 41.91,84.16 41.91,85.27 41.77,85.4 R224.2 41.31,85.4 40.78,85.93 40.78,86.42
TCP0_FLASH_WP#: length 3
  TOP w0.14: v1(52.58,83.78) 52.2,83.78 51.85,84.13 R236.2 51.69,84.44 51.18,84.95 U10.3
TCP0_GPIO_5: length 3.8
  TOP w0.079: 36.27,86.42 36.42,86.58 36.51,86.58 37.48,87.55 37.48,88.08 U9.B9
  TOP w0.14: R218.1 35.69,85.85 36.27,86.42
TCP0_GPIO_6: length 5.9
  TOP w0.079: U9.A8 38.17,87.74 37.75,87.31 37.75,87.01 37.16,86.42
  TOP w0.14: R246.2 R245.1 36.61,83.88 36.43,84.06 36.43,85.7 37.16,86.42
TCP0_GPIO_7: length 5.5
  TOP w0.079: v1(38.23,87.13) 38.42,87.31 38.42,88.08 U9.B8
  BOTTOM w0.14: v1(38.23,87.13) 38.61,87.51 v1(38.61,87.85) ; v1(38.23,87.13) 38.03,86.93 R874.1 ; v1(38.23,87.13) 38.87,86.49 R875.1 R1226.1
TCP0_GPIO_12: length 4.4
  TOP w0.079: 39.09,86.42 39.09,87.44 U9.A6
  TOP w0.14: 39.09,86.42 39.09,86.3 38.64,85.84 R221.2 38.64,84.9 38.86,84.68 38.86,84.28 38.61,84.04 R247.1
TCP0_JTAG_TCK: length 5.5
  TOP w0.079: U9.B5 39.78,88.09 39.78,87.63 40.21,87.19 40.21,86.61 40.03,86.42
  TOP w0.14: R249.2 41.05,83.98 41.05,85.27 40.91,85.4 R223.2 40.52,85.69 40.08,86.13 TP35.1 40,86.4 40.03,86.42
TCP0_JTAG_TDI: length 3.5
  TOP w0.079: 41.95,86.59 41.41,87.13 41.01,87.13 40.48,87.66 U9.A3
  TOP w0.14: R225.2 42.55,85.69 TP36.1 42.17,86.37 41.95,86.59
TCP0_JTAG_TDO: length 3.5
  TOP w0.079: U9.C5 v2(39.84,89.41)
  BOTTOM w0.14: R864.2 41.25,87.49 40.77,87.97 TP130.1 40.04,88.45 40.04,89.21 v2(39.84,89.41)
TCP0_JTAG_TMS: length 5.8
  TOP w0.079: U9.C3 v2(40.48,88.77)
  TOP w0.14: v1(43.31,86.45) 43.69,86.45 TP37.1 R227.2
  BOTTOM w0.14: v1(43.31,86.45) 41.91,87.85 41.41,87.85 v2(40.48,88.77)
TCP0_RESET#: length 11.5
  TOP w0.079: 35.41,93.96 36.23,93.96 37.03,93.16 37.03,92.7 U9.L11
  TOP w0.14: 35.41,93.96 34.43,93.96 34.3,94.09 32.81,94.09 32.01,94.88 31.69,94.88 31.53,95.05 R153.1 R149.1 R141.2 30.99,96.99 v1(30.86,97.12) 30.58,96.83 R148.1 R152.1
TCP0_TEST_PWRGD: length 5
  TOP w0.079: U9.B3 40.7,88.1 40.7,87.69 40.87,87.52 41.51,87.52 41.7,87.33 42.43,87.33
  TOP w0.14: R226.1 43.31,85.71 42.75,86.27 42.75,87.12 v1(42.55,87.33) 42.43,87.33
TCP0_THERMDA: length 2.2
  TOP w0.14: U9.M11 36.79,93.04 36.22,93.61 35.15,93.61 TP28.1
TCP0_TX_N0: length 157.7
  TOP w0.14: C228.1 45.12,92.48 arc(45.19,92.44) 45.26,92.43 45.35,92.43 arc(45.45,92.45) 45.54,92.5 v1(45.75,92.72)
  IN4 w0.086: v2(142.65,152.31) 142.46,152.12 arc(142.42,152.09) 142.36,152.08 142.3,152.08 arc(142.26,152.09) 142.22,152.12 142.16,152.18 arc(142.14,152.21) 142.13,152.26 142.13,152.97 arc(142.14,153.01) 142.16,153.05 143.16,154.05 arc(143.31,154.24) 143.42,154.46 arc(143.46,154.61) 143.48,154.76 143.48,156.64 arc(143.47,156.78) 143.44,156.93 arc(143.33,157.24) 143.17,157.52 142.75,158.12 142.41,158.49 141.64,159.03 arc(141.58,159.08) 141.53,159.14 141.07,159.8 140,160.63 139.77,160.79 138.65,160.79 137.51,160.99 136.39,160.79 135.57,160.94 134.74,160.79 134.41,160.79 133.71,160.67 133.27,160.67 133.02,160.71 132.04,160.54 130.79,160.76 129.54,160.54 128.29,160.76 128.26,160.75 127.04,160.54 126.77,160.58 124.91,160.25 124.78,160.21 119.2,159.23 118.8,158.66 117.31,157.62 116.04,155.8 115.83,154.64 115.9,154.25 115.9,152.93 115.69,151.69 116.08,149.49 115.94,148.72 115.94,148.18 115.6,147.84 115.35,147.67 115.11,147.32 113.72,146.35 110.16,141.28 109.96,140.15 109.73,139.92 109.06,138.51 109.06,136.52 108.9,135.61 109.02,134.91 108.83,133.83 108.83,132.25 108.25,130.42 107.81,130.11 107.55,129.74 106.58,127.34 106.33,125.91 106.33,125.91 106.08,124.48 106.08,124 105.92,123.07 106.11,121.99 105.89,120.73 106.11,119.48 105.89,118.23 106.11,116.98 105.89,115.73 106.11,114.48 105.89,113.23 105.9,113.12 106.11,111.98 105.84,110.46 106.06,109.21 105.89,108.22 105.99,107.63 105.36,105.54 102.85,103.03 102.01,102.6 101.2,102.46 100.43,102.59 99.18,102.37 97.93,102.59 95.04,102.08 93.89,101.28 93.42,100.6 92.47,99.94 91.74,99.36 90.28,98.77 88.79,98.34 88.04,98.21 86.78,98.43 85.53,98.21 84.28,98.43 83.03,98.21 81.78,98.43 80.53,98.21 79.28,98.43 78.03,98.21 76.78,98.43 75.53,98.21 74.28,98.43 73.03,98.21 71.78,98.43 70.53,98.21 69.27,98.43 68.02,98.21 66.77,98.43 65.52,98.21 64.27,98.43 62.95,98.2 61.9,98.38 61.68,98.35 61.36,98.35 60.36,98.04 60.07,97.64 59.53,97.26 58.44,97.26 57.94,97.34 56.75,97.14 56.05,97.26 55.76,97.26 55.26,97.09 54.9,96.74 54.68,96.42 53.63,95.68 53.32,95.24 52.8,94.72 52.2,94.55 51.88,94.55 51.48,94.38 51.28,94.1 50.54,93.58 50.02,92.84 49.27,92.32 49.02,91.96 48.91,91.85 48.13,91.71 47.34,91.85 47.04,92.15 arc(46.79,92.32) 46.49,92.37 46.2,92.37 arc(46.1,92.39) 46.02,92.45 v1(45.75,92.72)
  BOTTOM w0.14: U42.BP38 142.51,152.26 arc(142.58,152.3) v2(142.65,152.31)
TCP0_TX_N0_C: length 4
  TOP w0.079: 42.43,91.68 42.41,91.68 42.36,91.63 41.88,91.63 arc(41.81,91.65) 41.75,91.69 41.74,91.7 arc(41.68,91.74) 41.6,91.75 41.3,91.75 arc(41.16,91.73) 41.05,91.65 U9.J2
  TOP w0.14: 42.43,91.68 42.95,91.68 arc(43.12,91.71) 43.26,91.81 43.73,92.27 arc(43.89,92.39) 44.09,92.43 44.14,92.43 arc(44.23,92.44) 44.3,92.5 C228.2
TCP0_TX_N1: length 170.1
  TOP w0.14: C264.1 45.11,87.54 arc(45.19,87.49) 45.28,87.47 45.42,87.47 arc(45.52,87.49) 45.6,87.54 v1(45.82,87.76)
  IN4 w0.086: v1(45.82,87.76) arc(45.79,87.62) 45.71,87.51 arc(45.59,87.43) 45.45,87.4 45.37,87.4 arc(45.29,87.41) 45.22,87.46 45.15,87.53 44.7,87.85 44.25,88.48 44.25,88.67 44.14,89.3 44.35,90.47 44.13,91.72 44.3,92.68 44.25,92.93 44.25,93.26 44.31,93.39 44.87,93.96 45.13,94.08 45.91,94.22 46.7,94.08 47.02,94.13 47.29,94.13 47.54,94.04 47.64,93.94 47.95,93.82 48.59,93.82 49.16,94.02 49.5,94.5 50.31,95.07 50.53,95.38 50.97,95.82 51.32,95.93 51.8,95.93 52.22,96.08 52.66,96.7 53.65,97.39 53.99,97.88 54.54,98.43 55.04,98.61 56.28,98.61 56.81,98.52 58.12,98.75 58.61,98.66 59.11,98.81 59.45,99.3 59.96,99.66 60,99.7 61.56,99.7 61.97,99.77 63.02,99.59 64.27,99.81 65.52,99.59 66.77,99.81 68.02,99.59 69.27,99.81 70.53,99.59 71.78,99.81 73.03,99.59 74.28,99.81 75.53,99.59 76.78,99.81 78.03,99.59 79.28,99.81 80.53,99.59 81.78,99.81 83.03,99.59 84.28,99.81 85.53,99.59 86.78,99.81 87.79,99.63 89.11,99.86 91.57,100.97 92.37,101.53 93.01,102.44 93.74,102.95 94.32,103.54 95.25,103.91 96.34,103.91 96.83,103.83 97.93,104.02 99.18,103.8 100.43,104.02 101.03,103.92 101.66,104.03 102.18,104.33 104.18,106.32 104.55,107.6 104.47,108.01 104.68,109.2 104.46,110.45 104.73,111.98 104.53,113.12 104.51,113.23 104.73,114.48 104.51,115.73 104.73,116.98 104.51,118.23 104.73,119.48 104.51,120.73 104.73,121.99 104.53,123.17 104.6,123.59 104.73,124.32 104.73,124.59 104.78,124.88 104.71,125.26 104.71,125.51 104.61,126.07 104.87,127.56 105.2,127.88 106.21,130.3 106.47,130.56 107.1,131.47 107.48,132.66 107.48,132.82 107.37,133.47 107.51,134.28 107.51,134.28 107.63,134.96 107.52,135.61 107.69,136.58 107.69,139.15 108.04,139.65 108.26,140.89 108.6,141.96 108.69,142.08 109.27,143.88 109.26,143.92 109.14,144.61 109.34,145.76 109.22,146.42 109.38,147.28 108.96,149.61 109.3,151.55 109.86,152.11 110.15,152.32 110.72,153.12 111.76,153.85 112.49,154.89 114.53,156.32 115.99,158.4 117.06,159.16 117.85,160.27 120.34,162 121.14,162.16 122.62,161.9 125.82,162.46 128,162.08 130.52,162.52 133,162.09 133.02,162.08 133.02,162.08 133.5,162.17 134.62,162.17 135.44,162.31 135.45,162.3 137.01,162.58 140.13,162.31 141.82,161.12 142.59,160.03 143.25,159.56 arc(143.52,159.33) 143.75,159.07 145.13,157.09 arc(145.38,156.6) 145.46,156.06 145.46,155.01 arc(145.36,154.49) 145.06,154.04 143.89,152.87 arc(143.83,152.78) 143.81,152.68 143.81,152.34 arc(143.83,152.24) 143.88,152.15 144.14,151.89 arc(144.21,151.8) v2(144.23,151.69)
  BOTTOM w0.14: U42.BL37 143.82,151.46 arc(143.83,151.51) 143.86,151.56 143.95,151.65 arc(144,151.68) 144.05,151.69 v2(144.23,151.69)
TCP0_TX_N1_C: length 4.4
  TOP w0.079: 42.43,88.91 42.41,88.91 42.36,88.86 41.91,88.86 arc(41.82,88.88) 41.74,88.93 41.73,88.94 arc(41.65,89) 41.56,89.02 41.33,89.02 arc(41.19,88.99) 41.06,88.9 U9.C2
  TOP w0.14: 42.43,88.91 42.54,88.91 arc(42.61,88.9) 42.66,88.86 44.01,87.51 arc(44.06,87.48) 44.11,87.47 44.17,87.47 arc(44.23,87.48) 44.28,87.51 C264.2
TCP0_TX_P0: length 157.7
  TOP w0.14: C233.1 45.12,92.1 arc(45.19,92.14) 45.26,92.16 45.35,92.16 arc(45.45,92.14) 45.54,92.08 v1(45.75,91.87)
  IN4 w0.086: v2(142.65,151.66) 142.41,151.9 arc(142.39,151.91) 142.36,151.92 142.3,151.92 arc(142.19,151.94) 142.11,152 142.04,152.06 arc(141.98,152.15) 141.96,152.26 141.96,152.97 arc(141.98,153.08) 142.04,153.17 143.04,154.17 arc(143.17,154.33) 143.27,154.51 arc(143.3,154.64) 143.31,154.76 143.31,156.64 arc(143.3,156.77) 143.28,156.89 arc(143.18,157.17) 143.04,157.43 142.62,158.02 142.3,158.37 141.55,158.89 arc(141.46,158.96) 141.39,159.05 140.94,159.68 139.9,160.49 139.72,160.62 138.64,160.62 arc(138.64,160.62) 138.64,160.62 137.51,160.82 136.39,160.62 135.57,160.77 134.76,160.62 134.42,160.62 133.72,160.5 133.25,160.5 133.03,160.54 132.04,160.37 130.79,160.59 129.54,160.37 128.29,160.59 127.04,160.37 126.77,160.41 124.95,160.09 124.82,160.05 119.29,159.08 118.92,158.55 117.43,157.5 116.19,155.74 116,154.64 116.07,154.26 116.07,152.91 115.86,151.69 116.25,149.49 116.11,148.71 116.11,148.12 115.7,147.71 115.47,147.55 115.23,147.2 113.83,146.23 110.32,141.21 110.12,140.07 109.87,139.82 109.22,138.47 109.22,136.5 109.07,135.61 109.19,134.91 109,133.82 109,132.23 108.39,130.32 107.92,129.99 107.69,129.66 106.74,127.3 106.25,124.46 106.25,123.99 106.09,123.08 106.09,123.07 106.28,121.99 106.05,120.73 106.27,119.48 106.05,118.23 106.27,116.98 106.05,115.73 106.27,114.48 106.05,113.23 106.07,113.12 106.27,111.98 106.01,110.46 106.23,109.21 106.05,108.22 106.16,107.62 105.5,105.45 102.95,102.89 102.06,102.44 101.2,102.29 100.43,102.43 99.18,102.2 97.93,102.42 95.11,101.93 94.01,101.16 93.54,100.49 93.52,100.47 92.57,99.81 91.83,99.22 90.34,98.62 88.82,98.18 88.44,98.12 88.04,98.04 86.78,98.26 85.56,98.05 85.53,98.04 84.28,98.26 83.03,98.04 81.78,98.26 80.53,98.04 79.28,98.26 78.03,98.04 76.78,98.26 75.53,98.04 74.28,98.26 73.03,98.04 71.78,98.26 70.53,98.04 69.27,98.26 68.02,98.04 66.77,98.26 65.52,98.04 64.27,98.26 62.95,98.03 61.9,98.22 61.69,98.18 61.38,98.18 60.46,97.9 60.19,97.52 59.59,97.09 58.42,97.09 57.94,97.18 56.75,96.97 56.04,97.09 55.79,97.09 55.35,96.95 55.03,96.63 54.8,96.3 53.75,95.56 53.45,95.14 52.89,94.58 52.22,94.38 51.91,94.38 51.59,94.25 51.4,93.98 50.66,93.46 50.14,92.72 49.39,92.2 49.15,91.85 48.99,91.7 48.13,91.55 47.26,91.7 46.92,92.03 arc(46.73,92.16) 46.49,92.21 46.2,92.21 arc(46.1,92.19) 46.02,92.13 v1(45.75,91.87)
  BOTTOM w0.14: U42.BP37 142.51,151.61 arc(142.58,151.65) v2(142.65,151.66)
TCP0_TX_P0_C: length 4
  TOP w0.079: U9.J1 41.31,91.54 arc(41.2,91.42) 41.31,91.31 41.57,91.31 arc(41.66,91.33) 41.74,91.38 41.75,91.39 arc(41.83,91.45) 41.92,91.46 42.36,91.46 42.41,91.41 42.43,91.41
  TOP w0.14: 42.43,91.41 42.95,91.41 arc(43.22,91.47) 43.45,91.62 43.91,92.08 arc(44,92.14) 44.09,92.16 44.14,92.16 arc(44.23,92.14) 44.3,92.09 C233.2
TCP0_TX_P1: length 170.1
  TOP w0.14: C274.1 45.11,87.14 arc(45.19,87.19) 45.28,87.21 45.42,87.21 arc(45.52,87.19) 45.6,87.13 v1(45.82,86.91)
  IN4 w0.086: v1(45.82,86.91) 45.56,87.17 45.54,87.19 arc(45.52,87.2) 45.51,87.21 arc(45.49,87.22) 45.47,87.23 arc(45.45,87.23) 45.43,87.23 45.37,87.23 arc(45.23,87.26) 45.11,87.34 45.04,87.4 44.58,87.73 44.09,88.43 44.09,88.66 43.97,89.3 44.18,90.47 43.96,91.72 44.13,92.68 44.09,92.92 44.09,93.29 44.17,93.49 44.78,94.09 45.08,94.24 45.91,94.39 46.7,94.25 47,94.3 47.32,94.3 47.63,94.18 47.73,94.08 47.98,93.98 48.56,93.98 49.06,94.16 49.38,94.62 50.19,95.19 50.3,95.34 50.4,95.48 50.88,95.96 51.29,96.1 51.77,96.1 52.12,96.22 52.54,96.82 53.53,97.51 53.86,97.98 54.45,98.57 55.01,98.78 56.29,98.78 56.81,98.69 58.12,98.92 58.6,98.83 59.01,98.96 59.33,99.42 59.85,99.79 59.93,99.87 61.55,99.87 61.97,99.94 63.02,99.76 64.27,99.98 65.52,99.76 66.77,99.98 68.02,99.76 69.27,99.98 70.53,99.76 71.78,99.98 73.03,99.76 74.28,99.98 75.53,99.76 76.78,99.98 78.03,99.76 79.28,99.98 80.53,99.76 81.78,99.98 83.03,99.76 84.28,99.98 85.53,99.76 86.78,99.98 87.79,99.8 89.06,100.02 91.48,101.11 92.25,101.65 92.89,102.56 93.63,103.08 94.23,103.68 95.22,104.08 96.35,104.08 96.83,104 97.93,104.19 99.18,103.97 100.43,104.19 101.03,104.08 101.61,104.18 102.08,104.46 104.03,106.4 104.38,107.61 104.31,108.01 104.52,109.2 104.29,110.45 104.56,111.98 104.36,113.12 104.34,113.23 104.56,114.48 104.34,115.73 104.56,116.98 104.34,118.23 104.56,119.48 104.34,120.73 104.57,121.99 104.36,123.17 104.43,123.59 104.56,124.33 104.56,124.61 104.61,124.88 104.55,125.25 104.55,125.49 104.44,126.07 104.72,127.64 105.06,127.97 106.07,130.4 106.34,130.67 106.95,131.54 107.31,132.69 107.31,132.8 107.2,133.47 107.35,134.31 107.35,134.31 107.47,134.96 107.35,135.61 107.52,136.6 107.52,139.2 107.88,139.72 108.1,140.93 108.45,142.03 108.54,142.16 109.1,143.89 108.97,144.61 109.18,145.76 109.06,146.42 109.21,147.28 108.8,149.61 109.15,151.63 109.75,152.24 110.04,152.44 110.6,153.24 111.64,153.97 112.37,155.01 114.41,156.44 115.87,158.52 116.95,159.27 117.73,160.39 120.27,162.16 121.14,162.33 122.62,162.07 125.82,162.63 125.85,162.63 128,162.25 130.52,162.69 133.02,162.25 133.48,162.33 134.61,162.33 135.48,162.49 135.49,162.48 137,162.74 140.19,162.47 141.93,161.24 142.7,160.14 143.35,159.7 arc(143.64,159.45) 143.88,159.16 145.27,157.18 arc(145.53,156.65) 145.63,156.06 145.63,155.01 arc(145.51,154.42) 145.17,153.92 144.01,152.76 arc(143.98,152.72) 143.97,152.68 143.97,152.48 arc(143.98,152.44) 144.01,152.41 144.08,152.36 arc(144.1,152.34) 144.13,152.34 v2(144.23,152.34)
  BOTTOM w0.14: v2(144.23,152.34) 143.92,152.03 arc(143.87,152) U42.BL38
TCP0_TX_P1_C: length 4.4
  TOP w0.079: 42.43,88.65 42.41,88.65 42.36,88.7 41.93,88.7 arc(41.83,88.68) 41.75,88.62 41.74,88.61 arc(41.65,88.55) 41.55,88.53 41.27,88.53 41.2,88.6 41.2,88.71 41.27,88.78 U9.C1
  TOP w0.14: 42.43,88.65 42.5,88.65 43.82,87.32 arc(43.96,87.24) 44.11,87.21 44.13,87.21 arc(44.23,87.19) 44.31,87.13 C274.2
TCP0_TXRX_N0: length 155.3
  TOP w0.14: C239.1 45.11,90.85 arc(45.17,90.8) 45.25,90.79 45.4,90.79 arc(45.48,90.8) 45.55,90.85 v1(45.78,91.08)
  IN4 w0.086: v1(45.78,91.08) 46.01,90.85 arc(46.14,90.77) 46.28,90.74 46.61,90.74 47.26,90.62 48.54,90.85 49.79,90.63 51.27,90.89 52.13,91.42 52.38,91.78 53.6,92.64 54.31,93.64 54.72,93.93 54.91,94.38 54.91,95.16 55.08,95.64 55.75,96.31 56.22,96.45 56.73,96.36 57.94,96.57 58.37,96.5 59.9,96.5 60.04,96.63 61.09,97.37 61.67,97.59 61.93,97.59 62.89,97.42 64.27,97.66 65.52,97.44 66.77,97.66 68.02,97.44 69.27,97.66 70.53,97.44 71.78,97.66 73.03,97.44 74.28,97.66 75.53,97.44 76.78,97.66 78.03,97.44 79.28,97.66 80.53,97.44 81.78,97.66 83.03,97.44 84.28,97.66 85.53,97.44 86.78,97.66 88.04,97.44 88.95,97.6 89.77,97.81 90.57,98.07 92.13,98.7 92.91,99.31 92.93,99.33 93.97,100.06 94.42,100.71 95.36,101.37 97.93,101.82 99.18,101.6 100.43,101.82 101.32,101.67 102.52,101.88 103.25,102.26 106.12,105.13 106.77,107.59 106.66,108.22 106.83,109.21 106.61,110.46 106.88,111.98 106.68,113.12 106.66,113.23 106.88,114.48 106.66,115.73 106.88,116.98 106.66,118.23 106.88,119.48 106.66,120.73 106.88,121.99 106.81,122.36 106.69,123.05 106.77,123.49 106.84,123.89 106.84,124.41 107.25,126.77 107.93,128.58 108.91,129.98 109.59,132.13 109.59,133.75 109.8,134.91 109.67,135.61 109.84,136.54 109.84,138.37 110.47,139.57 110.66,139.76 110.87,140.88 114.38,145.88 115.65,146.78 115.86,147.06 115.99,147.16 116.73,147.9 116.73,148.8 116.85,149.49 116.53,151.3 117.34,155.88 119.32,157.87 120.47,158.68 126.83,159.8 127.04,159.76 128.29,159.98 129.54,159.76 130.79,159.98 132.04,159.76 132.86,159.91 133.77,159.91 134.42,160.02 134.81,160.02 135.57,160.16 140.44,159.3 140.49,159.27 140.88,158.7 arc(141.13,158.41) 141.42,158.17 141.78,157.92 arc(141.81,157.89) 141.84,157.86 142.19,157.52 arc(142.25,157.43) 142.27,157.32 142.27,155.59 arc(142.32,155.46) 142.44,155.41 arc(142.5,155.42) 142.54,155.45 v2(142.74,155.65)
  BOTTOM w0.079: U42.BL40 143.85,153.32 arc(143.93,153.38) 144.02,153.4 arc(144.03,153.4) 144.04,153.4 arc(144.22,153.49) 144.3,153.69 144.3,154.44 arc(144.28,154.56) 144.21,154.67 143.43,155.44 143.04,155.44 arc(142.95,155.46) 142.86,155.52 v2(142.74,155.65)
TCP0_TXRX_N0_C: length 3.8
  TOP w0.079: U9.G2 41.05,90.73 arc(41.16,90.81) 41.3,90.83 41.56,90.83 arc(41.64,90.82) 41.7,90.78 41.71,90.77 arc(41.78,90.72) 41.85,90.71 42.36,90.71 42.41,90.76 42.43,90.76
  TOP w0.14: C239.2 44.31,90.85 arc(44.21,90.78) 44.09,90.76 42.43,90.76
TCP0_TXRX_N1: length 164.3
  TOP w0.14: v1(45.82,89.39) 45.59,89.16 arc(45.52,89.12) 45.43,89.1 45.28,89.1 arc(45.21,89.11) 45.15,89.15 C254.1
  IN4 w0.086: v1(45.82,89.39) 45.92,89.28 arc(45.98,89.16) 45.92,89.03 45.92,89.03 arc(45.84,88.98) 45.75,88.96 45.49,88.96 arc(45.2,89.08) 45.08,89.37 45.08,89.76 arc(45.09,89.87) 45.1,89.99 45.15,90.24 arc(45.15,90.31) 45.15,90.39 44.94,91.56 45.1,92.52 45.05,92.85 45.05,92.99 45.08,93.08 45.26,93.25 45.38,93.31 46.03,93.42 46.78,93.29 47.07,93.29 47.75,93.05 48.33,92.94 49.08,93.08 49.63,93.4 49.73,93.51 50.05,93.96 50.86,94.53 51.11,94.89 51.28,95.06 51.6,95.16 52.04,95.16 52.59,95.35 52.86,95.63 53.26,96.19 54.28,96.91 54.49,97.2 54.99,97.7 55.34,97.85 56.1,97.85 56.75,97.74 57.94,97.95 58.49,97.85 59.27,97.85 59.69,98.15 60.06,98.67 60.33,98.94 61.63,98.94 61.97,99 63.02,98.82 64.27,99.04 65.52,98.82 66.77,99.04 68.02,98.82 69.27,99.04 70.53,98.82 71.78,99.04 73.03,98.82 74.28,99.04 75.53,98.82 76.78,99.04 78.03,98.82 79.28,99.04 80.53,98.82 81.78,99.04 83.03,98.82 84.28,99.04 85.53,98.82 86.78,99.04 87.8,98.86 89.42,99.14 91.34,99.87 92.96,101.01 93.6,101.92 94.45,102.52 94.7,102.77 95.55,103.1 96.35,103.1 96.84,103.02 97.89,103.2 99.18,102.98 100.43,103.2 101.06,103.09 101.87,103.23 102.61,103.66 104.85,105.9 105.34,107.6 105.25,108.06 105.45,109.2 105.23,110.46 105.48,111.84 105.5,111.98 105.42,112.43 105.3,113.12 105.28,113.23 105.42,114.03 105.5,114.48 105.42,114.93 105.28,115.73 105.42,116.53 105.5,116.98 105.42,117.43 105.28,118.23 105.42,119.03 105.5,119.48 105.28,120.73 105.5,121.99 105.31,123.1 105.39,123.59 105.49,124.12 105.49,124.53 105.55,124.88 105.49,125.23 105.49,125.48 105.43,125.83 105.65,127.09 105.79,127.23 106.93,129.9 107.38,130.54 107.75,130.8 108.16,132.1 108.24,132.6 108.24,133.91 108.42,134.91 108.29,135.61 108.46,136.57 108.46,138.62 109.24,140.52 109.35,141.16 109.46,141.79 109.75,142.2 110.06,143.98 109.94,144.7 110.13,145.8 110.03,146.38 110.17,147.17 109.74,149.61 109.87,150.39 110.01,151.17 110.28,151.44 110.68,151.72 111.27,152.57 112.31,153.29 113.04,154.33 115.05,155.74 116.51,157.82 117.62,158.6 118.35,159.64 119.74,160.62 122.73,161.15 122.76,161.13 125.85,161.67 127.95,161.3 128.29,161.36 129.54,161.14 130.79,161.36 132.04,161.14 133.02,161.31 133.32,161.26 133.66,161.26 134.44,161.4 134.7,161.4 134.7,161.4 135.71,161.58 136.58,161.43 138.2,161.71 139.99,161.4 140.07,161.4 141.26,160.56 141.99,159.51 142.71,159.01 arc(142.97,158.79) 143.2,158.52 143.93,157.48 arc(144.04,157.27) 144.07,157.03 144.07,155.87 arc(144.1,155.75) 144.17,155.64 144.28,155.53 arc(144.36,155.47) 144.47,155.45 144.68,155.45 arc(144.73,155.44) 144.76,155.42 144.8,155.38 arc(144.82,155.35) 144.83,155.32 v2(144.83,155.17)
  BOTTOM w0.079: v2(144.83,155.17) 144.83,155.22 arc(144.85,155.33) 144.91,155.42 144.91,155.42 arc(144.96,155.45) 145.01,155.46 145.12,155.46 arc(145.22,155.43) 145.26,155.33 145.26,154.71 arc(145.22,154.51) 145.1,154.34 arc(144.99,154.18) 144.96,153.99 144.96,153.83 arc(144.91,153.69) 144.8,153.6 arc(144.79,153.59) 144.78,153.59 144.74,153.58 arc(144.67,153.57) 144.61,153.59 arc(144.6,153.6) 144.59,153.61 arc(144.56,153.67) 144.54,153.74 144.54,153.78 arc(144.56,153.87) U42.BK41
TCP0_TXRX_N1_C: length 4
  TOP w0.079: 42.43,89.83 42.41,89.83 42.36,89.78 41.87,89.78 arc(41.79,89.79) 41.72,89.84 41.71,89.85 arc(41.64,89.9) 41.56,89.91 41.3,89.91 arc(41.16,89.89) 41.05,89.81 U9.E2
  TOP w0.14: 42.43,89.83 42.89,89.83 arc(43.16,89.77) 43.38,89.62 43.77,89.24 arc(43.89,89.16) 44.04,89.13 44.16,89.13 arc(44.23,89.14) 44.3,89.19 C254.2
