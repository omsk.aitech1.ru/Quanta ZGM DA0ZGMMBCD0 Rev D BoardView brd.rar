# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
C0201
  rect 0.203x0.381 smd: 1(-0.225,0) 2(0.225,0)
C0402
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
C0402_2
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
C0603
  rect 0.686x0.813 smd: 1(0.6,0) 2(-0.6,0)
C0805
  rect 0.864x1.372 smd: 1(0.88,0) 2(-0.88,0)
C1206
  rect 1.219x1.626 smd: 1(1.4,0) 2(-1.4,0)
C3528
  rect 1.6x2.591 smd: 1(1.5,0) 2(-1.5,0)
CC7343
  rect 2.413x2.819 smd: 1(-3.2,0) 2(3.2,0)
CHOKE-PCMB051H-3R3MS
  rect 1.905x2.489 smd: 1(-2.047,0) 2(2.047,0)
CLIP-39X35-100X18-3P
  rect 2.54x0.457 smd: 1(-1.975,0) 3(1.975,0)
  rect 0.991x0.889 smd: 2(0,0)
D-0_6X0_3-0_34H
  rect 0.229x0.33 smd: 1(-0.21,0) 2(0.21,0)
D-1_2X0_8-0_7H
  rect 0.61x0.787 smd: 1(-0.85,0) 2(0.85,0)
D-1_2X0_8-0_65H
  rect 0.533x0.508 smd: 1(-0.735,0) 2(0.735,0)
D-1_85X1_25-2P-0_95H
  rect 0.787x0.889 smd: 1(-1.07,0) 2(1.07,0)
D-3_8X2_5
  rect 1.6x1.905 smd: 1(-2.15,0) 2(2.15,0)
D-SOD323-1_7X1_25-PMEG4005AEA
  rect 0.61x0.61 smd: 1(-1.1,0) 2(1.1,0)
D-SOD323-1_85X1_25-0_95H
  rect 0.559x0.813 smd: 1(-1.15,0) 2(1.15,0)
DCJK-2DC3207-000111F-3P
  round 1.803 hole 1.803 unplated: (-5.75,6.7) (5.75,6.7)
  round 2.591 hole 2.007: 1(0,8.1)
  oval 1.245x3.505 hole 0.66x2.896: 2(-2.925,6.9) 3(2.925,6.9)
  oval 1.194x2.21 hole 0.61x1.6: 4(8.25,2.5)
  oval 1.295x4.902 hole 0.711x4.293: 5(8.8,7.05) 6(-8.8,7.05)
  oval 1.295x2.997 hole 0.711x2.388: 7(8.25,-1.15) 8(-8.25,-1.15) 9(8.25,-5.25) 10(-8.25,-5.25)
DDR4-D4AS0-26001-1P40-STD-260P-SMT
  round 1.702 hole 1.702 unplated: (-34.4,0)
  round 1.194 hole 1.194 unplated: (34.4,0)
  rect 0.254x1.753 smd: 1(-33.375,-4.1) 2(-33.125,4.1) 3(-32.875,-4.1) 4(-32.625,4.1) 5(-32.375,-4.1) 6(-32.125,4.1) 7(-31.875,-4.1) 8(-31.625,4.1) 9(-31.375,-4.1) 10(-31.125,4.1) 11(-30.875,-4.1) 12(-30.625,4.1) 13(-30.375,-4.1) 14(-30.125,4.1) 15(-29.875,-4.1) 16(-29.625,4.1) 17(-29.375,-4.1) 18(-29.125,4.1) 19(-28.875,-4.1) 20(-28.625,4.1) 21(-28.375,-4.1) 22(-28.125,4.1) 23(-27.875,-4.1) 24(-27.625,4.1) 25(-27.375,-4.1) 26(-27.125,4.1) 27(-26.875,-4.1) 28(-26.625,4.1) 29(-26.375,-4.1) 30(-26.125,4.1) 31(-25.875,-4.1) 32(-25.625,4.1) 33(-25.375,-4.1) 34(-25.125,4.1) 35(-24.875,-4.1) 36(-24.625,4.1) 37(-24.375,-4.1) 38(-24.125,4.1) 39(-23.875,-4.1) 40(-23.625,4.1) 41(-23.375,-4.1) 42(-23.125,4.1) 43(-22.875,-4.1) 44(-22.625,4.1) 45(-22.375,-4.1) 46(-22.125,4.1) 47(-21.875,-4.1) 48(-21.625,4.1) 49(-21.375,-4.1) 50(-21.125,4.1) 51(-20.875,-4.1) 52(-20.625,4.1) 53(-20.375,-4.1) 54(-20.125,4.1) 55(-19.875,-4.1) 56(-19.625,4.1) 57(-19.375,-4.1) 58(-19.125,4.1) 59(-18.875,-4.1) 60(-18.625,4.1) 61(-18.375,-4.1) 62(-18.125,4.1) 63(-17.875,-4.1) 64(-17.625,4.1) 65(-17.375,-4.1) 66(-17.125,4.1) 67(-16.875,-4.1) 68(-16.625,4.1) 69(-16.375,-4.1) 70(-16.125,4.1) 71(-15.875,-4.1) 72(-15.625,4.1) 73(-15.375,-4.1) 74(-15.125,4.1) 75(-14.875,-4.1) 76(-14.625,4.1) 77(-14.375,-4.1) 78(-14.125,4.1) 79(-13.875,-4.1) 80(-13.625,4.1) 81(-13.375,-4.1) 82(-13.125,4.1) 83(-12.875,-4.1) 84(-12.625,4.1) 85(-12.375,-4.1) 86(-12.125,4.1) 87(-11.875,-4.1) 88(-11.625,4.1) 89(-11.375,-4.1) 90(-11.125,4.1) 91(-10.875,-4.1) 92(-10.625,4.1) 93(-10.375,-4.1) 94(-10.125,4.1) 95(-9.875,-4.1) 96(-9.625,4.1) 97(-9.375,-4.1) 98(-9.125,4.1) 99(-8.875,-4.1) 100(-8.625,4.1) 101(-8.375,-4.1) 102(-8.125,4.1) 103(-7.875,-4.1) 104(-7.625,4.1) 105(-7.375,-4.1) 106(-7.125,4.1) 107(-6.875,-4.1) 108(-6.625,4.1) 109(-6.375,-4.1) 110(-6.125,4.1) 111(-5.875,-4.1) 112(-5.625,4.1) 113(-5.375,-4.1) 114(-5.125,4.1) 115(-4.875,-4.1) 116(-4.625,4.1) 117(-4.375,-4.1) 118(-4.125,4.1) 119(-3.875,-4.1) 120(-3.625,4.1) 121(-3.375,-4.1) 122(-3.125,4.1) 123(-2.875,-4.1) 124(-2.625,4.1) 125(-2.375,-4.1) 126(-2.125,4.1) 127(-1.875,-4.1) 128(-1.625,4.1) 129(-1.375,-4.1) 130(-1.125,4.1) 131(-0.875,-4.1) 132(-0.625,4.1) 133(-0.375,-4.1) 134(-0.125,4.1) 135(0.125,-4.1) 136(0.375,4.1) 137(0.625,-4.1) 138(0.875,4.1) 139(1.125,-4.1) 140(1.375,4.1) 141(1.625,-4.1) 142(1.875,4.1) 143(2.125,-4.1) 144(2.375,4.1) 145(4.625,-4.1) 146(4.875,4.1) 147(5.125,-4.1) 148(5.375,4.1) 149(5.625,-4.1) 150(5.875,4.1) 151(6.125,-4.1) 152(6.375,4.1) 153(6.625,-4.1) 154(6.875,4.1) 155(7.125,-4.1) 156(7.375,4.1) 157(7.625,-4.1) 158(7.875,4.1) 159(8.125,-4.1) 160(8.375,4.1) 161(8.625,-4.1) 162(8.875,4.1) 163(9.125,-4.1) 164(9.375,4.1) 165(9.625,-4.1) 166(9.875,4.1) 167(10.125,-4.1) 168(10.375,4.1) 169(10.625,-4.1) 170(10.875,4.1) 171(11.125,-4.1) 172(11.375,4.1) 173(11.625,-4.1) 174(11.875,4.1) 175(12.125,-4.1) 176(12.375,4.1) 177(12.625,-4.1) 178(12.875,4.1) 179(13.125,-4.1) 180(13.375,4.1) 181(13.625,-4.1) 182(13.875,4.1) 183(14.125,-4.1) 184(14.375,4.1) 185(14.625,-4.1) 186(14.875,4.1) 187(15.125,-4.1) 188(15.375,4.1) 189(15.625,-4.1) 190(15.875,4.1) 191(16.125,-4.1) 192(16.375,4.1) 193(16.625,-4.1) 194(16.875,4.1) 195(17.125,-4.1) 196(17.375,4.1) 197(17.625,-4.1) 198(17.875,4.1) 199(18.125,-4.1) 200(18.375,4.1) 201(18.625,-4.1) 202(18.875,4.1) 203(19.125,-4.1) 204(19.375,4.1) 205(19.625,-4.1) 206(19.875,4.1) 207(20.125,-4.1) 208(20.375,4.1) 209(20.625,-4.1) 210(20.875,4.1) 211(21.125,-4.1) 212(21.375,4.1) 213(21.625,-4.1) 214(21.875,4.1) 215(22.125,-4.1) 216(22.375,4.1) 217(22.625,-4.1) 218(22.875,4.1) 219(23.125,-4.1) 220(23.375,4.1) 221(23.625,-4.1) 222(23.875,4.1) 223(24.125,-4.1) 224(24.375,4.1) 225(24.625,-4.1) 226(24.875,4.1) 227(25.125,-4.1) 228(25.375,4.1) 229(25.625,-4.1) 230(25.875,4.1) 231(26.125,-4.1) 232(26.375,4.1) 233(26.625,-4.1) 234(26.875,4.1) 235(27.125,-4.1) 236(27.375,4.1) 237(27.625,-4.1) 238(27.875,4.1) 239(28.125,-4.1) 240(28.375,4.1) 241(28.625,-4.1) 242(28.875,4.1) 243(29.125,-4.1) 244(29.375,4.1) 245(29.625,-4.1) 246(29.875,4.1) 247(30.125,-4.1) 248(30.375,4.1) 249(30.625,-4.1) 250(30.875,4.1) 251(31.125,-4.1) 252(31.375,4.1) 253(31.625,-4.1) 254(31.875,4.1) 255(32.125,-4.1) 256(32.375,4.1) 257(32.625,-4.1) 258(32.875,4.1) 259(33.125,-4.1) 260(33.375,4.1)
  rect 3.505x4.597 smd: 261(-33.8,12) 262(33.8,12)
DDR4-D4AS0-26001-1P80-STD-260P-SMT
  round 1.702 hole 1.702 unplated: (-34.4,0)
  round 1.194 hole 1.194 unplated: (34.4,0)
  rect 0.254x1.753 smd: 1(-33.375,-4.1) 2(-33.125,4.1) 3(-32.875,-4.1) 4(-32.625,4.1) 5(-32.375,-4.1) 6(-32.125,4.1) 7(-31.875,-4.1) 8(-31.625,4.1) 9(-31.375,-4.1) 10(-31.125,4.1) 11(-30.875,-4.1) 12(-30.625,4.1) 13(-30.375,-4.1) 14(-30.125,4.1) 15(-29.875,-4.1) 16(-29.625,4.1) 17(-29.375,-4.1) 18(-29.125,4.1) 19(-28.875,-4.1) 20(-28.625,4.1) 21(-28.375,-4.1) 22(-28.125,4.1) 23(-27.875,-4.1) 24(-27.625,4.1) 25(-27.375,-4.1) 26(-27.125,4.1) 27(-26.875,-4.1) 28(-26.625,4.1) 29(-26.375,-4.1) 30(-26.125,4.1) 31(-25.875,-4.1) 32(-25.625,4.1) 33(-25.375,-4.1) 34(-25.125,4.1) 35(-24.875,-4.1) 36(-24.625,4.1) 37(-24.375,-4.1) 38(-24.125,4.1) 39(-23.875,-4.1) 40(-23.625,4.1) 41(-23.375,-4.1) 42(-23.125,4.1) 43(-22.875,-4.1) 44(-22.625,4.1) 45(-22.375,-4.1) 46(-22.125,4.1) 47(-21.875,-4.1) 48(-21.625,4.1) 49(-21.375,-4.1) 50(-21.125,4.1) 51(-20.875,-4.1) 52(-20.625,4.1) 53(-20.375,-4.1) 54(-20.125,4.1) 55(-19.875,-4.1) 56(-19.625,4.1) 57(-19.375,-4.1) 58(-19.125,4.1) 59(-18.875,-4.1) 60(-18.625,4.1) 61(-18.375,-4.1) 62(-18.125,4.1) 63(-17.875,-4.1) 64(-17.625,4.1) 65(-17.375,-4.1) 66(-17.125,4.1) 67(-16.875,-4.1) 68(-16.625,4.1) 69(-16.375,-4.1) 70(-16.125,4.1) 71(-15.875,-4.1) 72(-15.625,4.1) 73(-15.375,-4.1) 74(-15.125,4.1) 75(-14.875,-4.1) 76(-14.625,4.1) 77(-14.375,-4.1) 78(-14.125,4.1) 79(-13.875,-4.1) 80(-13.625,4.1) 81(-13.375,-4.1) 82(-13.125,4.1) 83(-12.875,-4.1) 84(-12.625,4.1) 85(-12.375,-4.1) 86(-12.125,4.1) 87(-11.875,-4.1) 88(-11.625,4.1) 89(-11.375,-4.1) 90(-11.125,4.1) 91(-10.875,-4.1) 92(-10.625,4.1) 93(-10.375,-4.1) 94(-10.125,4.1) 95(-9.875,-4.1) 96(-9.625,4.1) 97(-9.375,-4.1) 98(-9.125,4.1) 99(-8.875,-4.1) 100(-8.625,4.1) 101(-8.375,-4.1) 102(-8.125,4.1) 103(-7.875,-4.1) 104(-7.625,4.1) 105(-7.375,-4.1) 106(-7.125,4.1) 107(-6.875,-4.1) 108(-6.625,4.1) 109(-6.375,-4.1) 110(-6.125,4.1) 111(-5.875,-4.1) 112(-5.625,4.1) 113(-5.375,-4.1) 114(-5.125,4.1) 115(-4.875,-4.1) 116(-4.625,4.1) 117(-4.375,-4.1) 118(-4.125,4.1) 119(-3.875,-4.1) 120(-3.625,4.1) 121(-3.375,-4.1) 122(-3.125,4.1) 123(-2.875,-4.1) 124(-2.625,4.1) 125(-2.375,-4.1) 126(-2.125,4.1) 127(-1.875,-4.1) 128(-1.625,4.1) 129(-1.375,-4.1) 130(-1.125,4.1) 131(-0.875,-4.1) 132(-0.625,4.1) 133(-0.375,-4.1) 134(-0.125,4.1) 135(0.125,-4.1) 136(0.375,4.1) 137(0.625,-4.1) 138(0.875,4.1) 139(1.125,-4.1) 140(1.375,4.1) 141(1.625,-4.1) 142(1.875,4.1) 143(2.125,-4.1) 144(2.375,4.1) 145(4.625,-4.1) 146(4.875,4.1) 147(5.125,-4.1) 148(5.375,4.1) 149(5.625,-4.1) 150(5.875,4.1) 151(6.125,-4.1) 152(6.375,4.1) 153(6.625,-4.1) 154(6.875,4.1) 155(7.125,-4.1) 156(7.375,4.1) 157(7.625,-4.1) 158(7.875,4.1) 159(8.125,-4.1) 160(8.375,4.1) 161(8.625,-4.1) 162(8.875,4.1) 163(9.125,-4.1) 164(9.375,4.1) 165(9.625,-4.1) 166(9.875,4.1) 167(10.125,-4.1) 168(10.375,4.1) 169(10.625,-4.1) 170(10.875,4.1) 171(11.125,-4.1) 172(11.375,4.1) 173(11.625,-4.1) 174(11.875,4.1) 175(12.125,-4.1) 176(12.375,4.1) 177(12.625,-4.1) 178(12.875,4.1) 179(13.125,-4.1) 180(13.375,4.1) 181(13.625,-4.1) 182(13.875,4.1) 183(14.125,-4.1) 184(14.375,4.1) 185(14.625,-4.1) 186(14.875,4.1) 187(15.125,-4.1) 188(15.375,4.1) 189(15.625,-4.1) 190(15.875,4.1) 191(16.125,-4.1) 192(16.375,4.1) 193(16.625,-4.1) 194(16.875,4.1) 195(17.125,-4.1) 196(17.375,4.1) 197(17.625,-4.1) 198(17.875,4.1) 199(18.125,-4.1) 200(18.375,4.1) 201(18.625,-4.1) 202(18.875,4.1) 203(19.125,-4.1) 204(19.375,4.1) 205(19.625,-4.1) 206(19.875,4.1) 207(20.125,-4.1) 208(20.375,4.1) 209(20.625,-4.1) 210(20.875,4.1) 211(21.125,-4.1) 212(21.375,4.1) 213(21.625,-4.1) 214(21.875,4.1) 215(22.125,-4.1) 216(22.375,4.1) 217(22.625,-4.1) 218(22.875,4.1) 219(23.125,-4.1) 220(23.375,4.1) 221(23.625,-4.1) 222(23.875,4.1) 223(24.125,-4.1) 224(24.375,4.1) 225(24.625,-4.1) 226(24.875,4.1) 227(25.125,-4.1) 228(25.375,4.1) 229(25.625,-4.1) 230(25.875,4.1) 231(26.125,-4.1) 232(26.375,4.1) 233(26.625,-4.1) 234(26.875,4.1) 235(27.125,-4.1) 236(27.375,4.1) 237(27.625,-4.1) 238(27.875,4.1) 239(28.125,-4.1) 240(28.375,4.1) 241(28.625,-4.1) 242(28.875,4.1) 243(29.125,-4.1) 244(29.375,4.1) 245(29.625,-4.1) 246(29.875,4.1) 247(30.125,-4.1) 248(30.375,4.1) 249(30.625,-4.1) 250(30.875,4.1) 251(31.125,-4.1) 252(31.375,4.1) 253(31.625,-4.1) 254(31.875,4.1) 255(32.125,-4.1) 256(32.375,4.1) 257(32.625,-4.1) 258(32.875,4.1) 259(33.125,-4.1) 260(33.375,4.1)
  rect 2.007x3.505 smd: 261(-37.75,12) 262(37.75,8)
DFN6-1_4X1-5
  rect 0.533x0.254 smd: 1(0.362,-0.5) 2(0.362,0) 3(0.362,0.5) 4(-0.362,0.5) 5(-0.362,0) 6(-0.362,-0.5)
DFN10-3X3-5-11P-G5318
  rect 0.254x0.711 smd: 1(-1,-1.5) 2(-0.5,-1.5) 3(0,-1.5) 4(0.5,-1.5) 5(1,-1.5) 6(1,1.5) 7(0.5,1.5) 8(0,1.5) 9(-0.5,1.5) 10(-1,1.5)
  rect 2.591x1.6 smd: 11(0,0)
DFN14-3X2-4-15P-0_85H
  rect 0.203x0.711 smd: 1(-1.2,-1) 2(-0.8,-1) 3(-0.4,-1) 4(0,-1) 5(0.4,-1) 6(0.8,-1) 7(1.2,-1) 8(1.2,1) 9(0.8,1) 10(0.4,1) 11(0,1) 12(-0.4,1) 13(-0.8,1) 14(-1.2,1)
  rect 2.591x0.914 smd: 15(0,0)
DFN1006-3-1X0_6-0_55H-3P-SMT
  rect 0.508x0.178 smd: 1(0.401,0.187) 2(0.401,-0.187)
  rect 0.254x0.508 smd: 3(-0.275,0)
DP-C17732-12023-L-20P-SMT
  round 1.041 hole 1.041 unplated: (-3.9,0) (3.9,0)
  round 0.787 hole 0.559: 1(-2.7,-0.6) 3(-2.1,0.4) 5(-1.6,-0.6) 7(-1,0.4) 9(-0.5,-0.6) 11(0.5,-0.6) 13(1,0.4) 15(1.6,-0.6) 17(2.1,0.4) 19(2.7,-0.6)
  rect 0.406x1.6 smd: 2(-2.7,2) 4(-2.1,2) 6(-1.5,2) 8(-0.9,2) 10(-0.3,2) 12(0.3,2) 14(0.9,2) 16(1.5,2) 18(2.1,2) 20(2.7,2)
  oval 1.295x2.489 hole 0.787x2.007: 21(-5.6,-9.63) 23(5.6,-9.63)
  oval 1.295x2.388 hole 0.787x1.905: 22(-5.6,-0.38) 24(5.6,-0.38)
ECAP6_3X4_6-7_3-2P
  rect 3.505x0.991 smd: 1(2.75,0) 2(-2.75,0)
ECAP6_3X7_7-7_8
  rect 3.2x0.991 smd: 1(2.6,0) 2(-2.6,0)
ESD10-2_5X1-5-9P-AZ1143
  rect 0.254x0.686 smd: 1(-1,-0.437) 2(-0.5,-0.437) 4(0.5,-0.437) 5(1,-0.437) 6(1,0.437) 7(0.5,0.437) 9(-0.5,0.437) 10(-1,0.437)
  rect 0.381x1.549 smd: 3(0,0)
ESD-1X0_6-2P
  rect 0.559x0.61 smd: 1(-0.425,0) 2(0.425,0)
FILTER-NFG0QHB372HS2D-4P-SMT
  rect 0.203x0.229 smd: 1(-0.199,0.225) 2(0.199,0.225) 3(0.199,-0.225) 4(-0.199,-0.225)
FILTER-RFL11T2SA0BR-6P
  rect 0.508x0.33 smd: 1(-0.575,0.288) 2(0.575,0.288) 3(0.575,-0.288) 4(-0.575,-0.288)
  rect 0.279x0.457 smd: 5(0,0.475) 6(0,-0.475)
FPC-51695-0450M-V01-45P-L
  rect 0.305x0.61 smd: 1(-11,2.85) 2(-10.5,2.85) 3(-10,2.85) 4(-9.5,2.85) 5(-9,2.85) 6(-8.5,2.85) 7(-8,2.85) 8(-7.5,2.85) 9(-7,2.85) 10(-6.5,2.85) 11(-6,2.85) 12(-5.5,2.85) 13(-5,2.85) 14(-4.5,2.85) 15(-4,2.85) 16(-3.5,2.85) 17(-3,2.85) 18(-2.5,2.85) 19(-2,2.85) 20(-1.5,2.85) 21(-1,2.85) 22(-0.5,2.85) 23(0,2.85) 24(0.5,2.85) 25(1,2.85) 26(1.5,2.85) 27(2,2.85) 28(2.5,2.85) 29(3,2.85) 30(3.5,2.85) 31(4,2.85) 32(4.5,2.85) 33(5,2.85) 34(5.5,2.85) 35(6,2.85) 36(6.5,2.85) 37(7,2.85) 38(7.5,2.85) 39(8,2.85) 40(8.5,2.85) 41(9,2.85) 42(9.5,2.85) 43(10,2.85) 44(10.5,2.85) 45(11,2.85)
  rect 0.406x0.787 smd: 46(-12.5,0) 47(12.5,0)
GS12401-1011-9H-40P-R
  round 0.762 hole 0.762 unplated: (-10.5,0) (10.5,0)
  rect 0.254x1.143 smd: 1(9.75,2.125) 2(9.25,2.125) 3(8.75,2.125) 4(8.25,2.125) 5(7.75,2.125) 6(7.25,2.125) 7(6.75,2.125) 8(6.25,2.125) 9(5.75,2.125) 10(5.25,2.125) 11(4.75,2.125) 12(4.25,2.125) 13(3.75,2.125) 14(3.25,2.125) 15(2.75,2.125) 16(2.25,2.125) 17(1.75,2.125) 18(1.25,2.125) 19(0.75,2.125) 20(0.25,2.125) 21(-0.25,2.125) 22(-0.75,2.125) 23(-1.25,2.125) 24(-1.75,2.125) 25(-2.25,2.125) 26(-2.75,2.125) 27(-3.25,2.125) 28(-3.75,2.125) 29(-4.25,2.125) 30(-4.75,2.125) 31(-5.25,2.125) 32(-5.75,2.125) 33(-6.25,2.125) 34(-6.75,2.125) 35(-7.25,2.125) 36(-7.75,2.125) 37(-8.25,2.125) 38(-8.75,2.125) 39(-9.25,2.125) 40(-9.75,2.125)
  rect 1.499x2.997 smd: 41(12.25,0) 42(-12.25,0)
  rect 2.794x1.499 smd: 43(5.7,-2.05) 44(-5.7,-2.05)
H-C94D94N
  round 2.794 hole 2.794 unplated: (0,0)
H-C114D114N
  round 2.896 hole 2.896 unplated: (0,0)
H-C315D118P2
  round 8.001 hole 2.997: 1(0,0)
H-C315D276P2
  round 8.001 hole 7.01: 1(0,0)
H-C315I158D118P2
  round 8.001 hole 2.997: 1(0,0)
H-TBC315IC158D118P2
  round 8.001 hole 2.997: 1(0,0)
H-TC146IC186BC228D146P2
  round 3.708 hole 3.708: 1(0,0)
H-TC217IC174BC134D134PT
  round 3.404 hole 3.404: 1(0,0)
H-TC228IC174BC134D134PT
  round 3.404 hole 3.404: 1(0,0)
H-TC315IC158BC236D118P2
  round 8.001 hole 2.997: 1(0,0)
H-TC315IC198BC158D158PT
  round 8.001 hole 4.013: 1(0,0)
H-ZGM-1
  round 8.001 hole 2.997: 1(0,0)
H-ZGM-2
  custom 1.625x1.625 hole 2.997: 1(0,0)
H-ZGM-3
  custom 1.625x1.625 hole 2.997: 1(0,0)
HDMI-HERA7-AK120D-19P
  round 0.787 hole 0.559: 1(-4.5,7.35) 2(-4,8.9) 3(-3.5,7.35) 4(-3,8.9) 5(-2.5,7.35) 6(-2,8.9) 7(-1.5,7.35) 8(-1,8.9) 9(-0.5,7.35) 10(0,8.9) 11(0.5,7.35) 12(1,8.9) 13(1.5,7.35) 14(2,8.9) 15(2.5,7.35) 16(3,8.9) 17(3.5,7.35) 18(4,8.9) 19(4.5,7.35)
  oval 1.499x3.099 hole 0.889x2.489: 20(-8.75,0) 22(8.75,0)
  oval 1.499x2.108 hole 0.889x1.499: 21(-7.25,7.55) 23(7.25,7.55)
JOPEN25X30_S
  custom 0.159x0.159 smd: 1(-0.368,0) 2(0.368,0)
L2_5X2-1_2H
  rect 0.889x2.108 smd: 1(-0.85,0) 2(0.85,0)
L5_1X5_2-1_6H
  rect 1.905x2.489 smd: 1(-2.047,0) 2(2.047,0)
L6_6X6_6-2_8H
  rect 2.362x3.505 smd: 1(-3.025,0) 2(3.025,0)
L6_6X6_6-3_8
  rect 2.362x3.505 smd: 1(-3.025,0) 2(3.025,0)
L6_6X6_6-3H
  rect 1.854x3.505 smd: 1(-2.775,0) 2(2.775,0)
L10_3X10-4H-SMT
  rect 2.413x3.2 smd: 1(-4.75,0) 2(4.75,0)
L10X10-3_8
  rect 4.089x4.089 smd: 1(-4.75,0) 2(4.75,0)
L11_5X7_9-3_8H
  rect 3.505x3.708 smd: 1(-5.25,0) 2(5.25,0)
LEDLTST-G683GEBW-6P
  rect 0.94x0.61 smd: 1(-1.375,0.85) 2(-1.375,0) 3(-1.375,-0.85) 4(1.375,-0.85) 5(1.375,0) 6(1.375,0.85)
LQFP128-16X16-4-1_6H
  rect 0.203x1.499 smd: 1(-6.2,-7.85) 2(-5.8,-7.85) 3(-5.4,-7.85) 4(-5,-7.85) 5(-4.6,-7.85) 6(-4.2,-7.85) 7(-3.8,-7.85) 8(-3.4,-7.85) 9(-3,-7.85) 10(-2.6,-7.85) 11(-2.2,-7.85) 12(-1.8,-7.85) 13(-1.4,-7.85) 14(-1,-7.85) 15(-0.6,-7.85) 16(-0.2,-7.85) 17(0.2,-7.85) 18(0.6,-7.85) 19(1,-7.85) 20(1.4,-7.85) 21(1.8,-7.85) 22(2.2,-7.85) 23(2.6,-7.85) 24(3,-7.85) 25(3.4,-7.85) 26(3.8,-7.85) 27(4.2,-7.85) 28(4.6,-7.85) 29(5,-7.85) 30(5.4,-7.85) 31(5.8,-7.85) 32(6.2,-7.85) 65(6.2,7.85) 66(5.8,7.85) 67(5.4,7.85) 68(5,7.85) 69(4.6,7.85) 70(4.2,7.85) 71(3.8,7.85) 72(3.4,7.85) 73(3,7.85) 74(2.6,7.85) 75(2.2,7.85) 76(1.8,7.85) 77(1.4,7.85) 78(1,7.85) 79(0.6,7.85) 80(0.2,7.85) 81(-0.2,7.85) 82(-0.6,7.85) 83(-1,7.85) 84(-1.4,7.85) 85(-1.8,7.85) 86(-2.2,7.85) 87(-2.6,7.85) 88(-3,7.85) 89(-3.4,7.85) 90(-3.8,7.85) 91(-4.2,7.85) 92(-4.6,7.85) 93(-5,7.85) 94(-5.4,7.85) 95(-5.8,7.85) 96(-6.2,7.85)
  rect 1.499x0.203 smd: 33(7.85,-6.2) 34(7.85,-5.8) 35(7.85,-5.4) 36(7.85,-5) 37(7.85,-4.6) 38(7.85,-4.2) 39(7.85,-3.8) 40(7.85,-3.4) 41(7.85,-3) 42(7.85,-2.6) 43(7.85,-2.2) 44(7.85,-1.8) 45(7.85,-1.4) 46(7.85,-1) 47(7.85,-0.6) 48(7.85,-0.2) 49(7.85,0.2) 50(7.85,0.6) 51(7.85,1) 52(7.85,1.4) 53(7.85,1.8) 54(7.85,2.2) 55(7.85,2.6) 56(7.85,3) 57(7.85,3.4) 58(7.85,3.8) 59(7.85,4.2) 60(7.85,4.6) 61(7.85,5) 62(7.85,5.4) 63(7.85,5.8) 64(7.85,6.2) 97(-7.85,6.2) 98(-7.85,5.8) 99(-7.85,5.4) 100(-7.85,5) 101(-7.85,4.6) 102(-7.85,4.2) 103(-7.85,3.8) 104(-7.85,3.4) 105(-7.85,3) 106(-7.85,2.6) 107(-7.85,2.2) 108(-7.85,1.8) 109(-7.85,1.4) 110(-7.85,1) 111(-7.85,0.6) 112(-7.85,0.2) 113(-7.85,-0.2) 114(-7.85,-0.6) 115(-7.85,-1) 116(-7.85,-1.4) 117(-7.85,-1.8) 118(-7.85,-2.2) 119(-7.85,-2.6) 120(-7.85,-3) 121(-7.85,-3.4) 122(-7.85,-3.8) 123(-7.85,-4.2) 124(-7.85,-4.6) 125(-7.85,-5) 126(-7.85,-5.4) 127(-7.85,-5.8) 128(-7.85,-6.2)
MSOP8-4_9-65
  rect 0.406x1.448 smd: 1(-0.975,-2.325) 2(-0.325,-2.325) 3(0.325,-2.325) 4(0.975,-2.325) 5(0.975,2.325) 6(0.325,2.325) 7(-0.325,2.325) 8(-0.975,2.325)
NGFF-NASB0-S6701-TS58-75P-KB
  round 1.194 hole 1.194 unplated: (-10,0)
  round 1.702 hole 1.702 unplated: (10,0)
  rect 0.279x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 24(-3.5,-2.275) 25(-3.25,5.275) 26(-3,-2.275) 27(-2.75,5.275) 28(-2.5,-2.275) 29(-2.25,5.275) 30(-2,-2.275) 31(-1.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 59(5.25,5.275) 60(5.5,-2.275) 61(5.75,5.275) 62(6,-2.275) 63(6.25,5.275) 64(6.5,-2.275) 65(6.75,5.275) 66(7,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
NGFF-NASE0-S6701-TSH4-KE-SMT
  round 1.194 hole 1.194 unplated: (-10,0)
  round 1.702 hole 1.702 unplated: (10,0)
  rect 0.279x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 12(-6.5,-2.275) 13(-6.25,5.275) 14(-6,-2.275) 15(-5.75,5.275) 16(-5.5,-2.275) 17(-5.25,5.275) 18(-5,-2.275) 19(-4.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 59(5.25,5.275) 60(5.5,-2.275) 61(5.75,5.275) 62(6,-2.275) 63(6.25,5.275) 64(6.5,-2.275) 65(6.75,5.275) 66(7,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
NGFF-NASM0-S6701-TS40-75P-KM
  round 1.194 hole 1.194 unplated: (-10,0)
  round 1.702 hole 1.702 unplated: (10,0)
  rect 0.279x1.549 smd: 1(-9.25,5.275) 2(-9,-2.275) 3(-8.75,5.275) 4(-8.5,-2.275) 5(-8.25,5.275) 6(-8,-2.275) 7(-7.75,5.275) 8(-7.5,-2.275) 9(-7.25,5.275) 10(-7,-2.275) 11(-6.75,5.275) 12(-6.5,-2.275) 13(-6.25,5.275) 14(-6,-2.275) 15(-5.75,5.275) 16(-5.5,-2.275) 17(-5.25,5.275) 18(-5,-2.275) 19(-4.75,5.275) 20(-4.5,-2.275) 21(-4.25,5.275) 22(-4,-2.275) 23(-3.75,5.275) 24(-3.5,-2.275) 25(-3.25,5.275) 26(-3,-2.275) 27(-2.75,5.275) 28(-2.5,-2.275) 29(-2.25,5.275) 30(-2,-2.275) 31(-1.75,5.275) 32(-1.5,-2.275) 33(-1.25,5.275) 34(-1,-2.275) 35(-0.75,5.275) 36(-0.5,-2.275) 37(-0.25,5.275) 38(0,-2.275) 39(0.25,5.275) 40(0.5,-2.275) 41(0.75,5.275) 42(1,-2.275) 43(1.25,5.275) 44(1.5,-2.275) 45(1.75,5.275) 46(2,-2.275) 47(2.25,5.275) 48(2.5,-2.275) 49(2.75,5.275) 50(3,-2.275) 51(3.25,5.275) 52(3.5,-2.275) 53(3.75,5.275) 54(4,-2.275) 55(4.25,5.275) 56(4.5,-2.275) 57(4.75,5.275) 58(5,-2.275) 67(7.25,5.275) 68(7.5,-2.275) 69(7.75,5.275) 70(8,-2.275) 71(8.25,5.275) 72(8.5,-2.275) 73(8.75,5.275) 74(9,-2.275) 75(9.25,5.275)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
PAD-ZGM-1NP
  custom 1.859x1.859 smd: 1(0,0)
PAD-ZGM-2NP
  custom 0.761x0.761 smd: 1(0,0)
PAD-ZGM-3NP
  custom 0.761x0.761 smd: 1(0,0)
PAD-ZGM-4NP
  custom 0.761x0.761 smd: 1(0,0)
PAD-ZGM-5NP
  custom 0.761x0.761 smd: 1(0,0)
PAD-ZGM-6NP
  custom 1.627x1.627 smd: 1(0,0)
PAD-ZGM-7NP
  custom 0.763x0.763 smd: 1(0,0)
PAD-ZGM-8NP
  custom 0.763x0.763 smd: 1(0,0)
PAD-ZGM-9NP
  custom 0.763x0.763 smd: 1(0,0)
PAD-ZGM-10NP
  custom 0.763x0.763 smd: 1(0,0)
PAD-ZGM-11NP
  custom 5.017x5.017 smd: 1(0,0)
PAD-ZGM-12NP
  custom 0.763x0.763 smd: 1(0,0)
PAD-ZGM-13NP
  custom 0.763x0.763 smd: 1(0,0)
PAD-ZGM-14NP
  custom 1.987x1.987 smd: 1(0,0)
PAD-ZGM-15NP
  custom 0.763x0.763 smd: 1(0,0)
PAD-ZGM-16NP
  custom 0.763x0.763 smd: 1(0,0)
POWER-3X3-65-5P-ADNR21357
  rect 0.508x0.356 smd: 1(1.4,-0.975) 2(1.4,-0.325) 3(1.4,0.325) 4(1.4,0.975)
  custom 0.57x0.57 smd: 5(0,0)
POWER-5_2X5_55-1_27-5P
  rect 0.66x0.508 smd: 1(2.755,-1.905) 2(2.755,-0.635) 3(2.755,0.635) 4(2.755,1.905)
  custom 1.15x1.15 smd: 5(0,0)
POWER-5_2X5_55-1_27-7P-1H
  rect 0.508x0.559 smd: 1(-1.905,-2.8) 5(1.905,2.8) 6(0.635,2.8) 7(-0.635,2.8) 8(-1.905,2.8)
  custom 0.463x0.463 smd: 2(0,-2.1)
  rect 4.648x2.54 smd: 9(0,0.55)
POWER-5X6-1_27-10P
  rect 0.61x0.61 smd: 1(-1.905,-2.75) 2(-0.635,-2.75) 3(0.635,-2.75) 4(1.905,-2.75) 5(1.905,2.75) 6(0.635,2.75) 7(-0.635,2.75)
  rect 0.61x1.676 smd: 8(-1.905,2.21)
  rect 4.191x1.041 smd: 9(0,-1.535)
  custom 0.617x0.617 smd: 10(0,0)
QFN12-1_6X1_6-4-TUSB320
  custom 0.05x0.05 smd: 1(-0.2,-0.65) 2(0.2,-0.65) 3(0.75,-0.6) 4(0.75,-0.2) 5(0.75,0.2) 6(0.75,0.6) 7(0.2,0.65) 8(-0.2,0.65) 9(-0.75,0.6) 10(-0.75,0.2) 11(-0.75,-0.2) 12(-0.75,-0.6)
QFN16-2_5X2_5-45-17P
  custom 0.062x0.062 smd: 1(-0.675,-1.2) 4(0.675,-1.2) 5(1.2,-0.675) 8(1.2,0.675) 9(0.675,1.2) 12(-0.675,1.2) 13(-1.2,0.675) 16(-1.2,-0.675)
  rect 0.254x0.787 smd: 2(-0.225,-1.2) 3(0.225,-1.2) 10(0.225,1.2) 11(-0.225,1.2)
  rect 0.787x0.254 smd: 6(1.2,-0.225) 7(1.2,0.225) 14(-1.2,0.225) 15(-1.2,-0.225)
  rect 0.61x0.61 smd: 17(0,0)
QFN16-3X3-5-17P-SLGC55544C
  rect 0.305x0.991 smd: 1(-0.75,-1.6) 2(-0.25,-1.6) 3(0.25,-1.6) 4(0.75,-1.6) 9(0.75,1.6) 10(0.25,1.6) 11(-0.25,1.6) 12(-0.75,1.6)
  rect 0.991x0.305 smd: 5(1.6,-0.75) 6(1.6,-0.25) 7(1.6,0.25) 8(1.6,0.75) 13(-1.6,0.75) 14(-1.6,0.25) 15(-1.6,-0.25) 16(-1.6,-0.75)
  rect 1.702x1.702 smd: 17(0,0)
QFN19-4X3-4
  rect 0.254x1.702 smd: 1(-1,-0.95) 2(0,-0.95) 3(1,-0.95) 11(0.5,0.95) 12(-0.5,0.95)
  rect 0.787x0.254 smd: 4(1.9,-1.05) 9(1.9,1.05) 14(-1.9,1.05) 19(-1.9,-1.05)
  rect 0.787x0.203 smd: 5(1.9,-0.6) 6(1.9,-0.2) 7(1.9,0.2) 8(1.9,0.6) 15(-1.9,0.6) 16(-1.9,0.2) 17(-1.9,-0.2) 18(-1.9,-0.6)
  rect 0.254x0.787 smd: 10(1,1.4) 13(-1,1.4)
QFN20-3X3-4-21P-1_05H
  rect 0.203x0.508 smd: 1(-0.8,-1.39) 2(-0.4,-1.39) 3(0,-1.39) 4(0.4,-1.39) 5(0.8,-1.39) 11(0.8,1.39) 12(0.4,1.39) 13(0,1.39) 14(-0.4,1.39) 15(-0.8,1.39)
  rect 0.508x0.203 smd: 6(1.39,-0.8) 7(1.39,-0.4) 8(1.39,0) 9(1.39,0.4) 10(1.39,0.8) 16(-1.39,0.8) 17(-1.39,0.4) 18(-1.39,0) 19(-1.39,-0.4) 20(-1.39,-0.8)
  rect 1.854x1.854 smd: 21(0,0)
QFN20-3X3-4-21P-RT6543B
  custom 0.05x0.05 smd: 1(-0.8,-1.475) 5(0.8,-1.475) 6(1.475,-0.8) 10(1.475,0.8) 11(0.8,1.475) 15(-0.8,1.475) 16(-1.475,0.8) 20(-1.475,-0.8)
  rect 0.203x0.838 smd: 2(-0.4,-1.475) 3(0,-1.475) 4(0.4,-1.475) 12(0.4,1.475) 13(0,1.475) 14(-0.4,1.475)
  rect 0.838x0.203 smd: 7(1.475,-0.4) 8(1.475,0) 9(1.475,0.4) 17(-1.475,0.4) 18(-1.475,0) 19(-1.475,-0.4)
  rect 1.702x1.702 smd: 21(0,0)
QFN20-3X3-4-26P
  rect 0.203x0.787 smd: 1(-0.8,-1.5) 2(-0.4,-1.5) 3(0,-1.5) 4(0.4,-1.5) 5(0.8,-1.5) 11(0.8,1.5) 12(0.4,1.5) 13(0,1.5) 14(-0.4,1.5) 15(-0.8,1.5)
  rect 0.787x0.203 smd: 6(1.5,-0.8) 7(1.5,-0.4) 8(1.5,0) 9(1.5,0.4) 10(1.5,0.8) 16(-1.5,0.8) 17(-1.5,0.4) 18(-1.5,0) 19(-1.5,-0.4) 20(-1.5,-0.8)
  rect 1.803x1.803 smd: 21(0,0)
  round 0.508 hole 0.254: 22(-0.5,-0.5) 23(0.5,-0.5) 24(0.5,0.5) 25(-0.5,0.5) 26(0,0)
QFN28-4X4-4-29P-BQ24780RUYR
  custom 0.05x0.05 smd: 1(-1.2,-2) 2(-0.8,-2) 3(-0.4,-2) 4(0,-2) 5(0.4,-2) 6(0.8,-2) 7(1.2,-2) 8(2,-1.2) 9(2,-0.8) 10(2,-0.4) 11(2,0) 12(2,0.4) 13(2,0.8) 14(2,1.2) 15(1.2,2) 16(0.8,2) 17(0.4,2) 18(0,2) 19(-0.4,2) 20(-0.8,2) 21(-1.2,2) 22(-2,1.2) 23(-2,0.8) 24(-2,0.4) 25(-2,0) 26(-2,-0.4) 27(-2,-0.8) 28(-2,-1.2)
  rect 2.591x2.591 smd: 29(0,0)
QFN32-4X4-4-33P-MT6605N
  custom 0.051x0.051 smd: 1(-1.4,-2.1) 8(1.4,-2.1) 9(2.1,-1.4) 16(2.1,1.4) 17(1.4,2.1) 24(-1.4,2.1) 25(-2.1,1.4) 32(-2.1,-1.4)
  rect 0.203x0.991 smd: 2(-1,-2.1) 3(-0.6,-2.1) 4(-0.2,-2.1) 5(0.2,-2.1) 6(0.6,-2.1) 7(1,-2.1) 18(1,2.1) 19(0.6,2.1) 20(0.2,2.1) 21(-0.2,2.1) 22(-0.6,2.1) 23(-1,2.1)
  rect 0.991x0.203 smd: 10(2.1,-1) 11(2.1,-0.6) 12(2.1,-0.2) 13(2.1,0.2) 14(2.1,0.6) 15(2.1,1) 26(-2.1,1) 27(-2.1,0.6) 28(-2.1,0.2) 29(-2.1,-0.2) 30(-2.1,-0.6) 31(-2.1,-1)
  rect 2.642x2.642 smd: 33(0,0)
QFN32-4X4-4-33P-NCP45495
  custom 0.05x0.05 smd: 1(-1.4,-1.86) 8(1.4,-1.86) 9(1.86,-1.4) 16(1.86,1.4) 17(1.4,1.86) 24(-1.4,1.86) 25(-1.86,1.4) 32(-1.86,-1.4)
  rect 0.203x0.584 smd: 2(-1,-1.86) 3(-0.6,-1.86) 4(-0.2,-1.86) 5(0.2,-1.86) 6(0.6,-1.86) 7(1,-1.86) 18(1,1.86) 19(0.6,1.86) 20(0.2,1.86) 21(-0.2,1.86) 22(-0.6,1.86) 23(-1,1.86)
  rect 0.584x0.203 smd: 10(1.86,-1) 11(1.86,-0.6) 12(1.86,-0.2) 13(1.86,0.2) 14(1.86,0.6) 15(1.86,1) 26(-1.86,1) 27(-1.86,0.6) 28(-1.86,0.2) 29(-1.86,-0.2) 30(-1.86,-0.6) 31(-1.86,-1)
  rect 2.769x2.769 smd: 33(0,0)
QFN32-4X4-4-33P-SY9329C
  custom 0.05x0.05 smd: 1(-1.4,-1.95) 8(1.4,-1.95) 9(1.95,-1.4) 16(1.95,1.4) 17(1.4,1.95) 24(-1.4,1.95) 25(-1.95,1.4) 32(-1.95,-1.4)
  rect 0.203x0.787 smd: 2(-1,-1.95) 3(-0.6,-1.95) 4(-0.2,-1.95) 5(0.2,-1.95) 6(0.6,-1.95) 7(1,-1.95) 18(1,1.95) 19(0.6,1.95) 20(0.2,1.95) 21(-0.2,1.95) 22(-0.6,1.95) 23(-1,1.95)
  rect 0.787x0.203 smd: 10(1.95,-1) 11(1.95,-0.6) 12(1.95,-0.2) 13(1.95,0.2) 14(1.95,0.6) 15(1.95,1) 26(-1.95,1) 27(-1.95,0.6) 28(-1.95,0.2) 29(-1.95,-0.2) 30(-1.95,-0.6) 31(-1.95,-1)
  rect 2.108x1.092 smd: 33(0,0)
QFN32-5X5-5-33P-0_85H
  rect 0.305x0.991 smd: 1(-1.75,-2.6) 2(-1.25,-2.6) 3(-0.75,-2.6) 4(-0.25,-2.6) 5(0.25,-2.6) 6(0.75,-2.6) 7(1.25,-2.6) 8(1.75,-2.6) 17(1.75,2.6) 18(1.25,2.6) 19(0.75,2.6) 20(0.25,2.6) 21(-0.25,2.6) 22(-0.75,2.6) 23(-1.25,2.6) 24(-1.75,2.6)
  rect 0.991x0.305 smd: 9(2.6,-1.75) 10(2.6,-1.25) 11(2.6,-0.75) 12(2.6,-0.25) 13(2.6,0.25) 14(2.6,0.75) 15(2.6,1.25) 16(2.6,1.75) 25(-2.6,1.75) 26(-2.6,1.25) 27(-2.6,0.75) 28(-2.6,0.25) 29(-2.6,-0.25) 30(-2.6,-0.75) 31(-2.6,-1.25) 32(-2.6,-1.75)
  rect 3.505x3.505 smd: 33(0,0)
QFN33-5X5-5-19P
  rect 0.305x0.61 smd: 1(-1.75,-2.4) 2(-1.25,-2.4) 3(-0.75,-2.4) 4(-0.25,-2.4) 5(0.25,-2.4) 6(0.75,-2.4) 7(1.25,-2.4) 8(1.75,-2.4)
  custom 0.32x0.32 smd: 9(2.4,-1.75)
  custom 0.542x0.542 smd: 12(2.4,0.25)
  rect 3.81x0.61 smd: 16(0,2.4)
  rect 0.61x1.295 smd: 24(-2.4,1.25)
  rect 0.559x0.305 smd: 27(-2.4,0.25) 28(-2.4,-0.25)
  rect 0.61x0.305 smd: 29(-2.4,-0.75) 30(-2.4,-1.25) 31(-2.4,-1.75)
  rect 1.422x1.118 smd: 32(-1.05,-1.185)
  rect 0.559x0.356 smd: 33(-1.66,0.225)
QFN36-4_2X4_2-4-37P
  custom 0.05x0.05 smd: 1(-1.8,-2.1) 2(-1.4,-2.1) 3(-1,-2.1) 4(-0.6,-2.1) 5(-0.2,-2.1) 6(0.2,-2.1) 7(0.6,-2.1) 8(1,-2.1) 9(1.4,-2.1) 10(1.8,-2.1) 11(2.1,-1.4) 12(2.1,-1) 13(2.1,-0.6) 14(2.1,-0.2) 15(2.1,0.2) 16(2.1,0.6) 17(2.1,1) 18(2.1,1.4) 19(1.8,2.1) 20(1.4,2.1) 21(1,2.1) 22(0.6,2.1) 23(0.2,2.1) 24(-0.2,2.1) 25(-0.6,2.1) 26(-1,2.1) 27(-1.4,2.1) 28(-1.8,2.1) 29(-2.1,1.4) 30(-2.1,1) 31(-2.1,0.6) 32(-2.1,0.2) 33(-2.1,-0.2) 34(-2.1,-0.6) 35(-2.1,-1) 36(-2.1,-1.4)
  rect 2.997x2.997 smd: 37(0,0)
QFN39-6X5-45-21P-1H
  rect 0.254x0.61 smd: 1(-2.275,-2.4) 2(-1.825,-2.4) 3(-1.375,-2.4) 4(-0.925,-2.4) 5(-0.475,-2.4) 6(-0.025,-2.4)
  custom 0.55x0.55 smd: 7(1.15,0)
  rect 0.66x4.394 smd: 10(2.875,0)
  rect 2.159x2.362 smd: 25(-1.275,1.525)
  rect 0.61x0.254 smd: 30(-2.9,2.05) 31(-2.9,1.6) 32(-2.9,1.15) 33(-2.9,0.7) 34(-2.9,0.25) 35(-2.9,-0.2) 36(-2.9,-0.65) 37(-2.9,-1.1) 38(-2.9,-1.55) 39(-2.9,-2)
  rect 2.057x1.854 smd: 40(-1.275,-0.875)
  rect 0.406x0.559 smd: 41(0.25,-1.525)
QFN40-5X5-4-41P-NCP81610
  custom 0.05x0.05 smd: 1(-1.8,-2.335) 10(1.8,-2.335) 11(2.335,-1.8) 20(2.335,1.8) 21(1.8,2.335) 30(-1.8,2.335) 31(-2.335,1.8) 40(-2.335,-1.8)
  rect 0.203x0.635 smd: 2(-1.4,-2.335) 3(-1,-2.335) 4(-0.6,-2.335) 5(-0.2,-2.335) 6(0.2,-2.335) 7(0.6,-2.335) 8(1,-2.335) 9(1.4,-2.335) 22(1.4,2.335) 23(1,2.335) 24(0.6,2.335) 25(0.2,2.335) 26(-0.2,2.335) 27(-0.6,2.335) 28(-1,2.335) 29(-1.4,2.335)
  rect 0.635x0.203 smd: 12(2.335,-1.4) 13(2.335,-1) 14(2.335,-0.6) 15(2.335,-0.2) 16(2.335,0.2) 17(2.335,0.6) 18(2.335,1) 19(2.335,1.4) 32(-2.335,1.4) 33(-2.335,1) 34(-2.335,0.6) 35(-2.335,0.2) 36(-2.335,-0.2) 37(-2.335,-0.6) 38(-2.335,-1) 39(-2.335,-1.4)
  rect 3.632x3.632 smd: 41(0,0)
QFN40-5X5-4-41P-UP9511
  rect 0.203x0.991 smd: 1(-1.8,-2.6) 2(-1.4,-2.6) 3(-1,-2.6) 4(-0.6,-2.6) 5(-0.2,-2.6) 6(0.2,-2.6) 7(0.6,-2.6) 8(1,-2.6) 9(1.4,-2.6) 10(1.8,-2.6) 21(1.8,2.6) 22(1.4,2.6) 23(1,2.6) 24(0.6,2.6) 25(0.2,2.6) 26(-0.2,2.6) 27(-0.6,2.6) 28(-1,2.6) 29(-1.4,2.6) 30(-1.8,2.6)
  rect 0.991x0.203 smd: 11(2.6,-1.8) 12(2.6,-1.4) 13(2.6,-1) 14(2.6,-0.6) 15(2.6,-0.2) 16(2.6,0.2) 17(2.6,0.6) 18(2.6,1) 19(2.6,1.4) 20(2.6,1.8) 31(-2.6,1.8) 32(-2.6,1.4) 33(-2.6,1) 34(-2.6,0.6) 35(-2.6,0.2) 36(-2.6,-0.2) 37(-2.6,-0.6) 38(-2.6,-1) 39(-2.6,-1.4) 40(-2.6,-1.8)
  rect 3.505x3.505 smd: 41(0,0)
QFN40-6X3-4-41P-0_75H
  custom 0.05x0.05 smd: 1(-2.6,-1.425) 14(2.6,-1.425) 15(2.925,-1) 20(2.925,1) 21(2.6,1.425) 34(-2.6,1.425) 35(-2.925,1) 40(-2.925,-1)
  rect 0.203x0.559 smd: 2(-2.2,-1.425) 3(-1.8,-1.425) 4(-1.4,-1.425) 5(-1,-1.425) 6(-0.6,-1.425) 7(-0.2,-1.425) 8(0.2,-1.425) 9(0.6,-1.425) 10(1,-1.425) 11(1.4,-1.425) 12(1.8,-1.425) 13(2.2,-1.425) 22(2.2,1.425) 23(1.8,1.425) 24(1.4,1.425) 25(1,1.425) 26(0.6,1.425) 27(0.2,1.425) 28(-0.2,1.425) 29(-0.6,1.425) 30(-1,1.425) 31(-1.4,1.425) 32(-1.8,1.425) 33(-2.2,1.425)
  rect 0.559x0.203 smd: 16(2.925,-0.6) 17(2.925,-0.2) 18(2.925,0.2) 19(2.925,0.6) 36(-2.925,0.6) 37(-2.925,0.2) 38(-2.925,-0.2) 39(-2.925,-0.6)
  rect 4.496x1.499 smd: 41(0,0)
QFN40-6X4-4-49P-TUSB546
  custom 0.05x0.05 smd: 1(-1.4,-2.9) 2(-1,-2.9) 3(-0.6,-2.9) 4(-0.2,-2.9) 5(0.2,-2.9) 6(0.6,-2.9) 7(1,-2.9) 8(1.4,-2.9) 9(1.9,-2.2) 10(1.9,-1.8) 11(1.9,-1.4) 12(1.9,-1) 13(1.9,-0.6) 14(1.9,-0.2) 15(1.9,0.2) 16(1.9,0.6) 17(1.9,1) 18(1.9,1.4) 19(1.9,1.8) 20(1.9,2.2) 21(1.4,2.9) 22(1,2.9) 23(0.6,2.9) 24(0.2,2.9) 25(-0.2,2.9) 26(-0.6,2.9) 27(-1,2.9) 28(-1.4,2.9) 29(-1.9,2.2) 30(-1.9,1.8) 31(-1.9,1.4) 32(-1.9,1) 33(-1.9,0.6) 34(-1.9,0.2) 35(-1.9,-0.2) 36(-1.9,-0.6) 37(-1.9,-1) 38(-1.9,-1.4) 39(-1.9,-1.8) 40(-1.9,-2.2)
  rect 2.692x4.699 smd: 41(0,0)
  round 0.508 hole 0.254: 42(0,-2.1) 43(1.1,-0.75) 44(1.1,0.75) 45(0,2.1) 46(-1.1,0.75) 47(-1.1,-0.75) 48(0,-0.75) 49(0,0.75)
QFN42-9X3_5-5-43P-PI3EQX1004
  rect 0.279x0.635 smd: 1(-4,-1.59) 2(-3.5,-1.59) 3(-3,-1.59) 4(-2.5,-1.59) 5(-2,-1.59) 6(-1.5,-1.59) 7(-1,-1.59) 8(-0.5,-1.59) 9(0,-1.59) 10(0.5,-1.59) 11(1,-1.59) 12(1.5,-1.59) 13(2,-1.59) 14(2.5,-1.59) 15(3,-1.59) 16(3.5,-1.59) 17(4,-1.59) 22(4,1.59) 23(3.5,1.59) 24(3,1.59) 25(2.5,1.59) 26(2,1.59) 27(1.5,1.59) 28(1,1.59) 29(0.5,1.59) 30(0,1.59) 31(-0.5,1.59) 32(-1,1.59) 33(-1.5,1.59) 34(-2,1.59) 35(-2.5,1.59) 36(-3,1.59) 37(-3.5,1.59) 38(-4,1.59)
  rect 0.635x0.279 smd: 18(4.34,-0.75) 19(4.34,-0.25) 20(4.34,0.25) 21(4.34,0.75) 39(-4.34,0.75) 40(-4.34,0.25) 41(-4.34,-0.25) 42(-4.34,-0.75)
  rect 7.01x1.803 smd: 43(0,0)
QFN48-6X6-4-49P-ALC280
  rect 0.203x0.991 smd: 1(-2.2,-3.1) 2(-1.8,-3.1) 3(-1.4,-3.1) 4(-1,-3.1) 5(-0.6,-3.1) 6(-0.2,-3.1) 7(0.2,-3.1) 8(0.6,-3.1) 9(1,-3.1) 10(1.4,-3.1) 11(1.8,-3.1) 12(2.2,-3.1) 25(2.2,3.1) 26(1.8,3.1) 27(1.4,3.1) 28(1,3.1) 29(0.6,3.1) 30(0.2,3.1) 31(-0.2,3.1) 32(-0.6,3.1) 33(-1,3.1) 34(-1.4,3.1) 35(-1.8,3.1) 36(-2.2,3.1)
  rect 0.991x0.203 smd: 13(3.1,-2.2) 14(3.1,-1.8) 15(3.1,-1.4) 16(3.1,-1) 17(3.1,-0.6) 18(3.1,-0.2) 19(3.1,0.2) 20(3.1,0.6) 21(3.1,1) 22(3.1,1.4) 23(3.1,1.8) 24(3.1,2.2) 37(-3.1,2.2) 38(-3.1,1.8) 39(-3.1,1.4) 40(-3.1,1) 41(-3.1,0.6) 42(-3.1,0.2) 43(-3.1,-0.2) 44(-3.1,-0.6) 45(-3.1,-1) 46(-3.1,-1.4) 47(-3.1,-1.8) 48(-3.1,-2.2)
  rect 4.394x4.394 smd: 49(0,0)
R0201
  rect 0.203x0.381 smd: 1(-0.225,0) 2(0.225,0)
R0402
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
R0603
  rect 0.686x0.813 smd: 1(0.6,0) 2(-0.6,0)
R0805
  rect 0.864x1.372 smd: 1(0.88,0) 2(-0.88,0)
RC2037-SMT
  rect 0.584x4.191 smd: 1(-0.894,0) 2(0.894,0)
RC2512
  rect 3.099x3.988 smd: 1(-2.2,0) 2(2.2,0)
S0201
  rect 0.343x0.381 smd: 1(-0.225,0) 2(0.225,0)
S0402
  custom 0.125x0.125 smd: 1(0.39,0) 2(-0.39,0)
S0603
  rect 1.041x0.813 smd: 1(0.6,0) 2(-0.6,0)
S0612
  rect 1.321x3.2 smd: 1(-0.825,0) 2(0.825,0)
S0805
  rect 1.346x1.372 smd: 1(0.88,0) 2(-0.88,0)
SC70-2_1-65-5P
  rect 1.27x0.279 smd: 1(1.02,-0.65) 2(1.02,0) 3(1.02,0.65) 4(-1.02,0.65) 5(-1.02,-0.65)
SC70-2_1-65-6P
  rect 1.27x0.279 smd: 1(1.02,-0.65) 2(1.02,0) 3(1.02,0.65) 4(-1.02,0.65) 5(-1.02,0) 6(-1.02,-0.65)
SC70-2_1-65-6P-SN74AVC1T45
  rect 0.889x0.406 smd: 1(1.1,-0.65) 2(1.1,0) 3(1.1,0.65) 4(-1.1,0.65) 5(-1.1,0) 6(-1.1,-0.65)
SIMCARD-5-501709002000-6-6P
  rect 0.889x1.194 smd: 1(-3.175,6.8) 2(-0.635,6.8) 3(1.905,6.8) 5(-1.905,6.8) 6(0.635,6.8) 7(3.175,6.8)
  rect 1.295x1.803 smd: 8(-5.85,2.7) 9(5.85,2.7) 10(-5.85,-6.1) 11(5.85,-6.1)
SOIC8-6-1_27-24AA02
  rect 0.61x1.549 smd: 1(-1.905,-2.7) 2(-0.635,-2.7) 3(0.635,-2.7) 4(1.905,-2.7) 5(1.905,2.7) 6(0.635,2.7) 7(-0.635,2.7) 8(-1.905,2.7)
SOIC8-6-1_27-PM25LV010A
  rect 0.533x1.727 smd: 1(-1.905,-2.733) 2(-0.635,-2.733) 3(0.635,-2.733) 4(1.905,-2.733) 5(1.905,2.733) 6(0.635,2.733) 7(-0.635,2.733) 8(-1.905,2.733)
SON8-8X6-1_27-9P
  rect 0.508x1.397 smd: 1(-1.905,-3.9) 2(-0.635,-3.9) 3(0.635,-3.9) 4(1.905,-3.9) 5(1.905,3.9) 6(0.635,3.9) 7(-0.635,3.9) 8(-1.905,3.9)
  rect 4.293x3.404 smd: 9(0,0)
SOP8-5_99-1_27
  rect 0.508x1.549 smd: 1(-1.905,-2.815) 2(-0.635,-2.815) 3(0.635,-2.815) 4(1.905,-2.815) 5(1.905,2.815) 6(0.635,2.815) 7(-0.635,2.815) 8(-1.905,2.815)
SOP16-5_99-635
  rect 0.305x1.549 smd: 1(-2.223,-2.82) 2(-1.587,-2.82) 3(-0.953,-2.82) 4(-0.318,-2.82) 5(0.318,-2.82) 6(0.953,-2.82) 7(1.587,-2.82) 8(2.223,-2.82) 9(2.223,2.82) 10(1.587,2.82) 11(0.953,2.82) 12(0.318,2.82) 13(-0.318,2.82) 14(-0.953,2.82) 15(-1.587,2.82) 16(-2.223,2.82)
SOT23-1_7-65-3P
  rect 0.711x0.432 smd: 1(0.85,0.65) 2(0.85,-0.65) 3(-0.85,0)
SOT23-1_38-5-3P
  rect 0.533x0.381 smd: 1(0.69,0.5) 2(0.69,-0.5) 3(-0.69,0)
SOT23-2-95-3P
  rect 0.711x0.559 smd: 1(1,0.95) 2(1,-0.95) 3(-1,0)
SOT23-2_8-95-5P-LP2985-50DBVT
  rect 1.041x0.61 smd: 1(1.35,-0.95) 2(1.35,0) 3(1.35,0.95) 4(-1.35,0.95) 5(-1.35,-0.95)
SOT23-2_38-95-3P
  rect 0.787x0.533 smd: 1(1.19,0.95) 2(1.19,-0.95) 3(-1.19,0)
SOT23-5-2_8-95-5P-G708
  rect 1.194x0.533 smd: 1(1.5,-0.95) 2(1.5,0) 3(1.5,0.95) 4(-1.5,0.95) 5(-1.5,-0.95)
SOT23-6-2_8-95-6P-G5126TB1U
  rect 1.194x0.508 smd: 1(1.5,-0.95) 2(1.5,0) 3(1.5,0.95) 4(-1.5,0.95) 5(-1.5,0) 6(-1.5,-0.95)
SOT353-1-2_125-65-5P
  rect 1.245x0.279 smd: 1(1.045,-0.65) 2(1.045,0) 3(1.045,0.65) 4(-1.045,0.65) 5(-1.045,-0.65)
SOT353-2_1-65-5P
  rect 0.508x0.406 smd: 1(0.95,-0.65) 2(0.95,0) 3(0.95,0.65) 4(-0.95,0.65) 5(-0.95,-0.65)
SOT363-2_1-65-6P
  rect 0.889x0.356 smd: 1(0.8,-0.65) 2(0.8,0) 3(0.8,0.65) 4(-0.8,0.65) 5(-0.8,0) 6(-0.8,-0.65)
SOT563-1_6-5-6P-PJX138K
  rect 0.457x0.305 smd: 1(0.675,-0.5) 2(0.675,0) 3(0.675,0.5) 4(-0.675,0.5) 5(-0.675,0) 6(-0.675,-0.5)
SW-T3AL-23-Q-TR-4P
  rect 0.66x0.711 smd: 1(-1.475,0.95) 2(1.475,0.95) 3(-1.475,-0.95) 4(1.475,-0.95)
SW-TME-533B-Q-TR-6P
  rect 1.803x1.092 smd: 1(-3.1,1.85) 2(3.1,1.85) 3(-3.1,-1.85) 4(3.1,-1.85)
  rect 0.991x0.61 smd: 5(0,2.5) 6(0,-2.5)
TP2050
  round 0.508 smd: 1(0,0)
TQFN20-4X4-5-25P
  rect 0.305x0.94 smd: 1(-1,-1.925) 2(-0.5,-1.925) 3(0,-1.925) 4(0.5,-1.925) 5(1,-1.925) 11(1,1.925) 12(0.5,1.925) 13(0,1.925) 14(-0.5,1.925) 15(-1,1.925)
  rect 0.94x0.305 smd: 6(1.925,-1) 7(1.925,-0.5) 8(1.925,0) 9(1.925,0.5) 10(1.925,1) 16(-1.925,1) 17(-1.925,0.5) 18(-1.925,0) 19(-1.925,-0.5) 20(-1.925,-1)
  rect 2.108x2.108 smd: 21(0,0)
  round 0.61 hole 0.305: 22(-0.5,-0.5) 23(0.5,-0.5) 24(0.5,0.5) 25(-0.5,0.5)
TSOT23-6-2_8-95-6P-1H
  rect 1.194x0.508 smd: 1(1.5,-0.95) 2(1.5,0) 3(1.5,0.95) 4(-1.5,0.95) 5(-1.5,0) 6(-1.5,-0.95)
UB31-31105-00902-V01-9P
  round 1.219 hole 0.813: 1(3.5,10.4) 2(1,10.4) 3(-1,10.4) 4(-3.5,10.4) 5(-4,8.9) 6(-2,8.9) 7(0,8.9) 8(2,8.9) 9(4,8.9)
  oval 1.295x2.311 hole 0.711x1.702: 10(7.75,10.4) 11(-7.75,10.4) 12(7.75,0) 13(-7.75,0)
UB31-UCF3M-51N30-0P10-24P-SMT
  round 0.813 hole 0.813 unplated: (-3.675,0) (3.675,0)
  oval 0.838x2.159 hole 0.559x1.854: 1(-4.925,-0.45) 2(4.925,-0.45)
  oval 0.991x0.711 hole 0.711x0.406: 3(-3.775,-1.1) 4(3.775,-1.1)
  oval 1.041x2.362 hole 0.559x1.854: 5(-5.85,-6.05) 6(5.85,-6.05)
  rect 0.254x0.94 smd: A1(-2.625,0.275) A2(-2.125,0.275) A3(-1.625,0.275) A4(-1.125,0.275) A5(-0.625,0.275) A6(-0.125,0.275) A7(0.375,0.275) A8(0.875,0.275) A9(1.375,0.275) A10(1.875,0.275) A11(2.375,0.275) A12(2.875,0.275)
  rect 0.254x0.838 smd: B1(2.625,-1.375) B2(2.125,-1.375) B3(1.625,-1.375) B4(1.125,-1.375) B5(0.625,-1.375) B6(0.125,-1.375) B7(-0.375,-1.375) B8(-0.875,-1.375) B9(-1.375,-1.375) B10(-1.875,-1.375) B11(-2.375,-1.375) B12(-2.875,-1.375)
unnamed#2
  round 1.016 smd: 1(0,0)
VSSOP8-3_1-5-TS5A3359
  rect 0.254x1.168 smd: 1(-0.75,-1.563) 2(-0.25,-1.563) 3(0.25,-1.563) 4(0.75,-1.563) 5(0.75,1.563) 6(0.25,1.563) 7(-0.25,1.563) 8(-0.75,1.563)
WTB-50273-0040N-V10-4P-L
  rect 0.787x1.6 smd: 1(-1.875,2.9) 2(-0.625,2.9) 3(0.625,2.9) 4(1.875,2.9)
  rect 2.108x2.997 smd: 5(-4.425,0) 6(4.425,0)
WTB-50458-01001-V02-10P-L
  rect 0.559x1.295 smd: 1(-9,5.025) 2(-7,5.025) 3(-5,5.025) 4(-3,5.025) 5(-1,5.025) 6(1,5.025) 7(3,5.025) 8(5,5.025) 9(7,5.025) 10(9,5.025)
  rect 1.295x2.057 smd: 11(-12.1,0) 12(12.1,0)
WTB-GS12201-1011-7H-20P-L-SMT
  round 0.965 hole 0.965 unplated: (-5.8,0) (5.8,0)
  rect 0.254x1.143 smd: 1(-4.75,2.325) 2(-4.25,2.325) 3(-3.75,2.325) 4(-3.25,2.325) 5(-2.75,2.325) 6(-2.25,2.325) 7(-1.75,2.325) 8(-1.25,2.325) 9(-0.75,2.325) 10(-0.25,2.325) 11(0.25,2.325) 12(0.75,2.325) 13(1.25,2.325) 14(1.75,2.325) 15(2.25,2.325) 16(2.75,2.325) 17(3.25,2.325) 18(3.75,2.325) 19(4.25,2.325) 20(4.75,2.325)
  rect 1.295x1.397 smd: 21(-5.8,2.2) 22(5.8,2.2) 23(-5.8,-1.8) 24(5.8,-1.8)
XTL-2X1_6-1_4X1_1-4P
  rect 0.889x0.787 smd: 1(-0.7,-0.55) 2(0.7,-0.55) 3(0.7,0.55) 4(-0.7,0.55)
XTL-3_2X1_5-2_5-SMT
  rect 0.991x1.6 smd: 1(-1.25,0) 2(1.25,0)
XTL-3_2X2_5-2_2X1_6-0_9H
  rect 1.397x1.194 smd: 1(-1.1,-0.8) 2(1.1,-0.8) 3(1.1,0.8) 4(-1.1,0.8)
XTL-3_2X2_5-2_2X1_7
  rect 1.397x1.194 smd: 1(-1.1,-0.85) 2(1.1,-0.85) 3(1.1,0.85) 4(-1.1,0.85)

## Nets
1V8_AON_EN: PR122.1 Q12.2 UG3.4(Y)
3V_LDO: PC210.1 PR272.1 PR275.1 PR513.1 PU15.3
241VID0: PR658.2 PU39.6
241VID1: PR659.2 PU39.5
+0.85V_VCCLDOSTD: C739.1 U49.BF4 U49.BG3 U49.BG4
+1.2V_U3: C442.1 C443.1 C454.1 C468.1 C497.1 C779.1 C780.1 L12.2 U24.4 U24.10 U24.19 U24.22 U24.23 U24.24 U24.28(VDDM#3) U24.34
+1.2VSUS: C125.1 C126.2 C127.2 C136.1 C138.1 C143.1 C145.1 C146.1 C154.1 C155.1 C156.1 C158.1 C159.1 C160.1 C163.1 C164.1 C165.1 C166.1 C167.1 C168.1 C169.1 C170.1 C171.1 C172.1 C174.1 C176.2 C177.1 C179.1 C182.1 C184.1 C196.1 C198.1 C258.1 C262.1 C265.1 C266.1 C268.1 C269.1 C272.1 C273.1 C275.1 C276.1 C277.1 C278.1 C279.1 C280.1 C282.1 C283.1 C284.1 C286.1 C290.1 C291.2 C292.1 C297.1 C298.1 C299.1 C300.1 C302.1 C304.2 C305.1 C306.1 C307.1 C329.1 C330.1 C331.2 C694.1 C695.1 CN4.1 JDIM1.12 JDIM1.33 JDIM1.54 JDIM1.75 JDIM1.96 JDIM1.111 JDIM1.112 JDIM1.117 JDIM1.118 JDIM1.123 JDIM1.124 JDIM1.129 JDIM1.130 JDIM1.135 JDIM1.136 JDIM1.141 JDIM1.142 JDIM1.147 JDIM1.148 JDIM1.153 JDIM1.154 JDIM1.159 JDIM1.160 JDIM1.163 JDIM1.178 JDIM1.199 JDIM1.220 JDIM1.241 JDIM2.12 JDIM2.33 JDIM2.54 JDIM2.75 JDIM2.96 JDIM2.111 JDIM2.112 JDIM2.117 JDIM2.118 JDIM2.123 JDIM2.124 JDIM2.129 JDIM2.130 JDIM2.135 JDIM2.136 JDIM2.141 JDIM2.142 JDIM2.147 JDIM2.148 JDIM2.153 JDIM2.154 JDIM2.159 JDIM2.160 JDIM2.163 JDIM2.178 JDIM2.199 JDIM2.220 JDIM2.241 L12.1 PJ15.2 PR536.2 PR538.2 R114.1 R115.2 R116.1 R117.2 R118.1 R119.1 R123.1 R129.1 R130.1 R133.1 R142.1 R158.2 R177.1 R188.1 R190.1 R191.1 R199.1 R212.1 R213.1 R229.1 R265.1 R267.1 R268.1 R270.1 R294.2 R308.1 R1104.1 U42.AH11 U42.AH12 U42.AJ11 U42.AJ12 U42.AL11 U42.AM11 U42.AM12 U42.AN11 U42.AN12 U42.AR5 U42.AR11 U42.AT5 U42.AT11 U42.AT12 U42.AV10 U42.AV11 U42.AW5 U42.AW10 U42.AW11 U42.AW12 U42.AY5 U42.AY11 U42.BA11 U42.BC10 U42.BC11 U42.BC12 U42.BD5 U42.BD10 U42.BD11 U42.BE5 U42.BE11 U42.BF11 U42.BF12 U42.BG10 U42.BG11 U42.BH5 U42.BH10 U42.BK5 U42.BM10 U42.BN5 U42.BN10 U42.BP5 U42.BT10 U42.BV5 U42.BV10 U42.BW5
+1.2VSUS_TEMP: PC233.1 PC234.1 PC240.1 PC489.1 PC491.1 PC494.1 PC506.1 PJ15.1 PL23.2 PR621.1 PU38.19
+1.2VSUS_VIN: PC258.1 PC262.1 PC513.1 PC514.1 PC515.1 PJ20.1 PQ67.2 PR635.1
+1.05V_PWRGD_G1: C394.1 Q42.2 R391.2 R402.2
+1.05V_PWRGD_G2: Q42.3 Q45.2 R400.1
+1.8V: C486.2 C494.2 L21.1 L22.2 PQ21.1(S) PR614.1 Q39.5 RG95.2 RG98.2 RG104.1 RG178.2 U21.17 UG3.5
+1.8V_5G: C303.1 Q26.2 Q102.2 Q107.2 Q109.2 QG16.2 R239.2 R251.2 R559.1 R855.2 R861.2 R1045.2 R1051.2
+1.8V_AON: C140.1 C144.1 CG6.1 CG7.1 CG8.1 CG9.1 CG11.1 CG12.1 CG13.1 CG52.1 CG63.1 CG70.1 CG72.1 CG82.1 CG84.1 CG87.1 CG91.1 CG95.1 CG120.1 CG128.1 CG130.1 CG131.1 CG137.1 CG139.1 CG178.1 CG204.1 CG208.1 CG219.1 CG221.1 CG224.1 CG233.1 CG315.1 CG318.1 CG323.2 CG327.1 CG328.1 CG329.1 CG331.1 CG346.1 CG347.2 CG348.1 CG349.1 CG357.1 CG362.1 CG367.1 CG368.1 CG378.1 CG379.1 CG381.1 CG391.1 CG392.2 CG394.1 CG395.2 CG397.2 CG398.2 CG399.2 CG402.1 CG404.1 CG518.1 LG1.1 LG2.2 PJ1.1 PR184.2 PR189.2 PR380.1 PR535.2 Q82.2 Q117.2 Q117.5 QG18.2 QG24.2 QG25.2 R68.1 R1173.2 R1174.1 RG48.1 RG52.1 RG54.2 RG59.1 RG62.1 RG63.1 RG64.2 RG75.2 RG76.2 RG79.1 RG80.1 RG81.1 RG82.1 RG84.2 RG86.2 RG87.1 RG88.1 RG90.1 RG96.2 RG97.2 RG100.2 RG102.2 RG105.1 RG107.2 RG116.1 RG117.2 RG118.2 RG124.1 RG126.2 RG128.2 RG129.1 RG130.2 RG133.2 RG138.1 RG142.1 RG144.2 RG150.2 RG160.1 RG161.1 RG162.1 RG174.2 RG175.2 RG176.2 RG182.1 UG6.BF10 UG6.BF11 UG6.BF38 UG6.BF40 UG6.BF41 UG6.BG10 UG6.BG11 UG6.BG38 UG6.BG40 UG6.BG41 UG6.BG43 UG6.BG44 UG6.BH38 UG6.BH40 UG6.BH41 UG6.BH43 UG6.BH44 UG7.8 VRAM1.A5 VRAM1.A10 VRAM1.V5 VRAM1.V10 VRAM2.A5 VRAM2.A10 VRAM2.V5 VRAM2.V10 VRAM3.A5 VRAM3.A10 VRAM3.V5 VRAM3.V10 VRAM4.A5 VRAM4.A10 VRAM4.V5 VRAM4.V10 VRAM5.A5 VRAM5.A10 VRAM5.V5 VRAM5.V10 VRAM6.A5 VRAM6.A10 VRAM6.V5 VRAM6.V10 VRAM7.A5 VRAM7.A10 VRAM7.V5 VRAM7.V10 VRAM8.A5 VRAM8.A10 VRAM8.V5 VRAM8.V10
+1.8V_CLKLDO: C461.1 R481.1 U49.P29 U49.R29
+1.8V_DEEP_SUS: C427.2 C431.1 C449.1 C453.2 Q32.2 R309.1 R481.2 R498.1 R897.2 R914.2 R959.2 R967.2 R1003.2 R1077.2 R1078.2 U17.6(VCCB) U19.5 U19.6(VCCB) U22.5(VCC) U26.5(VCC) U49.AA27 U49.AB22 U49.AB23 U49.AB25 U49.AB27 U49.AD20 U49.AD22 U49.AD23 U49.AD25 U49.AD27 U49.AF20 U49.AF22 U49.AF23 U49.AF25 U49.AF27 U49.Y37
+1.8V_S5: C716.1 PJ6.2 PQ21.3 Q94.3 Q104.3 R413.1 R756.1 R1003.1
+1.8V_VCC: C75.1 C85.2 R756.2 R763.2 U42.AM35 U42.AN33 U42.AN34 U42.AN35 U42.AP33 U42.AR34 U42.AT33 U42.AT34 U42.AT35 U42.AU34
+1V8_AON_U: RG178.1 UG8.5(VCC) UG9.5(VCC)
+1V_GFX: C141.1 C142.1 C147.1 C685.1 CG317.1 CG319.1 CG320.1 CG321.1 CG322.1 CG324.1 CG325.1 CG326.1 CG330.1 CG332.1 CG334.1 CG335.1 CG336.1 CG343.1 CG345.1 CG350.1 CG351.1 CG352.1 CG356.2 CG358.1 CG361.1 CG369.1 CG380.1 CG393.1 CG523.1 CG524.1 CG526.2 CG527.1 PR528.2 PR529.2 UG6.BF13 UG6.BF14 UG6.BF16 UG6.BF17 UG6.BF19 UG6.BF20 UG6.BF22 UG6.BF23 UG6.BF26 UG6.BF28 UG6.BF29 UG6.BF31 UG6.BF32 UG6.BF34 UG6.BF35 UG6.BF37 UG6.BG13 UG6.BG14 UG6.BG16 UG6.BG17 UG6.BG19 UG6.BG20 UG6.BG23 UG6.BG26 UG6.BG27 UG6.BG28 UG6.BG29 UG6.BG31 UG6.BG32 UG6.BG34 UG6.BG35 UG6.BG37 UG6.BH26 UG6.BH28 UG6.BH29 UG6.BH31 UG6.BH32 UG6.BH34 UG6.BH35 UG6.BH37 UG6.BJ26 UG6.BJ27 UG6.BJ28 UG6.BJ29 UG6.BK26 UG6.BK28 UG6.BK29 UG6.BL26 UG6.BL27 UG6.BL28 UG6.BL29 UG6.BM26 UG6.BM28 UG6.BM29 UG6.BN26 UG6.BN27 UG6.BN28 UG6.BN29 UG6.BP26 UG6.BP28 UG6.BP29 UG6.BR26 UG6.BR27 UG6.BR28 UG6.BR29 UG6.BT26 UG6.BT28 UG6.BT29
+1V_GFX_EN: PR132.2 UG9.4
+1V_GFX_EN_1: DG5.2 PR135.1
+1V_GFX_PG: PR534.1 PR535.1 RG90.2 UG2.2
+1V_GFX_S: PC403.1 PC404.1 PC405.1 PQ14.1 PQ14.2 PQ14.3(S_3) PR133.1 PR134.1 PR528.1 PR529.1
+1V_S5_VIN: PC246.1 PC254.1 PC261.1 PC265.1 PC527.2 PJ18.1 PU39.2
+2.5V_SUS: C151.1 C152.1 C153.1 C157.1 C247.1 C253.1 C261.1 C271.1 JDIM1.257 JDIM1.259 JDIM2.257 JDIM2.259 PJ12.2
+3V: C27.1 C161.1 C162.1 C251.1 C257.1 C368.1 C381.1 C386.1 C393.1 C597.2 C601.1 C703.1 C707.1 C709.2 CN1.5 JDIM1.255 JDIM2.255 L11.1 L20.1 PC3.1 PR127.2 PR194.2 PR217.1 PR218.1 PR269.1 PR361.1 PR383.2 PR628.1 PU3.5(VCC) Q9.2 Q23.2 Q28.2 Q30.2 Q31.2 Q43.2 Q47.2 Q47.5 Q100.2 Q108.2 Q108.5 Q124.2 R12.2 R13.2 R15.2 R16.1 R44.1 R50.2 R52.2 R56.1 R58.1 R74.1 R79.2 R87.1 R88.2 R112.1 R120.1 R131.1 R137.1 R148.2 R238.1 R246.1 R250.2 R264.1 R271.1 R272.1 R293.2 R298.1 R314.2 R316.1 R339.2 R346.2 R354.2 R369.2 R373.2 R387.1 R412.2 R419.2 R420.1 R426.2 R427.2 R431.1 R436.1 R475.1 R499.2 R502.1 R505.2 R512.2 R517.2 R527.1 R529.2 R535.2 R539.2 R541.2 R554.2 R572.2 R582.2 R618.2 R621.1 R673.1 R674.1 R675.1 R741.1 R816.1 R817.1 R910.2 R912.2 R917.2 R923.2 R994.2 R996.2 R997.2 R999.2 R1000.2 R1005.2 R1088.2 R1090.2 R1118.2 R1119.2 R1120.2 R1121.2 R1122.2 R1123.2 R1124.2 R1125.2 R1128.2 R1134.2 R1169.1 R1195.2 R1196.2 R1197.1 R1200.1 R1203.1 R1206.1 R1207.1 R1208.1 RG93.2 RG106.2 RG171.1 U4.8 U38.4 U38.5 U39.5(VCC) U40.5(VCC) U43.5 U44.5(VCC) U45.5 UG4.5 UG5.5 UG10.5 UG11.5
+3V3PD: C231.1 Q20.2 Q20.5 Q22.2 Q24.1(S) Q25.2 Q29.2 Q29.5 Q105.2 Q106.2 Q106.5 R192.2 R200.2 R203.2 R211.2 R853.2 R858.2 R862.2 U11.H4
+3V_5G: C213.1 C217.1 C218.1 C225.1 C229.1 C234.1 C238.1 C244.1 C248.1 C249.1 C250.1 C332.1 C346.1 C367.1 C378.1 CN7.2 CN7.4 CN7.70 CN7.72 CN7.74 PJ4.1 PR125.2 PR670.1 Q27.2 Q49.2 Q49.5 Q51.2 Q51.5 Q104.2 R181.1 R202.2 R262.2 R838.2 R843.1 R857.2 R880.2 R940.2 R944.2 R1033.2 R1034.2 R1038.2 R1041.2 R1056.2 R1058.2 R1060.2 R1063.2 R1187.2 R1188.2
+3V_DEEP_SUS: C466.2 C473.2 C526.1 C664.1 R290.2 R315.2 R321.2 R328.2 R329.2 R345.2 R375.2 R415.2 R437.2 R508.2 R510.2 R511.1 R524.2 R553.2 R558.2 R562.2 R579.2 R924.2 R932.2 R937.2 R953.2 R955.2 R958.2 R964.2 R969.2 R970.2 R974.2 R975.2 R980.2 R983.2 R986.2 R987.2 R989.2 R991.2 R1006.2 R1010.2 R1019.2 R1023.2 R1053.2 R1061.2 U12.5(VCC) U25.5(VCC) U28.5(VCC) U30.5(VCC) U41.5(VCC) U49.AA18 U49.AG18 U49.AM37 U49.AP19 U49.AP22 U49.AP24 U49.AT35 U49.AU24 U49.V18
+3V_DP: C554.1 C555.1 C556.1 C557.1 C558.1 C858.1 C859.1 C860.1 CN24.20 R640.2 R655.1 R656.1 R657.1 R661.2 R664.1 R671.2 R677.1 R1179.1 R1181.1 R1183.1 R1185.1 U56.1 U56.6 U56.20 U56.28(VCC#4)
+3V_DVDD: C439.2 C441.2 L11.2 R398.1 R425.1 U20.3
+3V_DVDD_IO: C775.2 C776.2 L20.2 U20.18
+3V_EC: C434.1 R413.2 R436.2 U23.11
+3V_EDPMUX: C1.1 C2.1 C3.1 C4.1 C5.1 C7.1 C8.1 C9.1 C10.1 C596.2 R16.2 R17.2 R18.2 R25.2 R35.2 R36.2 R37.2 U36.3 U36.12 U36.23 U36.26 U36.29 U36.32(VDD#6) U37.16
+3V_HDD_REDRIVER: C535.1 C536.1 C836.1 C838.1 C845.1 R1135.2 R1141.2 R1145.2 R1153.2 R1156.2 R1164.2 R1167.2 R1169.2 U55.6 U55.16(VDD#2)
+3V_HDMI: C784.1 C785.1 C786.1 C787.1 C788.1 C797.1 C798.1 C799.1 C800.1 C801.1 C802.1 C803.1 Q52.2 R527.2 R552.2 R561.2 R569.1 R591.2 U27.3 U27.6 U27.9 U27.12 U27.15 U27.24 U27.27 U27.30 U27.33(VCC_9) U27.36
+3V_LDO_EC: D34.1(CATHODE) PR96.2 PR272.2 PR273.2 PR427.2 R317.2 R336.2 R337.2 R338.1 R358.2 R361.2 R438.1 R458.2 R612.2 R1027.2
+3V_RTC: C807.2 C808.2 C837.1 D71.3(CATHODE) R584.2 R616.2 R1103.1 R1105.2 R1116.1 U49.BF46 U49.BG46 U49.BG47
+3V_S5: C391.1 C402.2 C444.2 C552.1 C814.1 C815.1 C824.2 PC4.2 PC98.1 PC150.1 PC399.1 PR3.2 PR10.1 PR23.1 PR39.1 PR40.1 PR42.2 PR55.1 PR60.1 PR80.1 PR118.2 PR152.1 PR215.2 PR216.2 PR271.1 PR284.1 PR348.1 PR515.2 PR531.2 PR566.1 PR609.1 PR642.1 PR664.1 PR665.1 PR667.1 PU2.27(VCC) PU7.12 PU8.12 PU9.9(VCC) Q10.2 Q10.5 Q18.1(S) Q41.1(S) Q57.2 Q60.1(S) R32.1 R110.1 R111.1 R136.1 R151.2 R228.1 R318.2 R319.1 R349.1 R367.1 R368.1 R374.1 R379.1 R408.1 R414.1 R416.1 R459.2 R577.1 R580.2 R614.1 R620.2 R630.1 R637.2 R638.2 R648.2 R742.1 R798.1 R828.1 R830.1 R831.1 R1061.1 R1067.2 R1073.2 R1080.1 R1082.1 R1139.2 R1140.2 R1194.2 R1209.2 U17.1 U19.1 U49.BD48 U49.BD49 U49.BE49
+3V_SSD1: C223.1 C240.2 C323.2 C342.2 C363.2 C364.2 C365.2 C366.2 C734.2 C735.1 C736.1 CN6.2 CN6.4 CN6.12 CN6.14 CN6.16 CN6.18 CN6.70 CN6.72 CN6.74 R339.1
+3V_SSD2: C411.2 C412.2 C517.2 C769.1 C770.1 C771.2 C811.1 C816.2 C820.2 C827.2 C830.2 CN13.2 CN13.4 CN13.12 CN13.14 CN13.16 CN13.18 CN13.70 CN13.72 CN13.74 R427.1
+3V_SUS: C698.1 C699.1 CN4.4 L19.1 PQ29.1(S) PR297.1 Q40.2 Q40.5 R395.2 R396.2
+3V_TCSS: C35.1 C39.1 R75.2 R76.2 R739.2 R742.2 U2.5(VCC) U3.5(VCC)
+3V_THM: C564.1 Q75.2 Q75.5 R12.1 R684.1 R699.1 R704.1 U35.1(VCC)
+3V_THM2: C693.1 Q103.2 Q103.5 R13.1 R822.1 R825.2 R827.2 U46.1(VCC)
+3V_U3: C768.1 L19.2 R456.2 R462.2 R465.2 R485.1 R486.2 R494.1 R497.1 R981.1 U24.1 U24.18
+3VPCU: C23.1 C221.1 C222.1 C357.1 C358.1 C518.1 C519.2 C522.1 C527.1 C599.1 C705.1 C819.1 C823.2 C826.1 CN1.3 CN1.4 CN4.3 PJ5.1 PJ17.1 PQ29.3 PQ37.1(S) PQ70.1(S) PR58.2 PR112.1 PR182.1 PR264.2 PR265.2 PR266.2 PR267.2 PR273.1 PR293.2 PR326.2 PR330.2 PR336.2 PR341.1 PR342.1 PR655.2 PR668.1 R139.2 R162.1 R207.1 R341.1 R343.2 R578.2 R739.1 R1157.1 U8.12 U15.12
+3VPCU_EC: C374.1 C375.1 C425.1 C426.1 C491.1 C492.1 C516.1 L7.2 L14.1 R438.2 U23.26 U23.50 U23.92 U23.114 U23.121
