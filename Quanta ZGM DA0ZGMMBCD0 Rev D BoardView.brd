# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQSN0: length 72
  IN1 w0.127: v2(125.22,137.91) 125.06,138.07 125.06,138.26 124.74,138.57 122.93,138.57 119.21,134.85 119.21,121.83 117.56,120.19 117.56,114.33 118.82,113.07 118.82,106.01 119.09,105.74 119.44,105.74 119.56,105.61 119.56,105.36 119.44,105.23 119.09,105.23 118.82,104.96 118.82,104.51 119.09,104.24 119.39,104.24 119.51,104.11 119.51,103.86 119.39,103.73 119.09,103.73 118.82,103.46 118.82,103.01 119.09,102.74 119.43,102.74 119.56,102.62 119.56,102.36 119.43,102.23 119.09,102.23 118.82,101.97 118.82,99.64 119.61,98.85 119.61,92.91 123.69,88.83 123.69,87.05 123.96,86.78 124.4,86.78 v1(124.53,86.65)
  BOTTOM w0.102: U42.CP17 129.34,138.65 129.34,138.44 129.11,138.21 126.76,138.21 126.3,138.67 125.3,138.67 125.02,138.39 125.02,138.11 v2(125.22,137.91)
  BOTTOM w0.152: JDIM2.11 123.78,88.53 123.71,88.47 123.71,87.12 124.01,86.81 124.37,86.81 v1(124.53,86.65)
M_A_DQSN1: length 65.9
  IN1 w0.127: v2(124.33,132.56) 124.1,132.78 123.87,132.78 123.74,132.65 123.74,123.79 128.49,119.04 128.49,114.96 125.81,112.28 125.81,100.81 126.67,99.95 126.67,91.91 129.07,89.52 129.07,86.15 129.92,85.3 129.92,83.98 129.59,83.65 128.97,83.65 128.8,83.48 v1(128.8,83.4)
  BOTTOM w0.079: 126.39,135.07 126.41,135.07 126.44,135.09 128.98,135.09 129.2,135.3 129.2,135.48 129.28,135.56 U42.CP12
  BOTTOM w0.102: 126.39,135.07 126.17,135.07 125.41,134.31 125.41,133.27 124.98,132.84 124.61,132.84 v2(124.33,132.56)
  BOTTOM w0.152: JDIM2.32 129.03,82.21 129.33,82.52 129.33,83.55 129.11,83.77 128.95,83.77 128.8,83.62 v1(128.8,83.4)
M_A_DQSN2: length 57
  IN1 w0.127: v2(129.63,126.02) 129.82,126.21 130.02,126.21 130.14,126.08 130.14,124.53 130.52,124.15 130.52,123.97 129.8,123.26 129.8,122.88 130.12,122.56 130.5,122.56 131.22,123.27 131.4,123.27 132.07,122.6 132.07,122.32 131.52,121.78 131.52,121.21 132.07,120.66 132.07,113.08 131.8,112.81 131.8,111.44 131.67,111.31 131.47,111.31 131.2,111.04 131.2,110.59 131.47,110.32 131.67,110.32 131.8,110.2 131.8,109.94 131.67,109.81 131.47,109.81 131.4,109.74 131.2,109.55 131.2,109.09 131.47,108.82 131.67,108.82 131.8,108.7 131.8,100.28 132.27,99.81 132.27,93.2 134.24,91.23 134.24,89.9 134.51,89.63 135.02,89.63 135.15,89.5 135.15,89.25 135.02,89.12 134.51,89.12 134.24,88.85 134.24,87.28 134.65,86.87 135.22,86.87 v1(135.4,86.69)
  BOTTOM w0.079: 130.72,127.88 130.72,127.9 130.69,127.92 130.69,129.43 130.52,129.61 130.29,129.61 130.21,129.69 U42.CN3
  BOTTOM w0.102: v2(129.63,126.02) 129.63,126.06 129.79,126.22 130.19,126.22 130.72,126.74 130.72,127.88
  BOTTOM w0.152: JDIM2.53 134.28,87.16 134.6,86.83 135.26,86.83 v1(135.4,86.69)
M_A_DQSN3: length 54.9
  IN1 w0.127: v1(140.28,84.39) 140.28,84.16 140.15,84.04 139.89,84.04 139.76,84.16 139.76,85.84 140.76,86.84 140.76,92.79 137.69,95.86 137.69,104.74 136.13,106.3 136.13,125.77 135.24,126.66 135,126.66 v1(134.8,126.86)
  BOTTOM w0.102: v1(134.8,126.86) 134.8,126.84 134.6,126.64 134.38,126.64 133.95,127.07 133.95,130.15 133.77,130.33 133.6,130.33 U42.CH4
  BOTTOM w0.152: JDIM2.74 139.53,83.79 139.87,84.14 140.09,84.14 140.28,84.32 v1(140.28,84.39)
M_A_DQSN4: length 55
  IN1 w0.127: v2(159.88,126.59) 159.88,126.6 159.75,126.72 159.55,126.72 159.36,126.53 159.36,125.94 159.99,125.31 159.99,123.64 160.85,122.77 160.85,111.49 164.61,107.73 164.61,107.37 165.04,106.94 165.04,106.48 164.61,106.05 164.61,105.8 164.74,105.67 164.85,105.67 165.11,105.4 165.11,104.95 164.85,104.68 164.74,104.68 164.61,104.55 164.61,96.21 166.89,93.93 166.89,90.13 167.08,89.94 167.88,89.94 168.22,89.6 168.22,88.92 168.85,88.28 168.85,87.22 168.54,86.9 168.18,86.9 168.02,86.74 v1(168.02,86.7)
  BOTTOM w0.102: U42.AF4 160.63,130.37 160.85,130.37 161.08,130.14 161.08,127.12 160.72,126.76 160.08,126.76 159.91,126.59 v2(159.88,126.59)
  BOTTOM w0.152: v1(168.02,86.7) 167.85,86.86 167.47,86.86 167.16,87.17 167.16,88.42 167.28,88.53 JDIM2.177
M_A_DQSN5: length 56.6
  IN1 w0.127: v1(164.64,126.31) 164.49,126.16 164.22,126.16 163.95,125.89 163.95,124.74 164.43,124.26 164.43,112.97 170.34,107.07 170.34,99.15 170.49,98.99 170.49,95.39 174.01,91.88 174.01,84.17 173.81,83.96 173.59,83.96 173.51,84.05 v1(173.51,84.16)
  BOTTOM w0.102: U42.Y4 163.82,130.46 164,130.29 164.18,130.29 164.42,130.05 164.42,128.27 163.89,127.74 163.89,126.34 164.11,126.12 164.44,126.12 v1(164.64,126.31)
  BOTTOM w0.152: JDIM2.198 172.53,82.43 172.65,82.56 172.65,83.54 172.98,83.86 173.34,83.86 173.51,84.03 v1(173.51,84.16)
M_A_DQSN6: length 57
  IN1 w0.127: v1(168.35,126.31) 168.59,126.07 168.8,126.07 169.11,125.75 169.11,114.05 177.31,105.85 177.31,105.24 177.04,104.98 176.56,104.98 176.44,104.85 176.44,104.6 176.56,104.47 177.04,104.47 177.31,104.2 177.31,96.58 177.04,96.31 176.63,96.31 176.5,96.18 176.5,95.93 176.63,95.8 177.04,95.8 177.31,95.53 177.31,94.33 178.96,92.67 178.96,90.7 179.18,90.49 179.18,89.89 178.96,89.68 178.96,89.3 179.09,89.17 179.33,89.17 179.6,88.91 179.6,87.03 179.33,86.76 178.86,86.76 178.77,86.67 v1(178.77,86.62)
  BOTTOM w0.102: U42.R4 167.33,130.35 167.54,130.35 167.76,130.13 167.76,127.41 167.66,127.31 167.66,126.75 167.68,126.73 167.68,126.68 167.71,126.65 167.71,126.63
  BOTTOM w0.152: JDIM2.219 177.78,87.14 178.13,86.79 178.6,86.79 v1(178.77,86.62) ; 168.15,126.1 167.82,126.1 167.71,126.21
  BOTTOM w0.165: 168.15,126.1 v1(168.35,126.31) ; 167.71,126.63 167.71,126.21
M_A_DQSN7: length 58.7
  IN1 w0.127: v2(172.79,126.94) 173.02,126.72 173.24,126.72 173.5,126.45 173.5,120.92 172.99,120.41 172.99,115.58 183.83,104.75 183.83,101.3 183.12,100.6 183.12,94.07 184.46,92.73 184.46,85.95 184.01,85.5 183.79,85.5 183.45,85.16 183.45,84.27 183.58,84.14 183.82,84.14 183.95,84.27 v1(183.95,84.31)
  BOTTOM w0.102: v2(172.79,126.94) 172.59,126.74 172.08,126.74 171.06,127.75 171.06,130.06 170.84,130.28 170.57,130.28 170.5,130.35 U42.K4
  BOTTOM w0.152: v1(183.95,84.31) 183.67,84.03 183.46,84.03 183.15,83.73 183.15,82.56 183.03,82.43 JDIM2.240
M_A_DQSN8: length 4.2
  TOP w0.203: R213.2 144.18,86.1 v1(144.22,86.15)
  BOTTOM w0.14: v1(144.22,86.15) 144.78,86.7 JDIM2.95
M_A_DQSP0: length 72
  IN1 w0.127: v1(124.55,87.44) 124.55,87.24 124.33,87.02 124.06,87.02 123.94,87.15 123.94,88.93 119.85,93.01 119.85,98.95 119.06,99.74 119.06,101.87 119.19,101.99 119.53,101.99 119.8,102.26 119.8,102.72 119.53,102.98 119.19,102.98 119.06,103.11 119.06,103.36 119.19,103.49 119.49,103.49 119.75,103.76 119.75,104.21 119.49,104.48 119.19,104.48 119.06,104.61 119.06,104.86 119.19,104.99 119.54,104.99 119.8,105.26 119.8,105.71 119.54,105.98 119.19,105.98 119.06,106.11 119.06,113.17 117.8,114.43 117.8,120.09 119.45,121.73 119.45,134.75 123.03,138.33 124.64,138.33 124.82,138.16 124.82,138.06 124.67,137.91 v2(124.44,137.91)
  BOTTOM w0.102: U42.CR17 128.89,138.85 129.04,138.85 129.14,138.75 129.14,138.52 129.02,138.41 126.85,138.41 126.38,138.88 125.22,138.88 124.81,138.47 124.81,137.92 124.7,137.8 124.55,137.8 v2(124.44,137.91)
  BOTTOM w0.152: v1(124.55,87.44) 124.55,87.23 124.37,87.05 124.11,87.05 123.95,87.22 123.95,88.37 124.28,88.69 JDIM2.13
M_A_DQSP1: length 65.9
  IN1 w0.127: v1(128.77,84.23) 128.77,84.08 128.95,83.89 129.49,83.89 129.68,84.08 129.68,85.2 128.83,86.05 128.83,89.42 126.43,91.81 126.43,99.85 125.57,100.71 125.57,112.38 128.24,115.06 128.24,118.94 123.5,123.69 123.5,132.75 123.77,133.02 124.03,133.02 124.31,133.29 v2(124.32,133.29)
  BOTTOM w0.079: U42.CR12 128.96,135.56 129.04,135.48 129.04,135.37 128.92,135.25 126.44,135.25 126.41,135.27 126.39,135.27
  BOTTOM w0.102: v2(124.32,133.29) 124.33,133.29 124.57,133.05 124.9,133.05 125.2,133.35 125.2,134.39 126.08,135.27 126.39,135.27
  BOTTOM w0.152: v1(128.77,84.23) 128.98,84.01 129.21,84.01 129.57,83.65 129.57,82.42 129.53,82.37 JDIM2.34
M_A_DQSP2: length 56.9
  IN1 w0.127: v1(129.63,126.78) 129.63,126.61 129.79,126.45 130.12,126.45 130.39,126.18 130.39,124.63 130.76,124.25 130.76,123.87 130.04,123.16 130.04,122.98 130.22,122.8 130.4,122.8 131.12,123.51 131.5,123.51 132.31,122.7 132.31,122.22 131.76,121.68 131.76,121.31 132.31,120.76 132.31,112.98 132.04,112.71 132.04,111.34 131.77,111.07 131.57,111.07 131.44,110.94 131.44,110.69 131.57,110.56 131.77,110.56 132.04,110.3 132.04,109.84 131.77,109.57 131.57,109.57 131.44,109.45 131.44,109.19 131.57,109.06 131.77,109.06 132.04,108.8 132.04,100.38 132.51,99.91 132.51,93.3 134.48,91.33 134.48,90 134.61,89.87 135.12,89.87 135.39,89.6 135.39,89.15 135.12,88.88 134.61,88.88 134.48,88.75 134.48,87.38 134.75,87.11 135.24,87.11 135.36,87.24 v1(135.36,87.48)
  BOTTOM w0.079: 130.51,127.88 130.51,127.9 130.53,127.92 130.53,129.37 130.45,129.45 130.28,129.45 130.21,129.38 U42.CN2
  BOTTOM w0.102: 130.51,127.88 130.51,126.83 130.1,126.42 129.68,126.42 129.57,126.52 129.57,126.72 v1(129.63,126.78)
  BOTTOM w0.152: v1(135.36,87.48) 135.38,87.47 135.38,87.25 135.2,87.07 134.7,87.07 134.52,87.26 134.52,88.39 134.78,88.65 JDIM2.55
M_A_DQSP3: length 54.9
  IN1 w0.127: v2(134.8,126.21) 135,126.41 135.14,126.41 135.89,125.67 135.89,106.2 137.45,104.64 137.45,95.76 140.51,92.69 140.51,86.94 139.52,85.94 139.52,84.06 139.79,83.8 140.08,83.8 v1(140.36,83.51)
  BOTTOM w0.102: v2(134.8,126.21) 134.56,126.44 134.29,126.44 133.74,126.99 133.74,130.06 133.68,130.12 133.55,130.12 133.41,129.99 U42.CH3
  BOTTOM w0.152: v1(140.36,83.51) 140.36,83.74 140.21,83.89 139.97,83.89 139.77,83.69 139.77,82.69 140.03,82.43 JDIM2.76
M_A_DQSP4: length 55
  IN1 w0.127: v1(168.02,87.52) 168.02,87.27 168.15,87.14 168.44,87.14 168.61,87.32 168.61,88.18 167.98,88.82 167.98,89.5 167.78,89.7 166.98,89.7 166.65,90.03 166.65,93.83 164.37,96.11 164.37,104.65 164.64,104.92 164.75,104.92 164.87,105.05 164.87,105.3 164.75,105.43 164.64,105.43 164.37,105.7 164.37,106.15 164.8,106.58 164.8,106.83 164.37,107.27 164.37,107.63 160.61,111.39 160.61,122.67 159.74,123.54 159.74,125.21 159.12,125.84 159.12,126.63 159.45,126.96 159.74,126.96 159.88,127.1 v1(159.88,127.24)
  BOTTOM w0.102: U42.AF3 160.46,129.89 160.46,130.07 160.56,130.17 160.77,130.17 160.88,130.06 160.88,127.21 160.63,126.96 159.98,126.96 159.88,127.07 v1(159.88,127.24)
  BOTTOM w0.152: v1(168.02,87.52) 168.02,87.26 167.87,87.1 167.57,87.1 167.41,87.27 167.41,88.32 167.78,88.69 JDIM2.179
M_A_DQSP5: length 56.6
  IN1 w0.127: v2(164.64,125.66) 164.64,125.78 164.5,125.92 164.32,125.92 164.19,125.79 164.19,124.84 164.68,124.36 164.68,113.07 170.58,107.17 170.58,99.25 170.74,99.09 170.74,95.49 174.25,91.98 174.25,84.07 173.91,83.72 173.69,83.72 173.51,83.54 v1(173.51,83.33)
  BOTTOM w0.102: v2(164.64,125.66) 164.64,125.81 164.53,125.92 164.53,125.91 164.02,125.91 163.68,126.25 163.68,127.82 164.22,128.36 164.22,129.96 164.09,130.09 163.93,130.09 163.82,129.99 U42.Y3
  BOTTOM w0.152: JDIM2.200 173.03,82.43 172.9,82.56 172.9,83.44 173.08,83.62 173.35,83.62 173.51,83.47 v1(173.51,83.33)
M_A_DQSP6: length 56.9
  IN1 w0.127: v1(178.77,87.44) 178.72,87.4 178.72,87.22 178.94,87 179.23,87 179.36,87.13 179.36,88.81 179.23,88.93 178.99,88.93 178.72,89.2 178.72,89.78 178.94,89.99 178.94,90.39 178.72,90.6 178.72,92.57 177.07,94.23 177.07,95.43 176.94,95.56 176.53,95.56 176.26,95.83 176.26,96.28 176.53,96.55 176.94,96.55 177.07,96.68 177.07,104.1 176.94,104.23 176.46,104.23 176.19,104.5 176.19,104.95 176.46,105.22 176.94,105.22 177.07,105.34 177.07,105.75 168.87,113.95 168.87,125.65 168.7,125.82 168.52,125.82 168.39,125.7 v1(168.39,125.55)
  BOTTOM w0.102: U42.R3 167.16,130.04 167.26,130.14 167.45,130.14 167.55,130.04 167.55,127.49 167.46,127.4 167.46,126.65 167.44,126.63
  BOTTOM w0.152: v1(168.39,125.55) 168.39,125.67 168.22,125.84 168.04,125.84 168.04,125.85 167.71,125.85 167.61,125.95 167.6,125.95 167.45,126.1 167.45,126.17 167.44,126.18 167.44,126.21 ; v1(178.77,87.44) 178.79,87.42 178.79,87.18 178.64,87.03 178.23,87.03 178.02,87.24 178.02,88.21 178.28,88.47 JDIM2.221
  BOTTOM w0.165: 167.44,126.63 167.44,126.21
M_A_DQSP7: length 58.7
  IN1 w0.127: v2(172.79,126.28) 172.98,126.48 173.14,126.48 173.26,126.35 173.26,121.02 172.75,120.51 172.75,115.48 183.59,104.64 183.59,101.4 182.88,100.7 182.88,93.97 184.22,92.63 184.22,86.05 183.91,85.74 183.69,85.74 183.21,85.26 183.21,84.17 183.48,83.9 183.87,83.9 184,83.77 184,83.53 v1(183.95,83.49)
  BOTTOM w0.102: U42.K3 170.5,130.03 170.54,130.08 170.75,130.08 170.86,129.97 170.86,127.67 171.99,126.53 172.54,126.53 v2(172.79,126.28)
  BOTTOM w0.152: JDIM2.242 183.53,82.43 183.4,82.56 183.4,83.63 183.56,83.79 183.79,83.79 183.95,83.63 v1(183.95,83.49)
M_A_DQSP8: length 3.9
  TOP w0.14: R190.2 145.32,88.43 145.32,88.4 145.31,88.4 145.31,88.01 145.32,88.01 145.32,87.97 v1(145.73,87.56)
  BOTTOM w0.14: v1(145.73,87.56) 145.73,87.56 145.28,88.02 JDIM2.97
M_A_PARITY: length 57.9
  IN1 w0.127: v2(148.43,128.24) 148.53,128.14 148.73,128.14 149.02,128.42 149.22,128.42 149.45,128.19 149.45,128.01 149.1,127.66 149.1,127.13 149.23,127.01 149.48,127.01 149.61,126.88 149.61,126.62 149.48,126.5 149.23,126.5 149.1,126.37 149.1,126.12 149.23,125.99 149.48,125.99 149.61,125.86 149.61,125.61 149.48,125.48 149.23,125.48 149.1,125.35 149.1,125.1 149.23,124.97 149.48,124.97 149.61,124.85 149.61,124.59 149.48,124.47 149.23,124.47 149.1,124.34 149.1,124.08 149.23,123.96 149.48,123.96 149.61,123.83 149.61,123.58 149.48,123.45 149.23,123.45 149.1,123.32 149.1,123.07 149.23,122.94 149.48,122.94 149.61,122.81 149.61,122.56 149.48,122.43 149.23,122.43 149.1,122.31 149.1,122.05 149.23,121.93 149.48,121.93 149.61,121.8 149.61,121.54 149.48,121.42 149.23,121.42 149.1,121.29 149.1,121.04 149.23,120.91 149.48,120.91 149.61,120.78 149.61,120.53 149.48,120.4 149.23,120.4 149.1,120.27 149.1,120.02 149.23,119.89 149.48,119.89 149.61,119.77 149.61,119.51 149.48,119.39 149.23,119.39 149.1,119.26 149.1,119 149.23,118.88 149.48,118.88 149.61,118.75 149.61,118.5 149.48,118.37 149.23,118.37 149.1,118.24 149.1,117.99 149.23,117.86 149.48,117.86 149.61,117.73 149.61,117.48 149.48,117.35 149.23,117.35 149.1,117.23 149.1,116.97 149.23,116.85 149.48,116.85 149.61,116.72 149.61,116.46 149.48,116.34 149.23,116.34 149.1,116.21 149.1,115.96 149.23,115.83 149.48,115.83 149.61,115.7 149.61,115.45 149.48,115.32 149.23,115.32 149.1,115.19 149.1,114.94 149.23,114.81 149.48,114.81 149.61,114.69 149.61,114.43 149.48,114.31 149.23,114.31 149.1,114.18 149.1,113.92 149.23,113.8 149.48,113.8 149.61,113.67 149.61,113.42 149.48,113.29 149.23,113.29 149.1,113.16 149.1,112.44 154.41,107.13 154.41,101.85 154,101.45 154,95.21 158.45,90.77 158.45,89.16 v1(158.2,88.91)
  BOTTOM w0.102: U42.BE1 148.1,128.56 v2(148.43,128.24)
  BOTTOM w0.216: v1(158.2,88.91) 157.93,88.63 156.99,88.63 156.78,88.85 JDIM2.143
M_A_RAS#: length 59.7
  IN1 w0.127: v1(161.03,82.74) 160.55,83.21 160.55,83.64 160.32,83.87 160.32,84.15 160.55,84.38 160.55,85.18 160.02,85.72 160.02,88.19 160.17,88.34 160.17,90.36 160.17,91.58 156.94,94.81 156.94,95.56 156.81,95.69 156.55,95.69 156.42,95.82 156.42,96.07 156.55,96.2 156.81,96.2 156.94,96.32 156.94,96.58 156.81,96.71 156.55,96.71 156.42,96.84 156.42,97.09 156.55,97.21 156.81,97.21 156.94,97.34 156.94,100.2 156.67,100.47 156.67,107.31 151.71,112.28 151.71,115.97 151.84,116.1 151.99,116.1 152.11,116.22 152.11,116.48 151.99,116.6 151.84,116.6 151.71,116.73 151.71,116.99 151.84,117.11 151.99,117.11 152.11,117.24 152.11,117.49 151.99,117.62 151.84,117.62 151.71,117.75 151.71,118 151.84,118.13 151.99,118.13 152.11,118.26 152.11,118.51 151.99,118.64 151.84,118.64 151.71,118.76 151.71,119.02 151.84,119.14 151.99,119.14 152.11,119.27 152.11,119.53 151.99,119.65 151.84,119.65 151.71,119.78 151.71,120.03 151.84,120.16 151.99,120.16 152.11,120.29 152.11,120.54 151.99,120.67 151.84,120.67 151.71,120.8 151.71,121.05 151.84,121.18 151.99,121.18 152.11,121.3 152.11,121.56 151.99,121.68 151.84,121.68 151.71,121.81 151.71,122.07 151.84,122.19 151.99,122.19 152.11,122.32 152.11,122.57 151.99,122.7 151.84,122.7 151.71,122.83 151.71,123.08 151.84,123.21 151.99,123.21 152.11,123.34 152.11,123.59 151.99,123.72 151.84,123.72 151.71,123.84 151.71,124.1 151.84,124.22 151.99,124.22 152.11,124.35 152.11,124.61 151.99,124.73 151.84,124.73 151.71,124.86 151.71,125.11 151.84,125.24 151.99,125.24 152.11,125.37 152.11,125.62 151.99,125.75 151.84,125.75 151.71,125.88 151.71,126.13 151.84,126.26 151.93,126.26 152.06,126.38 152.06,126.64 151.93,126.76 151.6,126.76 151.3,127.06 151.3,127.73 v2(150.95,128.08)
  BOTTOM w0.102: U42.AY2 150.68,128.9 150.68,128.29 150.89,128.08 v2(150.95,128.08)
  BOTTOM w0.216: v1(161.03,82.74) JDIM2.152
M_A_WE#: length 61.1
  IN1 w0.127: v1(161.75,86.7) 162.07,86.7 162.19,86.83 162.19,92 159.55,94.65 159.55,95.23 159.42,95.36 159.27,95.36 159.14,95.48 159.14,95.74 159.27,95.87 159.42,95.87 159.55,95.99 159.55,96.25 159.42,96.37 159.27,96.37 159.14,96.5 159.14,96.75 159.27,96.88 159.42,96.88 159.55,97.01 159.55,106.88 154.93,111.5 154.93,112.96 155.06,113.09 155.68,113.09 155.81,113.21 155.81,113.47 155.68,113.59 155.06,113.59 154.93,113.72 154.93,113.97 155.06,114.1 155.68,114.1 155.81,114.23 155.81,114.48 155.68,114.61 155.06,114.61 154.93,114.74 154.93,114.99 155.06,115.12 155.68,115.12 155.81,115.24 155.81,115.5 155.68,115.63 155.06,115.63 154.93,115.75 154.93,116.01 155.06,116.13 155.68,116.13 155.81,116.26 155.81,116.51 155.68,116.64 155.06,116.64 154.93,116.77 154.93,117.02 155.06,117.15 155.68,117.15 155.81,117.28 155.81,117.53 155.68,117.66 155.06,117.66 154.93,117.78 154.93,118.04 155.06,118.17 155.68,118.17 155.81,118.29 155.81,118.55 155.68,118.67 155.06,118.67 154.93,118.8 154.93,119.05 155.06,119.18 155.68,119.18 155.81,119.31 155.81,119.56 155.68,119.69 155.06,119.69 154.93,119.82 154.93,120.07 155.06,120.2 155.41,120.2 155.54,120.32 155.54,120.58 155.41,120.71 155.06,120.71 154.93,120.83 154.93,122.73 154.6,123.06 154.6,127.7 v2(154.34,127.96)
  BOTTOM w0.102: U42.AR1 154.72,128.34 v2(154.34,127.96)
  BOTTOM w0.216: JDIM2.151 160.78,88.65 160.94,88.48 160.94,87.51 v1(161.75,86.7)
M_B_A0: length 49.5
  IN4 w0.102: 149.78,128.17 150.34,128.73 150.34,131 149.58,131.76 149.58,132.86 149.37,133.07 148.91,133.07 v2(148.44,133.53)
  IN4 w0.127: v1(157.79,97.49) 157.53,97.74 157.27,97.74 157.14,97.61 157.14,96.56 157.34,96.36 158.95,96.36 159.07,96.48 159.07,96.75 158.95,96.88 158.53,96.88 158.36,97.05 158.36,97.78 158.28,97.86 158.28,98.5 157.93,98.84 157.93,99.89 158.15,100.1 158.15,100.4 157.93,100.62 157.93,100.9 158.15,101.12 158.15,106.06 150.12,114.09 150.12,121.23 149.81,121.54 149.81,121.86 150.12,122.17 150.12,125.06 149.78,125.39 149.78,128.17
  BOTTOM w0.102: U42.BE9 148.04,133.63 148.15,133.53 v2(148.44,133.53)
  BOTTOM w0.216: v1(157.79,97.49) 157.51,97.49 157.08,97.05 JDIM1.144
M_B_A1: length 49.6
  IN4 w0.127: v2(146.24,131.53) 146.63,131.14 146.89,131.14 147.02,131.02 147.02,130.76 146.89,130.63 146.72,130.63 146.53,130.44 146.03,130.44 145.91,130.31 145.91,130.05 146.03,129.93 146.49,129.93 146.61,129.81 146.84,129.81 147.01,129.64 147.01,129.46 146.85,129.29 146.74,129.29 146.62,129.17 146.62,128.54 146.75,128.41 147.25,128.41 147.38,128.28 147.38,127.51 147.25,127.38 146.95,127.38 146.83,127.26 146.83,127 146.95,126.88 147.26,126.88 147.38,126.75 147.38,126.5 147.26,126.37 146.92,126.37 146.79,126.24 146.79,125.99 146.92,125.86 147.2,125.86 147.35,125.71 147.35,125.36 147.23,125.23 146.38,125.23 146.25,125.11 146.25,124.63 146.08,124.46 146.08,124.28 146.61,123.75 146.61,120.45 146.49,120.32 146.01,120.32 145.88,120.2 145.88,119.94 146.01,119.82 146.49,119.82 146.61,119.69 146.61,119.44 146.49,119.31 146,119.31 145.87,119.18 145.87,118.93 146,118.8 146.49,118.8 146.61,118.67 146.61,118.24 146.49,118.11 146,118.11 145.87,117.99 145.87,117.73 146,117.61 146.49,117.61 146.61,117.48 146.61,117.23 146.49,117.1 146,117.1 145.87,116.97 145.87,116.72 146,116.59 146.49,116.59 146.61,116.46 146.61,116.21 146.49,116.08 146,116.08 145.87,115.96 145.87,115.7 146,115.57 146.49,115.57 146.61,115.45 146.61,115.16 146.49,115.04 146.31,115.04 146.15,114.88 146.15,114.7 155.77,105.08 155.77,104.8 155.56,104.59 155.56,104.28 155.77,104.07 155.77,103.86 155.56,103.65 155.56,103.25 155.77,103.04 155.77,102.26 155.65,102.13 v1(155.36,102.13)
  BOTTOM w0.102: v2(146.24,131.53) U42.BH6
  BOTTOM w0.216: JDIM1.133 154.33,103.43 154.49,103.26 154.49,102.57 154.92,102.13 v1(155.36,102.13)
M_B_A2: length 49.5
  IN4 w0.102: 147.4,129.79 147.4,131.26 147.1,131.55 v2(146.99,131.55)
  IN4 w0.127: v1(155.1,98.83) 154.9,98.83 154.64,98.56 154.64,97.05 154.94,96.75 156.56,96.75 156.71,96.89 156.71,97.15 156.58,97.28 155.96,97.28 155.76,97.48 155.76,100.36 155.92,100.52 156.08,100.52 156.21,100.65 156.21,100.9 156.08,101.03 155.92,101.03 155.79,101.16 155.79,101.45 155.92,101.57 156.08,101.57 156.21,101.7 156.21,105.26 147.04,114.42 147.04,123.93 146.68,124.29 146.68,124.29 146.68,124.68 146.81,124.8 147.6,124.8 147.79,124.99 147.79,128.89 147.4,129.28 147.4,129.79
  BOTTOM w0.102: v2(146.99,131.55) 146.82,131.55 146.63,131.75 U42.BG6
  BOTTOM w0.216: JDIM1.132 154.08,97.81 v1(155.1,98.83)
M_B_A3: length 48
  IN4 w0.102: 144.83,127.47 144.83,127.92 144.63,128.12 144.63,133.34 144.43,133.54 v2(144.06,133.54)
  IN4 w0.127: 144.83,127.47 144.83,125.27 144.36,124.8 144.36,115.69 144.23,115.57 143.64,115.57 143.52,115.44 143.52,115.16 143.66,115.02 144.23,115.02 144.36,114.89 144.36,114.64 144.23,114.51 143.66,114.51 143.52,114.38 143.52,114.09 143.64,113.97 144.75,113.97 144.91,113.8 144.91,113.52 144.79,113.4 143.64,113.4 143.52,113.27 143.52,112.87 143.64,112.74 144.85,112.74 145.07,112.96 145.25,112.96 145.5,112.71 145.68,112.71 145.75,112.78 145.93,112.78 146.11,112.6 146.11,112.42 146.04,112.35 146.04,112.17 146.22,111.99 146.4,111.99 146.47,112.06 146.65,112.06 146.83,111.88 146.83,111.7 146.76,111.63 146.76,111.45 146.94,111.27 147.12,111.27 147.19,111.35 147.37,111.35 147.55,111.17 147.55,110.99 147.47,110.91 147.47,110.73 147.65,110.55 147.83,110.55 147.91,110.63 148.09,110.63 148.27,110.45 148.27,110.27 148.19,110.19 148.19,110.01 148.37,109.83 148.55,109.83 148.63,109.91 148.81,109.91 148.99,109.73 148.99,109.55 148.91,109.47 148.91,109.29 149.09,109.11 149.27,109.11 149.35,109.19 149.53,109.19 149.71,109.01 149.71,108.83 149.63,108.75 149.63,108.57 149.81,108.39 149.99,108.39 150.07,108.47 150.25,108.47 150.43,108.29 150.43,108.11 150.35,108.03 150.35,107.86 150.53,107.68 150.71,107.68 150.79,107.75 150.96,107.75 151.14,107.57 151.14,107.39 151.07,107.32 151.07,107.14 151.25,106.96 151.43,106.96 151.5,107.03 151.68,107.03 151.86,106.85 151.86,106.67 151.79,106.6 151.79,106.42 151.97,106.24 152.15,106.24 152.22,106.31 152.4,106.31 152.58,106.13 152.58,105.95 152.51,105.88 152.51,105.7 152.69,105.52 152.87,105.52 152.94,105.59 153.12,105.59 153.3,105.42 153.3,105.24 153.23,105.16 153.23,104.98 154.05,104.15 154.05,103.1 v1(153.99,103.04)
  BOTTOM w0.102: v2(144.06,133.54) 143.73,133.21 U42.BM8
  BOTTOM w0.216: JDIM1.131 153.83,103.23 153.99,103.07 v1(153.99,103.04)
M_B_A4: length 46.6
  IN4 w0.102: 143.5,124.17 143.5,124.41 143.64,124.56 143.64,131.47 143.74,131.57 v2(144.04,131.57)
  IN4 w0.127: v1(152.66,98.92) 152.93,98.92 153.14,98.7 153.14,97.71 153.31,97.54 153.6,97.54 153.77,97.71 153.77,98.89 153.14,99.52 153.14,103.84 148.09,108.9 145.15,111.83 143.06,111.83 142.65,112.24 142.65,117.4 142.78,117.52 143.36,117.52 143.5,117.66 143.5,124.17
  BOTTOM w0.102: v2(144.04,131.57) 143.69,131.91 U42.BM6
  BOTTOM w0.216: v1(152.66,98.92) 153.08,98.5 JDIM1.128
M_B_A5: length 48.4
  IN4 w0.102: v2(144.06,132.24) 144.42,131.88 144.42,125.55
  IN4 w0.127: 144.42,125.55 144.42,125.46 144.01,125.06 144.01,124.31 143.93,124.22 143.93,117.3 143.72,117.09 143.21,117.09 143.09,116.97 143.09,116.69 143.22,116.56 143.77,116.56 143.93,116.41 143.93,116.18 143.8,116.05 143.21,116.05 143.09,115.93 143.09,112.42 143.2,112.31 145.29,112.31 147.79,109.8 153.57,104.02 153.57,99.8 153.7,99.67 154.44,99.67 154.57,99.54 154.57,99.15 154.44,99.02 154.33,99.02 154.2,98.9 154.2,96.99 154.06,96.85 152.95,96.85 152.58,97.22 v1(152.58,97.6)
  BOTTOM w0.102: U42.BM7 143.73,132.56 v2(144.06,132.24)
  BOTTOM w0.216: v1(152.58,97.6) JDIM1.126
M_B_A6: length 42
  IN4 w0.102: 143.34,125.57 143.34,128.29 143.39,128.35 143.39,132.34 143.68,132.62 143.68,133.44 143.56,133.55 v2(143.29,133.55)
  IN4 w0.114: 143.34,125.38 143.34,125.57
  IN4 w0.127: 143.34,125.38 143.34,124.87 143.06,124.6 143.06,120.16 142.94,120.04 142.35,120.04 142.22,119.91 142.22,119.64 142.35,119.51 142.91,119.51 143.04,119.38 143.04,119.13 142.91,119 142.35,119 142.22,118.88 142.22,118.59 142.35,118.46 142.9,118.46 143.04,118.33 143.04,118.08 142.91,117.96 142.35,117.96 142.22,117.83 142.22,112.06 142.88,111.4 144.97,111.4 152.68,103.69 152.68,103.09 v1(152.71,103.06)
  BOTTOM w0.102: v2(143.29,133.55) 143.29,133.76 143.18,133.86 U42.BN9
  BOTTOM w0.216: v1(152.71,103.06) 152.71,103.09 152.83,103.2 JDIM1.127
M_B_A7: length 43.8
  IN4 w0.102: 138.81,128.59 139.2,128.97 139.2,132.49 v2(139.59,132.88)
  IN4 w0.127: 138.81,128.59 138.81,125.64 138.34,125.16 138.34,110.45 145.43,103.35 145.43,102.54 148.68,99.29 149.44,99.29 151.19,97.54 v1(151.36,97.54)
  BOTTOM w0.102: U42.BV8 139.62,132.88 v2(139.59,132.88)
  BOTTOM w0.216: JDIM1.122 151.58,97.33 v1(151.36,97.54)
M_B_A8: length 47.2
  IN4 w0.102: 143.02,125.09 143.02,128.42 143.15,128.55 143.15,132.49 142.9,132.73 142.9,134.07 143.21,134.37 143.87,134.37 v2(144.06,134.19)
  IN4 w0.127: 143.02,125.09 142.63,124.7 142.63,121.62 142.51,121.49 141.99,121.49 141.79,121.3 141.79,121.1 141.92,120.98 142.43,120.98 142.56,120.85 142.56,120.6 142.43,120.47 141.98,120.47 141.79,120.28 141.79,111.88 142.7,110.97 144.79,110.97 152.25,103.51 152.25,103.32 152.12,103.19 151.91,103.19 151.79,103.07 151.79,102.63 151.91,102.51 152.05,102.51 152.18,102.38 152.18,102.13 152.05,102 151.91,102 151.79,101.87 151.79,101.35 151.91,101.22 152.14,101.22 v1(152.66,101.74)
  BOTTOM w0.102: v2(144.06,134.19) 143.73,133.86 U42.BM9
  BOTTOM w0.216: v1(152.66,101.74) 152.61,101.79 152.58,101.79 152.16,102.21 152.16,103.17 152.33,103.33 JDIM1.125
M_B_A9: length 46.3
  IN4 w0.102: v2(142.52,134.19) 141.52,133.19 141.52,128.36 141.77,128.1 141.77,126.24 141.35,125.82
  IN4 w0.127: 141.35,125.82 140.9,125.38 140.9,122.86 140.06,122.01 140.06,111.16 144.72,106.51 144.99,106.51 145.35,106.88 145.97,106.88 147.13,105.71 147.6,105.71 149.47,103.85 150.03,103.29 150.03,101.68 149.63,101.28 149.63,101.03 149.78,100.88 149.96,100.88 150.47,101.4 v1(150.47,101.55)
  BOTTOM w0.102: U42.BP8 141.83,133.52 141.83,134 142.02,134.19 v2(142.52,134.19)
  BOTTOM w0.216: JDIM1.121 151.33,102.4 v1(150.47,101.55)
M_B_A10: length 54.4
  IN4 w0.127: v1(159.13,97.43) 158.91,97.43 158.79,97.55 158.79,97.96 158.71,98.04 158.71,98.71 158.37,99.05 158.37,99.66 158.58,99.87 158.58,106.24 151.33,113.49 151.33,114.37 151.2,114.5 150.68,114.5 150.55,114.63 150.55,114.97 150.68,115.1 151.2,115.1 151.33,115.23 151.33,115.47 151.19,115.61 150.68,115.61 150.55,115.73 150.55,115.99 150.68,116.11 151.2,116.11 151.33,116.24 151.33,116.49 151.2,116.62 150.68,116.62 150.55,116.75 150.55,117 150.68,117.13 151.2,117.13 151.33,117.26 151.33,117.5 151.19,117.64 150.68,117.64 150.55,117.77 150.55,118.02 150.68,118.15 151.2,118.15 151.33,118.27 151.33,118.5 151.18,118.65 150.68,118.65 150.55,118.78 150.55,119.04 150.68,119.16 151.2,119.16 151.33,119.29 151.33,119.54 151.2,119.67 150.68,119.67 150.55,119.8 150.55,120.05 150.68,120.18 151.17,120.18 151.3,120.31 151.3,120.56 151.17,120.69 150.68,120.69 150.55,120.81 150.55,121.07 150.68,121.19 151.19,121.19 151.32,121.32 151.32,121.58 151.19,121.7 150.68,121.7 150.54,121.84 150.54,122.07 150.68,122.21 151.19,122.21 151.32,122.34 151.32,122.59 151.19,122.72 150.68,122.72 150.55,122.85 150.55,123.1 150.68,123.23 151.19,123.23 151.31,123.35 151.31,123.61 151.19,123.73 150.68,123.73 150.55,123.86 150.55,124.12 150.68,124.24 151.09,124.24 151.21,124.37 151.21,124.59 151.05,124.75 150.68,124.75 150.53,124.9 150.53,125.26 150.16,125.63 150.16,126.09 150.16,128.22 150.63,128.69 150.63,131.06 149.85,131.84 149.85,132.13 v2(149.97,132.25)
  BOTTOM w0.102: U42.AY7 150.68,132.25 v2(149.97,132.25)
  BOTTOM w0.216: v1(159.13,97.43) 159.58,96.98 JDIM1.146
M_B_A11: length 45.8
  IN4 w0.102: v2(142.52,132.91) 142.52,132.78 142.91,132.39 142.91,128.69 142.72,128.51 142.72,125.41
  IN4 w0.127: 142.72,125.41 142.2,124.88 142.2,122.32 141.36,121.48 141.36,111.7 142.52,110.54 144.61,110.54 151.35,103.8 151.35,100.22 150.87,99.74 150.37,99.74 150.21,99.58 150.21,99.23 150.37,99.07 151.14,99.07 v1(151.32,99.25)
  BOTTOM w0.102: v2(142.52,132.91) 142.17,132.56 U42.BP7
  BOTTOM w0.216: JDIM1.120 151.08,97.16 150.82,97.42 150.82,98.74 v1(151.32,99.25)
M_B_A12: length 46.6
  IN4 w0.102: 142.09,125.96 142.09,128.23 141.83,128.48 141.83,132.85 v2(142.52,133.54)
  IN4 w0.127: 142.09,125.96 141.34,125.21 141.34,122.68 140.49,121.83 140.49,111.34 142.44,109.4 142.62,109.4 142.89,109.67 143.07,109.67 143.25,109.49 143.25,109.31 142.98,109.04 142.98,108.86 143.15,108.68 143.33,108.68 144.2,109.55 144.38,109.55 144.56,109.37 144.56,109.19 143.69,108.32 143.69,108.14 143.87,107.96 144.05,107.96 144.92,108.83 145.1,108.83 145.28,108.65 145.28,108.47 144.41,107.61 144.41,107.43 144.72,107.12 144.9,107.12 145.69,107.92 146.01,107.92 146.34,107.58 146.34,107.4 146.34,107.17 146.47,107.04 146.7,107.04 146.88,107.05 147.06,106.87 147.06,106.69 147.06,106.51 147.24,106.33 147.6,106.33 150.49,103.44 v1(150.49,102.87)
  BOTTOM w0.102: v2(142.52,133.54) 142.19,133.86 U42.BP9
  BOTTOM w0.216: JDIM1.119 150.81,104.33 150.81,103.18 v1(150.49,102.87)
M_B_A13: length 54.1
  IN4 w0.127: v1(161.75,98.87) 162.19,98.44 162.43,98.44 162.55,98.57 162.55,99.07 162.26,99.36 162.26,99.71 162.55,100.01 162.55,100.35 162.19,100.71 162.19,103.44 162.74,103.99 162.74,106.36 157.94,111.16 157.94,112.04 157.81,112.17 156.94,112.17 156.81,112.3 156.81,112.6 156.94,112.73 157.81,112.73 157.94,112.86 157.94,113.11 157.81,113.24 157.03,113.24 156.9,113.37 156.9,113.59 157.06,113.75 157.81,113.75 157.94,113.87 157.94,114.12 157.81,114.25 157.04,114.25 156.92,114.38 156.92,114.64 157.04,114.76 157.81,114.76 157.94,114.89 157.94,115.13 157.8,115.27 157.06,115.27 156.93,115.4 156.93,115.65 157.06,115.78 157.81,115.78 157.94,115.91 157.94,116.15 157.81,116.29 157.06,116.29 156.93,116.41 156.93,116.67 157.06,116.79 157.81,116.79 157.94,116.92 157.94,117.16 157.8,117.3 157.06,117.3 156.93,117.43 156.93,117.68 157.06,117.81 157.81,117.81 157.94,117.94 157.94,118.19 157.81,118.32 157.06,118.32 156.93,118.45 156.93,119.21 156.93,119.36 156.19,120.1 156.19,124.01 154.8,125.4 154.8,125.74 154.43,126.11 154.43,126.38 155.11,127.06 155.11,131.67 155.68,132.24 v2(155.87,132.24)
  BOTTOM w0.102: v2(155.87,132.24) 156.19,132.56 U42.AM7
  BOTTOM w0.216: JDIM1.158 162.58,98.05 v1(161.75,98.87)
M_B_ACT#: length 43.8
  IN4 w0.102: v2(138.81,132.22) 138.43,131.84 138.43,129.34 138.45,129.33 138.45,127.19
  IN4 w0.127: 138.45,127.19 138.45,125.87 137.9,125.33 137.9,110.27 145,103.17 145,101.33 146.16,100.18 146.34,100.18 146.61,100.45 146.79,100.45 146.97,100.27 146.97,100.09 146.63,99.75 146.63,99.57 146.88,99.32 147.07,99.32 147.27,99.51 147.45,99.51 148.82,98.14 v1(149.08,98.14)
  BOTTOM w0.102: U42.BW7 138.87,132.25 138.84,132.25 v2(138.81,132.22)
  BOTTOM w0.216: JDIM1.114 149.58,97.93 149.36,98.14 v1(149.08,98.14)
M_B_ALERT#: length 83.8
  IN4 w0.086: v1(149.07,98.8) 149.85,98.02 149.85,97.19 151.47,95.57 169.34,95.57 170.59,96.81 186.29,96.81 187.17,97.69 187.17,98.49 187.59,98.92 187.59,103.33 187.41,103.51 187.41,107.68 184.23,110.85 184.23,119.65 178.74,125.15 178.33,125.15 175.24,128.24
  IN4 w0.102: v2(173.78,130.79) 174.21,130.36 174.21,129.56 175.24,128.53 175.24,128.24
  BOTTOM w0.102: U42.E4 173.65,130.79 v2(173.78,130.79)
  BOTTOM w0.14: v1(149.07,98.8) 149.4,98.8 149.85,98.35 149.85,97.44 150.08,97.22 JDIM1.116
M_B_BA0: length 55.5
  IN4 w0.102: 151.99,131.16 151.78,131.37 151.78,133.36 151.61,133.53 v2(151.4,133.53)
  IN4 w0.127: v1(159.13,98.95) 159.51,98.95 159.63,98.82 159.63,96.57 160.01,96.19 160.81,96.19 161.14,96.52 161.14,100.07 160.41,100.81 160.41,104.1 160.83,104.52 160.83,105.83 153.38,113.28 153.38,118.28 153.51,118.4 153.99,118.4 154.11,118.53 154.11,118.79 153.99,118.91 153.51,118.91 153.38,119.04 153.38,119.29 153.51,119.42 153.99,119.42 154.11,119.55 154.11,119.8 153.99,119.93 153.51,119.93 153.38,120.06 153.38,120.49 153.54,120.64 153.99,120.64 154.11,120.77 154.11,121.02 153.98,121.15 153.54,121.15 153.38,121.31 153.38,121.52 153.58,121.73 153.99,121.73 154.11,121.85 154.11,123.65 151.76,126 151.76,126.91 152.5,127.64 152.5,130.37 152.7,130.58 152.7,131.02 152.57,131.16 151.99,131.16
  BOTTOM w0.102: U42.AY8 151.08,133.21 v2(151.4,133.53)
  BOTTOM w0.216: JDIM1.150 160.58,97.5 v1(159.13,98.95)
M_B_BA1: length 56.5
  IN4 w0.127: v2(151.38,134.19) 151.28,134.09 151.1,134.09 150.92,134.27 150.92,135.57 150.78,135.71 150.5,135.71 150.37,135.58 150.37,133.87 150.5,133.74 150.7,133.74 150.83,133.61 150.83,133.36 150.7,133.23 150.5,133.23 150.37,133.11 150.37,131.69 150.94,131.12 150.94,128.63 150.45,128.15 150.45,125.89 151.71,124.63 151.71,124.31 151.84,124.18 152.3,124.18 152.45,124.03 152.45,123.8 152.33,123.68 151.89,123.68 151.76,123.55 151.76,123.29 151.89,123.17 152.39,123.17 152.52,123.04 152.52,122.79 152.39,122.66 151.89,122.66 151.76,122.53 151.76,122.28 151.89,122.15 152.39,122.15 152.52,122.02 152.52,121.77 152.39,121.64 151.89,121.64 151.76,121.52 151.76,121.26 151.89,121.14 152.39,121.14 152.52,121.01 152.52,120.75 152.39,120.63 151.89,120.63 151.76,120.5 151.76,120.25 151.89,120.12 152.39,120.12 152.52,119.99 152.52,119.74 152.39,119.61 151.89,119.61 151.76,119.48 151.76,119.23 151.89,119.1 152.39,119.1 152.52,118.98 152.52,118.72 152.39,118.6 151.89,118.6 151.76,118.47 151.76,118.21 151.89,118.09 152.39,118.09 152.52,117.96 152.52,117.71 152.39,117.58 151.89,117.58 151.76,117.45 151.76,117.2 151.89,117.07 152.39,117.07 152.52,116.94 152.52,116.69 152.39,116.56 151.89,116.56 151.76,116.44 151.76,116.18 151.89,116.06 152.39,116.06 152.52,115.93 152.52,115.67 152.39,115.55 151.89,115.55 151.76,115.42 151.76,115.17 151.89,115.04 152.39,115.04 152.52,114.91 152.52,114.66 152.39,114.53 151.89,114.53 151.76,114.4 151.76,114.12 151.89,113.99 152.39,113.99 152.52,113.87 152.52,112.92 159.28,106.16 159.28,105.98 159.01,105.71 159.01,105.39 159.14,105.26 159.83,105.26 159.96,105.13 159.96,104.88 159.84,104.75 159.14,104.75 159.01,104.62 159.01,104.37 159.14,104.24 159.42,104.24 159.55,104.12 159.55,103.86 159.42,103.74 159.14,103.74 159.01,103.61 159.01,103.18 v1(159.13,103.06)
  BOTTOM w0.102: v2(151.38,134.19) 151.05,133.86 U42.AY9
  BOTTOM w0.216: v1(159.13,103.06) 159.33,103.26 JDIM1.145
M_B_BG#0: length 47.4
  IN4 w0.115: 140.72,128.01 140.72,130.36 141.14,130.78 v2(141.14,131.55)
  IN4 w0.127: 140.72,128.01 140.72,127.75 140.89,127.58 140.89,127.11 140.72,126.94 140.72,125.96 140.47,125.71 140.47,123.04 139.63,122.19 139.63,110.99 143.14,107.47 144.06,106.56 144.06,106.56 144.76,105.86 144.94,105.86 145.33,106.24 145.53,106.24 145.7,106.07 145.7,105.89 145.31,105.5 145.31,105.31 145.48,105.14 145.66,105.14 146.29,105.76 146.47,105.76 146.65,105.59 146.65,105.41 146.02,104.78 146.02,104.6 146.19,104.42 146.39,104.42 147.24,105.28 147.42,105.28 147.6,105.1 147.6,104.92 147.03,104.35 147.03,104.17 147.26,103.94 147.44,103.94 148.01,104.52 148.19,104.52 148.49,104.21 148.49,104.03 148.28,103.82 148.28,103.64 148.46,103.46 148.64,103.46 148.85,103.67 149.03,103.67 149.53,103.17 149.53,101.8 149.41,101.67 v1(149.12,101.67)
  BOTTOM w0.102: v2(141.14,131.55) 141.23,131.47 141.96,131.47 142.14,131.65 U42.BP6
  BOTTOM w0.216: v1(149.12,101.67) 149.16,101.67 149.54,102.05 149.54,103.15 149.83,103.43 JDIM1.115
M_B_BG#1: length 44.8
  IN4 w0.127: v2(140.34,132.24) 140.05,132.52 139.87,132.52 139.64,132.29 139.64,132.1 140,131.74 140,131.32 140.17,131.15 140.45,131.15 140.58,131.02 140.58,130.85 140.37,130.64 140.37,128.32 140.11,128.05 140.11,127.87 140.3,127.68 140.3,127.23 140.11,127.04 140.11,126.86 140.34,126.63 140.34,126.25 140.06,125.97 140.06,125.23 140,125.18 140,123.18 139.2,122.37 139.2,110.81 146.03,103.98 146.61,103.98 147.16,103.43 147.87,103.43 148.14,103.16 148.14,101.43 147.72,101.01 147.72,100.87 148.35,100.23 148.64,100.23 148.89,100.48 148.89,100.7 148.66,100.94 148.66,102.57 v1(149.06,102.97)
  BOTTOM w0.102: v2(140.34,132.24) 140.01,132.56 U42.BV7
  BOTTOM w0.216: v1(149.06,102.97) 149.06,103.12 149.33,103.38 JDIM1.113
M_B_CAS#: length 54.1
  IN4 w0.102: 156.32,132.97 155.87,133.43 v2(155.87,133.54)
  IN4 w0.127: v1(161.75,97.58) 161.57,97.4 161.57,96.32 161.71,96.18 164.36,96.18 164.51,96.33 164.51,97.58 164.36,97.73 164,97.73 163.88,97.6 163.88,96.85 163.75,96.72 162.46,96.72 162.33,96.85 162.33,97.73 162.48,97.88 162.83,97.88 162.99,98.04 162.99,99.25 162.81,99.43 162.81,99.65 163.03,99.87 163.03,100.48 162.63,100.89 162.63,103.27 163.17,103.81 163.17,104.29 163.3,104.42 163.41,104.42 163.56,104.57 163.56,104.93 163.41,105.08 163.34,105.08 163.19,105.23 163.19,105.44 163.43,105.68 163.43,105.86 163.17,106.12 163.17,106.54 158.38,111.33 158.38,112.04 158.37,112.04 158.37,118.53 158.15,118.75 157.52,118.75 157.36,118.91 157.36,119.54 156.62,120.28 156.62,124.14 155.9,124.86 155.9,125.24 155.77,125.37 155.39,125.37 155.23,125.53 155.23,126.29 155.44,126.5 155.44,131.43 155.64,131.63 156.2,131.63 156.32,131.76 156.32,132.97
  BOTTOM w0.102: v2(155.87,133.54) 155.54,133.21 U42.AN8
  BOTTOM w0.216: JDIM1.156 162.08,97.26 v1(161.75,97.58)
M_B_CB0: length 4.4
  TOP w0.203: v1(144.56,99.47) 144.52,99.47 144.02,98.97 R129.2
  BOTTOM w0.14: JDIM1.92 144.08,98.99 v1(144.56,99.47)
M_B_CB1: length 4.5
  TOP w0.14: R119.2 143.03,100.85 v1(143.25,101.07)
  BOTTOM w0.14: JDIM1.91 143.83,103.5 143.7,103.38 143.7,101.52 v1(143.25,101.07)
M_B_CB2: length 2.2
  TOP w0.14: v1(146.29,103.07) 146.29,103.17 146.38,103.26 R114.2
  BOTTOM w0.14: v1(146.29,103.07) 146.29,103.17 146.33,103.21 JDIM1.101
M_B_CB3: length 4.5
  TOP w0.14: R118.2 146.47,100.95 v1(146.37,100.85)
  BOTTOM w0.14: v1(146.37,100.85) 146.37,101.59 147.12,102.35 147.12,103.25 147.33,103.45 JDIM1.105
M_B_CB4: length 3.4
  TOP w0.203: v1(143.23,98.15) 143.14,98.24 R133.2
  BOTTOM w0.14: JDIM1.88 143.08,97.01 142.71,97.37 142.71,97.99 142.87,98.15 v1(143.23,98.15)
M_B_CB5: length 3.9
  TOP w0.14: v1(143.27,102.37) 143.22,102.37 142.75,102.83 142.75,103.73 R116.2
  BOTTOM w0.14: JDIM1.87 142.83,102.81 v1(143.27,102.37)
M_B_CB6: length 4.2
  TOP w0.203: R123.2 147.05,99.25 146.89,99.25 146.48,98.84 v1(146.34,98.84)
  BOTTOM w0.14: JDIM1.100 146.08,97.2 145.87,97.4 145.87,98.38 v1(146.34,98.84)
M_B_CB7: length 3.3
  TOP w0.203: v1(146.37,98.19) 146.21,98.19 145.91,98.49 R130.2
  BOTTOM w0.14: v1(146.37,98.19) 147.08,97.49 JDIM1.104
M_B_CKE0: length 41.9
  IN4 w0.102: 139.82,128.33 140.04,128.55 140.04,130.93 139.59,131.38 v2(139.59,131.57)
  IN4 w0.127: 139.82,128.33 139.71,128.22 139.71,127.8 139.93,127.58 139.93,127.36 139.7,127.12 139.7,126.77 139.93,126.54 139.93,126.36 139.7,126.13 139.7,125.44 139.51,125.25 138.98,125.25 138.77,125.04 138.77,124.83 138.89,124.7 139.48,124.7 139.61,124.58 139.61,124.33 139.48,124.2 138.89,124.2 138.77,124.08 138.77,123.79 138.89,123.67 139.38,123.67 139.52,123.53 139.52,123.3 139.38,123.16 138.89,123.16 138.77,123.03 138.77,110.63 145.85,103.55 146.43,103.55 147.25,102.73 147.25,102.55 146.76,102.05 146.76,101.83 146.91,101.68 147.11,101.68 147.7,102.27 v1(147.7,102.36)
  BOTTOM w0.102: U42.BW6 139.25,131.91 v2(139.59,131.57)
  BOTTOM w0.216: v1(147.7,102.36) 148.19,102.85 148.19,103.31 148.33,103.45 JDIM1.109
M_B_CKE1: length 44.2
  IN4 w0.102: v2(142.52,132.23) 142.12,131.83 142.12,128.66 142.4,128.38 142.4,125.65
  IN4 w0.127: 142.4,125.65 141.77,125.02 141.77,122.5 140.93,121.66 140.93,111.52 142.34,110.11 144.43,110.11 150.92,103.62 150.92,101.24 150.04,100.36 149.62,100.36 v1(149.1,99.84)
  BOTTOM w0.102: U42.BN7 142.86,132.56 v2(142.52,132.23)
  BOTTOM w0.216: v1(149.1,99.84) 148.45,99.19 148.45,97.21 148.58,97.09 JDIM1.110
M_B_CLKN0: length 47.3
  IN4 w0.102: v2(145.47,134.21) 145.29,134.04 145.12,134.04 144.89,133.81 144.89,128.46 145.07,128.28 145.07,128.26 145.09,128.24
  IN4 w0.127: 145.09,128.24 145.59,127.74 145.59,127.19 145.37,126.97 145.37,125 144.99,124.62 144.99,123.78 145.26,123.51 145.61,123.51 145.74,123.39 145.74,123.02 145.59,122.88 145.26,122.88 144.99,122.61 144.99,122.03 145.26,121.76 145.6,121.76 145.74,121.62 145.74,121.25 145.61,121.13 145.26,121.13 144.99,120.86 144.99,114.62 154.69,104.93 154.69,102.7 154.49,102.5 154.49,101.97 154.21,101.7 154.21,100.59 154.48,100.32 155,100.32 v1(155.14,100.18)
  BOTTOM w0.102: U42.BK9 145.12,133.86 v2(145.47,134.21)
  BOTTOM w0.152: JDIM1.139 155.83,103.33 156.08,103.08 156.08,100.59 155.78,100.29 155.25,100.29 v1(155.14,100.18)
M_B_CLKN1: length 46.6
  IN4 w0.102: v2(145.48,132.24) 145.69,132.02 145.87,132.02 146.27,132.42 147.73,132.42 148.03,132.12 148.03,129.7 148.14,129.59 148.73,129.59 149.08,129.24 149.08,127.25 148.64,126.81 148.64,125.92 148.66,125.9 148.66,125.87
  IN4 w0.127: v1(156.49,98.47) 156.68,98.66 157.03,98.66 157.3,98.93 157.3,100.54 157.08,100.76 157.08,105.62 147.92,114.78 147.92,122.17 148.05,122.3 148.28,122.3 148.55,122.57 148.55,123.15 148.28,123.41 148.05,123.41 147.92,123.54 147.92,123.89 148.11,124.08 148.39,124.08 148.66,124.35 148.66,125.87
  BOTTOM w0.102: U42.BK7 145.42,132.24 v2(145.48,132.24)
  BOTTOM w0.152: v1(156.49,98.47) 156.4,98.56 156.18,98.56 155.96,98.34 155.96,97.34 156.08,97.23 JDIM1.140
M_B_CLKP0: length 47.3
  IN4 w0.102: v2(145.48,133.51) 145.54,133.58 145.54,133.72 145.43,133.84 145.2,133.84 145.09,133.73 145.09,128.55 145.22,128.42 145.25,128.42
  IN4 w0.127: 145.25,128.42 145.83,127.84 145.83,127.09 145.61,126.87 145.61,124.9 145.24,124.52 145.24,123.88 145.36,123.76 145.71,123.76 145.98,123.49 145.98,122.92 145.69,122.64 145.36,122.64 145.24,122.51 145.24,122.13 145.36,122 145.7,122 145.98,121.72 145.98,121.15 145.71,120.89 145.36,120.89 145.24,120.76 145.24,114.72 154.93,105.03 154.93,102.6 154.73,102.4 154.73,101.87 154.45,101.6 154.45,100.69 154.58,100.57 154.97,100.57 155.12,100.72 v1(155.12,100.85)
  BOTTOM w0.102: v2(145.48,133.51) 145.45,133.55 144.96,133.55 144.89,133.47 144.89,133.33 145.01,133.21 U42.BK8
  BOTTOM w0.152: JDIM1.137 155.33,103.49 155.83,102.98 155.83,100.69 155.68,100.53 155.44,100.53 v1(155.12,100.85)
M_B_CLKP1: length 46.7
  IN4 w0.102: 148.42,125.87 148.42,125.9 148.44,125.92 148.44,126.9 148.88,127.33 148.88,129.16 148.64,129.39 148.06,129.39 147.83,129.62 147.83,132.03 147.64,132.22 146.36,132.22 145.96,131.82 145.7,131.82 v2(145.48,131.59)
  IN4 w0.127: v1(156.43,99.24) 156.43,99.1 156.62,98.9 156.93,98.9 157.06,99.03 157.06,100.44 156.84,100.66 156.84,105.52 147.68,114.68 147.68,122.27 147.95,122.54 148.18,122.54 148.31,122.67 148.31,123.05 148.18,123.17 147.95,123.17 147.68,123.44 147.68,123.99 148.01,124.32 148.29,124.32 148.42,124.45 148.42,125.87
  BOTTOM w0.102: U42.BK6 145.15,131.91 v2(145.48,131.59)
  BOTTOM w0.152: JDIM1.138 155.58,97.23 155.72,97.37 155.72,98.44 156.43,99.15 v1(156.43,99.24)
M_B_CS#0: length 52.6
  IN4 w0.127: v1(161.7,100.24) 161.58,100.24 160.84,100.99 160.84,103.92 161.26,104.34 161.26,106.01 153.81,113.46 153.81,115.75 153.94,115.88 154.3,115.88 154.43,116 154.43,116.26 154.3,116.38 153.94,116.38 153.81,116.51 153.81,116.77 153.94,116.89 154.29,116.89 154.42,117.02 154.42,117.27 154.29,117.4 153.94,117.4 153.81,117.53 153.81,117.76 154.03,117.98 154.42,117.98 154.55,118.1 154.55,123.83 152.16,126.21 152.16,126.75 153.37,127.96 153.37,130.34 153.1,130.61 153.1,131.05 153.37,131.31 153.37,133.04 153.09,133.32 153.09,133.81 153.37,134.09 153.37,135.73 153.21,135.88 152.68,135.88 152.52,135.73 152.52,133.24 v2(152.17,132.89)
  BOTTOM w0.102: v2(152.17,132.89) 152.21,132.89 152.53,133.21 U42.AV8
  BOTTOM w0.216: v1(161.7,100.24) 160.33,101.62 JDIM1.149
M_B_CS#1: length 49.5
  IN4 w0.102: 156.29,125.82 156.29,131.05 156.67,131.44 156.67,132.96 156.25,133.38 156.25,134.09 156.15,134.19 v2(155.87,134.19)
  IN4 w0.127: 156.29,125.82 156.29,125.13 157.06,124.36 157.06,120.46 157.79,119.72 157.79,119.31 157.92,119.18 158.33,119.18 158.8,118.71 158.8,118.28 158.93,118.15 159.31,118.15 159.44,118.03 159.44,117.77 159.31,117.64 158.93,117.64 158.8,117.52 158.8,117.26 158.93,117.14 159.29,117.14 159.44,116.99 159.44,116.76 159.31,116.63 158.93,116.63 158.8,116.5 158.8,116.25 158.93,116.12 159.31,116.12 159.44,115.99 159.44,115.74 159.31,115.61 158.93,115.61 158.8,115.49 158.8,115.23 158.93,115.1 159.3,115.1 159.44,114.97 159.44,114.72 159.31,114.6 158.93,114.6 158.8,114.47 158.8,114.22 158.93,114.09 159.31,114.09 159.44,113.96 159.44,113.71 159.31,113.58 158.93,113.58 158.8,113.45 158.8,113.2 158.93,113.07 159.31,113.07 159.44,112.94 159.44,112.69 159.31,112.56 158.93,112.56 158.8,112.44 158.8,112.17 158.85,112.12 158.93,112.04 159.31,112.04 159.44,111.91 159.44,111.64 159.33,111.53 159.2,111.53 159.07,111.4 159.07,111.25 164,106.33 164,104.39 163.72,104.11 163.72,103.93 163.95,103.69 163.95,103.51 163.83,103.39 163.36,103.39 163.06,103.09 163.06,101.07 163.23,100.89 v1(163.45,100.89)
  BOTTOM w0.102: U42.AN9 155.54,133.86 v2(155.87,134.19)
  BOTTOM w0.216: v1(163.45,100.89) 163.37,100.89 162.33,101.94 JDIM1.157
M_B_DIM0_ODT0: length 55
  IN4 w0.102: 154.74,127.67 154.74,132.29 154.84,132.4 155.32,132.4 155.49,132.56 155.49,134.09 155.38,134.19 v2(155.12,134.19)
  IN4 w0.127: v1(161.7,102.95) 161.7,103.57 162.31,104.17 162.31,104.67 162.12,104.86 162.12,105.41 162.31,105.59 162.31,106.18 156.02,112.47 156.02,112.65 156.15,112.77 156.37,112.77 156.5,112.9 156.5,113.21 156.37,113.34 155.15,113.34 154.93,113.56 154.93,113.77 155.06,113.9 156.36,113.9 156.5,114.03 156.5,114.28 156.37,114.41 154.83,114.41 154.68,114.56 154.68,114.79 154.8,114.91 156.37,114.91 156.5,115.04 156.5,115.29 156.36,115.42 155.51,115.42 155.39,115.55 155.39,115.8 155.51,115.93 156.35,115.93 156.5,116.08 156.5,116.31 156.37,116.44 155.54,116.44 155.41,116.57 155.41,116.82 155.54,116.95 156.36,116.95 156.5,117.08 156.5,117.32 156.36,117.45 155.54,117.45 155.41,117.58 155.41,117.84 155.54,117.96 156.35,117.96 156.5,118.11 156.5,118.34 156.37,118.47 155.54,118.47 155.41,118.6 155.41,118.85 155.54,118.98 156.24,118.98 156.38,119.12 156.38,119.3 156.2,119.49 155.54,119.49 155.41,119.61 155.41,120.15 155.54,120.27 155.63,120.27 155.76,120.4 155.76,120.65 155.63,120.78 155.54,120.78 155.41,120.91 155.41,121.16 155.54,121.29 155.63,121.29 155.76,121.42 155.76,121.67 155.63,121.8 155.54,121.8 155.41,121.92 155.41,122.18 155.54,122.3 155.63,122.3 155.76,122.43 155.76,122.69 155.63,122.81 155.54,122.81 155.41,122.94 155.41,123.19 155.54,123.32 155.63,123.32 155.76,123.45 155.76,123.7 155.63,123.83 155.54,123.83 155.41,123.96 155.41,124.18 154.4,125.19 154.4,125.53 154.28,125.66 153.87,125.66 153.71,125.82 153.71,126 153.97,126.27 153.97,126.98 154.1,127.1 154.59,127.1 154.74,127.25 154.74,127.67
  BOTTOM w0.102: U42.AR9 154.8,133.86 v2(155.12,134.19)
  BOTTOM w0.216: v1(161.7,102.95) 161.83,103.07 JDIM1.155
M_B_DIM0_ODT1: length 47.5
  IN4 w0.102: 156.58,125.4 156.58,130.84 157.02,131.27 157.02,133.8 156.63,134.18 v2(156.63,134.18)
  IN4 w0.127: v1(163.51,102.26) 163.79,102.26 163.92,102.12 163.92,98.29 164.05,98.16 164.3,98.16 164.43,98.29 164.43,102.41 164.24,102.6 164.24,103.19 164.43,103.38 164.43,106.51 159.87,111.06 159.87,118.25 157.49,120.64 157.49,124.49 156.58,125.4
  BOTTOM w0.102: v2(156.63,134.18) 156.31,133.86 U42.AM9
  BOTTOM w0.216: JDIM1.161 163.33,103.44 163,103.12 163,102.77 163.46,102.31 v1(163.51,102.26)
M_B_DQ0: length 62.7
  IN4 w0.114: v2(132.41,142.74) 132.02,143.13 129.93,143.13 129.76,143.29
  IN4 w0.127: 129.76,143.29 121.89,143.29 117.23,138.64 116.13,137.53 116.13,136.53 115.5,135.9 115.5,128.26 114.55,127.32 114.55,110.2 114.84,109.91 114.84,109.73 114.84,109.55 115.02,109.37 115.2,109.37 115.2,109.38 115.38,109.38 115.56,109.2 115.56,109.02 115.48,108.94 115.48,108.76 115.66,108.58 115.84,108.58 115.92,108.66 116.1,108.66 116.28,108.48 116.28,108.3 116.2,108.22 116.2,108.04 116.38,107.86 116.56,107.86 116.64,107.94 116.81,107.94 116.99,107.76 116.99,107.58 116.92,107.51 116.92,107.33 117.1,107.15 117.28,107.15 117.35,107.22 117.53,107.22 117.71,107.04 117.71,106.86 117.64,106.79 117.64,106.61 117.82,106.43 118,106.43 118.07,106.5 118.25,106.5 118.43,106.32 118.43,106.14 118.36,106.07 118.36,105.89 118.54,105.71 118.72,105.71 118.79,105.78 118.97,105.78 119.15,105.6 119.15,105.42 119.08,105.35 119.08,105.17 119.26,104.99 119.44,104.99 119.51,105.06 119.69,105.06 119.87,104.88 119.87,104.7 119.8,104.63 119.8,104.45 119.98,104.27 120.16,104.27 120.23,104.34 120.41,104.34 120.59,104.16 120.59,103.98 120.52,103.91 120.52,103.73 120.7,103.55 120.99,103.55 v1(121.72,102.82)
  BOTTOM w0.102: U42.CK22 132.41,142.68 v2(132.41,142.74)
  BOTTOM w0.216: v1(121.72,102.82) 121.83,102.92 JDIM1.3
M_B_DQ1: length 63.5
  IN4 w0.102: 130.52,142.13 130.71,142.32 132.07,142.32 132.4,142 v2(132.4,142)
  IN4 w0.114: 127.87,142.49 123.75,142.49 ; 130.52,142.13 128.22,142.13
  IN4 w0.115: 128.22,142.13 127.87,142.49
  IN4 w0.127: v1(122.94,98.85) 122.53,99.26 122.53,103.3 115.31,110.52 115.31,127 116.26,127.95 116.26,135.58 116.89,136.22 116.89,137.22 117.65,137.97 122.16,142.49 123.75,142.49
  BOTTOM w0.102: U42.CJ22 132.4,142.03 v2(132.4,142)
  BOTTOM w0.216: JDIM1.8 123.08,98.71 v1(122.94,98.85)
M_B_DQ2: length 65.5
  IN4 w0.114: 124.92,139.36 125.48,139.91 130.17,139.91 130.36,139.72 131.31,139.72 v2(131.75,140.17)
  IN4 w0.127: v1(126.33,103.06) 126.33,103.22 125.96,103.59 125.96,103.77 126,103.81 126,103.99 125.82,104.17 125.64,104.17 125.6,104.13 125.42,104.13 125.24,104.31 125.24,104.49 125.28,104.53 125.28,104.71 125.1,104.89 124.92,104.89 124.88,104.85 124.7,104.85 124.52,105.03 124.52,105.21 124.56,105.25 124.56,105.43 124.38,105.61 124.2,105.61 124.16,105.57 123.98,105.57 123.8,105.75 123.8,105.93 123.84,105.97 123.84,106.15 123.66,106.33 123.48,106.33 123.44,106.29 123.26,106.29 123.08,106.47 123.08,106.65 123.12,106.69 123.12,106.87 122.94,107.05 122.76,107.05 122.72,107.01 122.54,107.01 122.36,107.19 122.36,107.37 122.4,107.41 122.4,107.59 122.22,107.77 122.04,107.77 122,107.73 121.82,107.73 121.64,107.91 121.64,108.09 121.68,108.13 121.68,108.31 121.5,108.49 121.32,108.49 121.28,108.45 121.1,108.45 120.92,108.62 120.92,108.8 120.97,108.85 120.97,109.03 120.79,109.21 120.61,109.21 120.56,109.16 120.39,109.16 120.21,109.34 120.21,109.52 120.25,109.56 120.25,109.74 120.11,109.88 120.07,109.92 119.89,109.92 119.85,109.88 119.67,109.88 119.49,110.06 119.49,110.24 119.53,110.28 119.53,110.46 119.35,110.64 119.17,110.64 119.13,110.6 118.95,110.6 118.77,110.78 118.77,110.96 118.81,111 118.81,111.18 118.63,111.36 118.45,111.36 118.41,111.32 118.23,111.32 117.94,111.61 117.94,122.74 118.3,123.1 118.65,123.45 118.65,123.63 117.96,124.32 117.96,124.51 118.13,124.69 118.31,124.69 119.01,123.99 119.19,123.99 119.43,124.23 119.43,124.41 118.52,125.32 118.52,125.5 118.7,125.68 118.88,125.68 119.79,124.77 119.97,124.77 120.31,125.11 120.31,125.76 120.19,125.89 119.48,125.89 119.35,126.01 119.35,126.27 119.48,126.39 120.19,126.39 120.31,126.52 120.31,127.33 120.06,127.58 120.06,127.84 120.31,128.09 120.31,128.35 120.06,128.6 120.06,128.86 120.31,129.11 120.31,129.36 120.06,129.61 120.06,129.87 120.31,130.12 120.31,130.38 120.06,130.63 120.06,130.89 120.31,131.14 120.31,131.4 120.06,131.65 120.06,131.9 120.31,132.15 120.31,132.41 120.06,132.66 120.06,132.92 120.31,133.17 120.31,133.43 120.06,133.68 120.06,133.94 120.31,134.19 120.31,134.44 120.06,134.69 120.06,134.95 120.31,135.2 120.31,135.46 120.06,135.71 120.06,135.97 120.31,136.22 120.31,136.6 123.07,139.36 124.92,139.36
  BOTTOM w0.102: U42.CJ20 132.36,140.17 v2(131.75,140.17)
  BOTTOM w0.216: JDIM1.21 v1(126.33,103.06)
