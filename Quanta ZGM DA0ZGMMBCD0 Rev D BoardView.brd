# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VMC_DQ5: length 10.4
  IN2 w0.102: v2(252.19,163.36) 252.19,163.92 251.81,164.3 251.81,168.09 253.24,169.52 254.21,169.52 v2(254.68,169.98)
  BOTTOM w0.13: 254.75,170.82 254.75,170.06
  BOTTOM w0.161: v2(252.19,163.36) UG6.E8 ; VRAM3.U4 254.75,170.82 ; 254.75,170.06 v2(254.68,169.98)
VMC_DQ6: length 8.8
  IN2 w0.102: v2(252.21,164.77) 252.21,164.91 252.68,165.38 252.68,167.89 253.77,168.98 255.17,168.98 v2(256.26,170.07)
  BOTTOM w0.102: UG6.C8 251.88,164.42 252.21,164.75 v2(252.21,164.77) ; v2(256.26,170.07) 255.89,170.45 VRAM3.V3
VMC_DQ7: length 13.6
  IN2 w0.102: v2(251.13,164.2) 251.27,164.35 251.27,165.17 250.79,165.66 250.79,168.39 253.5,171.1 254.09,171.1 254.29,171.3 254.29,171.88 255.09,172.68 255.87,172.68 256.26,173.07 v2(256.26,173.08)
  BOTTOM w0.102: UG6.D10 250.93,164.2 v2(251.13,164.2)
  BOTTOM w0.161: VRAM3.P2 256.62,173.45 256.26,173.08 v2(256.26,173.08)
VMC_DQ8: length 26.8
  IN1 w0.102: v2(257.8,164.2) 258.14,164.54 258.14,165.3 258.4,165.55 258.4,167.93 259.8,169.33 259.8,182.13 257.8,184.13 256.07,184.13 v2(255.57,183.63)
  BOTTOM w0.102: v2(255.57,183.63) 255.88,183.32 VRAM3.A3 ; UG6.D2 256.14,163.72 256.47,163.39 257.01,163.39 257.8,164.18 v2(257.8,164.2)
VMC_DQ9: length 29.9
  IN1 w0.102: v2(257.7,162.81) 258.5,163.61 258.5,165.16 258.73,165.39 258.73,167.63 260.35,169.25 260.35,182.33 258.09,184.6 255.7,184.6 255.1,183.99 255.1,183.15 v2(254.77,182.82)
  BOTTOM w0.102: v2(254.77,182.82) 255.13,182.46 VRAM3.B4
  BOTTOM w0.161: UG6.E1 257.28,163.02 257.49,162.81 v2(257.7,162.81)
VMC_DQ10: length 23.5
  IN1 w0.102: v2(256.25,182.83) 256.65,183.23 257.98,183.23 259.27,181.95 259.27,169.46 257.95,168.13 v2(257.95,165.84)
  BOTTOM w0.102: UG6.C2 256.22,164.42 256.58,164.79 257,164.79 ; v2(256.25,182.83) 256.63,182.46 VRAM3.B2
  BOTTOM w0.161: 257,164.79 257.95,165.74 v2(257.95,165.84)
VMC_DQ11: length 17.2
  IN1 w0.102: v2(256.4,164.07) 256.4,164.9 256.05,165.24 256.05,169.2 256.64,169.78 256.64,178.7 v2(257,179.06)
  BOTTOM w0.102: UG6.D3 255.7,164.07 v2(256.4,164.07) ; VRAM3.G2 256.64,178.7 v2(257,179.06)
VMC_DQ12: length 18.1
  IN1 w0.102: v2(256.44,165.49) 256.31,165.61 256.31,166.45 256.57,166.7 256.57,168.86 257.46,169.75 257.46,180.09 v2(257,180.56)
  BOTTOM w0.102: v2(256.44,165.49) 256.44,165.01 256.18,164.76 255.93,164.76 255.59,164.42 UG6.C3
  BOTTOM w0.161: VRAM3.E2 256.64,180.2 v2(257,180.56)
VMC_DQ13: length 17.4
  IN1 w0.102: v2(255.01,164.77) 254.58,165.19 254.58,165.71 254.84,165.97 254.84,167.43 255.12,167.7 255.12,179.96 255.5,180.35 v2(255.5,180.59)
  BOTTOM w0.102: VRAM3.E3 255.88,180.21 v2(255.5,180.59) ; UG6.B4 v2(255.01,164.77)
VMC_DQ14: length 18.7
  IN1 w0.102: v2(256.27,179.83) 256.27,179.08 255.88,178.69 255.88,169.6 255.68,169.4 255.68,164.1 254.99,163.41 v2(254.99,162.66)
  BOTTOM w0.161: v2(256.27,179.83) 256.63,179.47 VRAM3.F2 ; UG6.E4 254.65,163 v2(254.99,162.66)
VMC_DQ15: length 19.8
  IN1 w0.102: v2(254.31,164.06) 254.31,165.85 254.58,166.13 254.58,169.37 254.29,169.66 254.29,180.67 255.49,181.86 v2(255.49,182.07)
  BOTTOM w0.102: UG6.D5 253.96,163.72 v2(254.31,164.06)
  BOTTOM w0.161: v2(255.49,182.07) 255.86,182.45 VRAM3.B3
VMC_DQ16: length 16.6
  IN2 w0.102: v2(248.74,174.58) 248.73,174.58 248.56,174.41 246.52,174.41 245.7,173.59 245.7,169.38 245.22,168.9 245.22,163.75 245.51,163.46 245.51,162.36 v2(245.9,161.97)
  BOTTOM w0.102: UG6.F17 v2(245.9,161.97)
  BOTTOM w0.161: VRAM3.N13 248.74,174.56 v2(248.74,174.58)
VMC_DQ17: length 10.2
  IN2 w0.102: v2(249.5,171.57) 249.52,171.57 249.88,171.21 249.88,169.45 249.34,168.91 249.34,166.54 248.82,166.02 248.82,165.37 248.38,164.93 248.38,163.76 v2(247.99,163.37)
  BOTTOM w0.161: UG6.E14 247.99,163.36 v2(247.99,163.37) ; VRAM3.U12 v2(249.5,171.57)
VMC_DQ18: length 7
  IN2 w0.102: v2(247.99,164.78) 247.99,164.9 248.52,165.43 248.52,166.06 248.92,166.46 248.92,169.08 249.5,169.66 v2(249.5,170.05)
  BOTTOM w0.102: VRAM3.V12 249.13,170.4 249.47,170.05 v2(249.5,170.05)
  BOTTOM w0.161: v2(247.99,164.78) 247.99,164.73 247.68,164.42 UG6.C14
VMC_DQ19: length 13
  IN2 w0.102: v2(248,161.27) 248.29,160.99 249.27,160.99 249.64,161.36 249.64,168.59 250.7,169.65 250.7,170.4 v2(250.27,170.83)
  BOTTOM w0.102: VRAM3.U11 249.9,171.2 v2(250.27,170.83) ; v2(248,161.27) UG6.H14
VMC_DQ20: length 13.2
  IN2 w0.102: v2(247.97,173.82) 247.97,173.81 247.63,173.47 246.81,173.47 246.25,172.91 246.25,168.97 245.5,168.22 245.5,163.91 245.9,163.51 v2(245.9,163.39)
  BOTTOM w0.161: v2(247.97,173.82) 248.34,173.45 VRAM3.P13 ; UG6.E17 245.9,163.37 v2(245.9,163.39)
VMC_DQ21: length 10.5
  IN2 w0.102: v2(248.74,170.82) 248.74,170.82 249.12,170.44 249.12,169.79 248.14,168.81 248.14,166.19 247.6,165.65 247.6,163.5 v2(246.9,162.81)
  BOTTOM w0.102: UG6.F16 246.41,162.32 v2(246.9,162.81)
  BOTTOM w0.161: VRAM3.U13 248.74,170.83 v2(248.74,170.82)
VMC_DQ22: length 12.3
  IN2 w0.102: v2(249.5,173.06) 249.5,173.06 249.14,172.7 247.7,172.7 247.62,172.61 246.84,172.61 246.62,172.39 246.62,168.57 246.81,168.38 246.81,166.93 246.28,166.41 246.28,165.25 245.9,164.87 v2(245.9,164.77)
  BOTTOM w0.102: v2(249.5,173.06) 249.5,173.07 VRAM3.P12 ; UG6.C17 v2(245.9,164.77)
VMC_DQ23: length 18.5
  IN2 w0.102: v2(247.98,175.32) 247.92,175.27 246.86,175.27 245.27,173.69 245.27,169.51 244.7,168.93 244.7,165.63 244.26,165.19 244.26,161.22 244.51,160.98 244.8,160.98 v2(245.21,160.57)
  BOTTOM w0.102: VRAM3.M13 248.35,174.95 v2(247.98,175.32) ; v2(245.21,160.57) 245.55,160.91 UG6.H17
VMC_DQ24: length 24.4
  IN1 w0.102: v2(249.52,182.07) 249.78,182.33 249.89,182.45 251.11,182.45 252.32,181.24 252.32,168.09 252.64,167.77 252.64,166.43 252.59,166.38 252.59,164.3 251.8,163.51 251.8,162.99 251.63,162.82 v2(251.02,162.82)
  BOTTOM w0.161: v2(249.52,182.07) 249.5,182.07 VRAM3.B12 ; UG6.F10 250.52,162.32 v2(251.02,162.82)
VMC_DQ25: length 26.5
  IN1 w0.102: v2(250.25,182.84) 250.67,183.26 251.23,183.26 252.75,181.73 252.75,168.74 252.93,168.56 252.93,166.14 253.36,165.71 253.36,163.97 253.06,163.67 252.78,163.67 252.58,163.46 252.58,162.96 251.82,162.2 251.82,161.66 251.63,161.48 v2(250.96,161.48)
  BOTTOM w0.102: VRAM3.B11 249.88,182.46 v2(250.25,182.84)
  BOTTOM w0.161: UG6.G10 250.59,161.48 v2(250.96,161.48)
VMC_DQ26: length 16.9
  IN1 w0.102: v2(250.1,164.77) 250.1,164.93 250.47,165.31 250.47,168.16 249.88,168.75 249.88,176.27 249.12,177.03 249.12,179.42 v2(248.75,179.79)
  BOTTOM w0.161: VRAM3.F13 248.72,179.79 v2(248.75,179.79) ; UG6.C11 v2(250.1,164.77)
VMC_DQ27: length 20
  IN1 w0.102: v2(250.12,163.37) 250.5,163.76 250.5,164.97 250.79,165.25 250.79,176.02 251.47,176.7 251.47,177.98 250.75,178.69 250.07,178.69 249.89,178.87 249.89,180.17 v2(249.51,180.56)
  BOTTOM w0.102: v2(249.51,180.56) 249.15,180.2 VRAM3.E12
  BOTTOM w0.161: v2(250.12,163.37) 250.1,163.37 UG6.E11
VMC_DQ28: length 19
  IN1 w0.102: v2(250.1,161.98) 249.71,162.37 249.71,166.17 249.38,166.5 249.38,169.2 249.12,169.45 249.12,175.74 248.35,176.52 248.35,178.74 v2(248.01,179.08)
  BOTTOM w0.161: VRAM3.G13 248.01,179.06 v2(248.01,179.08) ; v2(250.1,161.98) 250.1,161.99 249.77,162.32 UG6.F11
VMC_DQ29: length 20.3
  IN1 w0.102: v2(248.01,180.56) 247.94,180.56 247.59,180.2 247.59,176.58 248.36,175.81 248.36,169.61 248.56,169.4 248.92,169.04 248.92,166.25 249.42,165.75 249.42,163.24 v2(248.99,162.81)
  BOTTOM w0.102: v2(248.01,180.56) 248.37,180.2 VRAM3.E13
  BOTTOM w0.161: UG6.F13 248.5,162.32 v2(248.99,162.81)
VMC_DQ30: length 24.9
  IN1 w0.102: v2(248,161.97) 248.38,162.36 248.38,165.62 247.35,166.65 247.35,168.38 246.63,169.11 246.63,175.01 246.68,175.07 246.68,175.44 246.37,175.75 246.37,181.89 246.93,182.46 248.41,182.46 v2(248.77,182.82)
  BOTTOM w0.102: v2(248.77,182.82) 248.4,182.45 VRAM3.B13
  BOTTOM w0.161: UG6.F14 247.65,162.2 247.88,161.97 v2(248,161.97)
VMC_DQ31: length 30.3
  IN1 w0.102: v2(249.48,183.6) 249.97,184.09 251.06,184.09 253.23,181.93 253.23,169.53 253.77,168.99 253.77,162.83 252.87,161.93 252.87,161.3 252.46,160.89 251.9,160.89 251.75,161.04 250.95,161.04 250.76,160.85 250.48,160.57 v2(250.1,160.57)
  BOTTOM w0.102: VRAM3.A12 249.13,183.25 v2(249.48,183.6)
  BOTTOM w0.254: UG6.H11 v2(250.1,160.57)
VMC_DQ32: length 27.2
  IN1 w0.102: v2(239.6,161.97) 240.01,162.38 240.01,163.18 240.82,163.99 240.82,168.22 238.93,170.11 238.93,176.53 238.82,176.64 238.82,178.17 238.3,178.7 238.3,182.37 236.6,184.07 235.48,184.07 v2(235.03,183.62)
  BOTTOM w0.102: VRAM2.V3 234.63,183.21 v2(235.03,183.62)
  BOTTOM w0.161: UG6.F26 v2(239.6,161.97)
VMC_DQ33: length 23.9
  IN1 w0.102: v2(239.6,163.38) 240,163.78 240,164.4 239.99,164.4 239.99,164.87 240.39,165.27 240.39,167.98 238.54,169.84 238.54,176.16 238.36,176.33 238.36,178.16 237.73,178.79 237.73,182.29 236.81,183.22 236.11,183.22 v2(235.75,182.85)
  BOTTOM w0.102: VRAM2.U4 235.38,182.48 v2(235.75,182.85)
  BOTTOM w0.161: v2(239.6,163.38) 239.25,163.03 UG6.E26
VMC_DQ34: length 31.8
  IN1 w0.102: v2(234.24,182.82) 234.6,183.19 234.6,184.03 235.02,184.44 236.81,184.44 238.89,182.36 238.89,178.69 239.35,178.22 239.39,178.22 239.79,177.82 239.79,169.86 241.23,168.42 241.23,162.35 239.44,160.56 v2(238.9,160.56)
  BOTTOM w0.102: UG6.H26 239.25,160.91 v2(238.9,160.56) ; v2(234.24,182.82) 233.88,182.46 VRAM2.U2
VMC_DQ35: length 18.9
  IN1 w0.102: v2(234.25,179.04) 234.58,178.71 235.9,178.71 236.16,178.45 236.16,178.2 237.04,177.32 237.04,175.87 237.35,175.56 237.35,169.41 238.72,168.04 238.72,164.47 v2(238.48,164.23)
  BOTTOM w0.102: v2(234.25,179.04) 233.88,179.41 VRAM2.N2 ; UG6.D28 237.97,163.72 v2(238.48,164.23)
VMC_DQ36: length 22.2
  IN1 w0.102: v2(239.59,164.76) 240.02,165.19 240.02,167.86 238.13,169.74 238.13,175.91 237.9,176.14 237.9,177.94 237.2,178.64 237.2,182.17 236.92,182.45 235.38,182.45 v2(235.01,182.08)
  BOTTOM w0.102: UG6.C26 239.25,164.43 v2(239.59,164.76) ; v2(235.01,182.08) 234.99,182.08 VRAM2.U3
VMC_DQ37: length 23.3
  IN1 w0.102: v2(233.48,180.58) 233.07,180.99 232.43,180.99 231.78,180.33 231.78,172.69 232.42,172.04 232.92,172.04 233.11,171.86 233.11,171.34 233.25,171.2 233.65,171.2 233.87,170.98 233.87,170.6 234.06,170.41 234.4,170.41 234.63,170.18 234.63,169.49 236.03,168.09 236.03,165.4 236.96,164.46 236.96,163.9 v2(237.49,163.37)
  BOTTOM w0.102: UG6.E29 237.15,163.03 v2(237.49,163.37) ; VRAM2.P2 233.49,180.58 v2(233.48,180.58)
VMC_DQ38: length 20.6
  IN1 w0.102: v2(238.51,162.82) 238.1,163.23 238.1,164.41 238.33,164.63 238.33,167.9 237.02,169.21 237.02,175.23 236.79,175.45 236.4,175.45 236.16,175.69 236.16,177.7 235.92,177.94 233.88,177.94 233.51,178.32 v2(233.51,178.33)
  BOTTOM w0.102: v2(233.51,178.33) 233.51,178.33 233.88,178.69 VRAM2.M2
  BOTTOM w0.161: v2(238.51,162.82) 238.4,162.82 237.9,162.32 UG6.F28
VMC_DQ39: length 23.2
  IN1 w0.102: v2(238.26,161.31) 238.56,161.31 239.19,161.94 239.19,168.08 237.75,169.53 237.75,175.76 237.43,176.08 237.43,177.75 237.17,178.02 236.75,178.02 236.42,178.34 236.42,178.56 236.16,178.83 236.16,179.93 235.9,180.18 235.41,180.18 v2(235.03,180.57)
  BOTTOM w0.102: VRAM2.P3 234.65,180.2 v2(235.03,180.57)
  BOTTOM w0.161: v2(238.26,161.31) 237.95,161.62 UG6.G28
VMC_DQ40: length 11.1
  IN2 w0.102: v2(236.32,162.79) 236.82,163.29 236.82,163.48 236.82,166.1 236.85,166.14 236.85,168.41 235.39,169.86 235.39,171.2 235.02,171.57 v2(235.01,171.57)
  BOTTOM w0.161: UG6.F31 235.85,162.32 v2(236.32,162.79) ; v2(235.01,171.57) 235.01,171.57 234.64,171.2 VRAM2.B3
VMC_DQ41: length 18.4
  IN2 w0.102: v2(237.5,159.17) 237.11,159.56 237.11,160.22 236.45,160.87 235.92,160.87 234.76,162.03 234.76,164.57 234.49,164.84 234.49,165.58 233.95,166.13 233.95,168.11 232.1,169.96 232.1,171.83 232.28,172.01 232.82,172.01 233.05,172.24 233.05,172.63 233.49,173.07 v2(233.49,173.09)
  BOTTOM w0.102: VRAM2.E2 233.86,173.45 233.51,173.09 v2(233.49,173.09) ; UG6.K29 237.15,159.52 v2(237.5,159.17)
VMC_DQ42: length 15.1
  IN2 w0.102: v2(235.01,173.07) 235.01,173.05 236.19,171.87 236.19,171.39 236.48,171.11 236.74,171.11 236.99,170.87 236.99,169.44 237.95,168.47 237.95,165.3 237.88,165.22 237.88,161.81 237.49,161.43 v2(237.49,160.58)
  BOTTOM w0.102: UG6.H29 v2(237.49,160.58) ; v2(235.01,173.07) 235,173.07 234.63,173.44 VRAM2.E3
VMC_DQ43: length 19.3
  IN2 w0.102: v2(238.2,159.87) 237.88,160.19 237.88,161.51 238.08,161.71 238.08,165.05 238.23,165.2 238.23,169.16 237.42,169.97 237.42,173.56 236.91,174.07 236.36,174.07 236.21,173.91 236.21,173.67 235.93,173.39 235.64,173.39 235.59,173.45 234.65,173.45 234.26,173.84 v2(234.25,173.84)
  BOTTOM w0.102: UG6.J28 v2(238.2,159.87) ; VRAM2.F2 233.9,174.2 234.25,173.84 v2(234.25,173.84)
VMC_DQ44: length 7.9
  IN2 w0.102: v2(236.21,164.17) 236.59,164.55 236.59,164.89 236.01,165.47 236.01,168.56 235.01,169.56 v2(235.01,170.06)
  BOTTOM w0.161: VRAM2.A3 235.01,170.06 v2(235.01,170.06) ; UG6.D31 235.81,163.72 236.21,164.13 v2(236.21,164.17)
VMC_DQ45: length 11.6
  IN2 w0.102: v2(236.1,161.27) 236.25,161.27 237.05,162.07 237.05,168.72 236.18,169.6 236.18,170.42 v2(235.78,170.82)
  BOTTOM w0.102: v2(235.78,170.82) 235.4,171.2 VRAM2.B4 ; UG6.G31 v2(236.1,161.27)
VMC_DQ46: length 9.3
  IN2 w0.102: v2(234.25,170.82) 234.26,170.82 234.63,170.45 234.63,169.33 235.77,168.18 235.77,163.75 235.41,163.38 v2(235.39,163.38)
  BOTTOM w0.161: UG6.E32 235.39,163.36 v2(235.39,163.38) ; v2(234.25,170.82) 234.25,170.83 233.88,171.2 VRAM2.B2
VMC_DQ47: length 18.2
  IN2 w0.102: v2(235.4,160.56) 235.4,161.04 234.56,161.88 234.56,162.11 234.32,162.35 233.88,162.35 233.68,162.55 233.68,167.83 231.67,169.84 231.67,173.28 231.98,173.59 232.9,173.59 233.1,173.79 233.1,174.17 233.49,174.56 v2(233.49,174.58)
  BOTTOM w0.102: UG6.H31 235.75,160.91 v2(235.4,160.56) ; v2(233.49,174.58) 233.51,174.58 VRAM2.G2
VMC_DQ48: length 24.6
  IN1 w0.102: v2(240.99,182.08) 241.35,182.44 243.48,182.44 244.56,181.36 244.56,173.81 244.74,173.63 244.74,167.27 245.22,166.79 245.22,164.02 244.71,163.51 244.71,162.89 v2(244.79,162.81)
  BOTTOM w0.161: v2(240.99,182.08) 241.36,182.45 VRAM2.U12 ; UG6.F19 244.64,162.81 v2(244.79,162.81)
VMC_DQ49: length 33.5
  IN1 w0.102: v2(240.26,182.82) 240.63,183.18 240.63,183.87 241.17,184.42 244.08,184.42 245.46,183.04 245.46,175.53 246.14,174.85 246.14,168.9 246.84,168.2 246.84,164.79 247.39,164.25 247.39,161.22 245.33,159.17 v2(245.2,159.17)
  BOTTOM w0.102: v2(240.26,182.82) 240.27,182.82 240.63,182.46 VRAM2.U11 ; UG6.K17 v2(245.2,159.17)
VMC_DQ50: length 15.9
  IN1 w0.102: v2(242.51,179.06) 242.97,178.61 242.97,170.24 243.42,169.79 243.42,165.27 243.79,164.89 v2(243.79,164.77)
  BOTTOM w0.102: v2(243.79,164.77) 243.45,164.42 UG6.C20
  BOTTOM w0.161: VRAM2.M13 242.13,178.7 242.5,179.06 242.5,179.06 v2(242.51,179.06)
VMC_DQ51: length 30.6
  IN1 w0.102: v2(241.05,183.65) 241.49,184.09 243.54,184.09 243.77,183.85 243.77,183.65 245.17,182.25 245.17,175 245.72,174.46 245.72,167.5 246.19,167.02 246.34,166.87 246.34,160.46 245.78,159.9 v2(244.56,159.9)
  BOTTOM w0.102: UG6.J19 244.24,160.22 v2(244.56,159.9)
  BOTTOM w0.161: VRAM2.V12 241.38,183.33 v2(241.05,183.65)
VMC_DQ52: length 19
  IN1 w0.102: v2(243.8,163.37) 243.8,163.52 243.39,163.93 243.39,164.91 243.04,165.26 243.04,169 242.13,169.92 242.13,179.99 242.5,180.36 v2(242.5,180.56)
  BOTTOM w0.161: v2(242.5,180.56) 242.49,180.56 VRAM2.P13 ; UG6.E20 v2(243.8,163.37)
VMC_DQ53: length 20.6
  IN1 w0.102: v2(241.75,179.84) 241.37,179.46 241.37,169.85 242.27,168.94 242.27,167.06 242.61,166.72 242.61,165.13 242.33,164.85 242.33,163.91 242.61,163.63 242.61,162.59 243.23,161.97 v2(243.8,161.97)
  BOTTOM w0.161: v2(241.75,179.84) 242.13,179.46 VRAM2.N13 ; UG6.F20 v2(243.8,161.97)
VMC_DQ54: length 28.9
  IN1 w0.102: v2(241.77,182.82) 242.2,183.26 243.47,183.26 244.9,181.83 244.9,174.64 245.21,174.34 245.21,167.42 245.51,167.12 245.51,161.43 245.03,160.95 244.34,160.95 243.8,160.41 v2(243.8,159.17)
  BOTTOM w0.102: UG6.K20 v2(243.8,159.17)
  BOTTOM w0.161: v2(241.77,182.82) 242.13,182.46 VRAM2.U13
VMC_DQ55: length 23.2
  IN1 w0.102: v2(241,180.56) 240.4,180.56 239.83,179.98 239.83,178.16 240.6,177.38 240.6,169.64 242.03,168.21 242.03,165.93 242.09,165.87 242.09,161.54 v2(243.08,160.55)
  BOTTOM w0.102: VRAM2.P12 241.36,180.2 v2(241,180.56) ; UG6.H20 v2(243.08,160.55)
VMC_DQ56: length 18.9
  IN2 w0.102: v2(241.75,175.3) 242.11,174.94 244.26,174.94 244.8,174.4 244.8,169.66 244.22,169.08 244.22,167.24 243.41,166.43 243.41,161.65 v2(243.06,161.3)
  BOTTOM w0.102: v2(243.06,161.3) 242.37,161.3 UG6.G22
  BOTTOM w0.161: v2(241.75,175.3) 242.11,174.95 VRAM2.G13
VMC_DQ57: length 15.6
  IN2 w0.102: v2(241.75,173.81) 242.12,173.44 242.79,173.44 242.99,173.25 242.99,172.23 243.2,172.02 243.52,172.02 243.82,171.72 243.82,170.03 243.49,169.7 243.49,167.51 242.61,166.64 242.61,165.36 242.33,165.07 242.33,163.95 242.51,163.76 242.51,161.96 v2(242.69,161.78)
  BOTTOM w0.102: UG6.F22 242.59,161.78 v2(242.69,161.78) ; v2(241.75,173.81) 242.12,173.45 VRAM2.E13
VMC_DQ58: length 7.4
  IN2 w0.102: v2(242.51,170.8) 242.5,170.8 242.18,170.49 242.18,169.31 242.01,169.14 242.01,165.78 241.7,165.47 v2(241.7,165.46)
  BOTTOM w0.102: VRAM2.B13 242.13,171.19 v2(242.51,170.8) ; UG6.C23 241.35,164.62 241.7,164.97 v2(241.7,165.46)
VMC_DQ59: length 13.9
  IN2 w0.102: v2(242.51,174.56) 242.51,174.56 242.94,174.13 244.05,174.13 244.36,173.83 244.36,169.84 243.82,169.3 243.82,167.32 242.95,166.45 242.95,165.31 242.62,164.99 242.62,164.29 v2(242.71,164.2)
  BOTTOM w0.161: v2(242.51,174.56) 242.49,174.56 VRAM2.F13 ; UG6.D22 242.23,163.72 v2(242.71,164.2)
VMC_DQ60: length 8.2
  IN2 w0.102: v2(241.75,170.01) 241.75,169.4 241.14,168.79 241.14,166.42 241.32,166.25 241.32,163.76 v2(241.71,163.37)
  BOTTOM w0.102: UG6.E23 241.7,163.37 v2(241.71,163.37)
  BOTTOM w0.161: VRAM2.A12 241.38,170.38 v2(241.75,170.01)
VMC_DQ61: length 11.4
  IN2 w0.102: v2(240.3,161.97) 241.09,162.76 241.09,163.5 241,163.59 241,165.24 240.84,165.4 240.84,169.19 241.37,169.72 241.37,170.43 v2(240.99,170.81)
  BOTTOM w0.102: UG6.F23 241.11,162.32 240.76,161.97 v2(240.3,161.97)
  BOTTOM w0.161: v2(240.98,170.81) 240.99,170.81 VRAM2.B12
VMC_DQ62: length 9.8
  IN2 w0.102: v2(240.4,162.73) 240.4,163.01 240,163.41 240,167.71 239.61,168.09 239.61,168.83 240.17,169.4 v2(240.17,170.02)
  BOTTOM w0.102: v2(240.17,170.02) 240.26,170.11 240.26,170.83 240.63,171.19 VRAM2.B11
  BOTTOM w0.161: UG6.F25 239.98,162.32 v2(240.4,162.73)
VMC_DQ63: length 15.2
  IN2 w0.102: v2(239.6,161.26) 239.2,161.66 239.2,168.89 239.78,169.47 239.78,171.86 240.98,173.07 v2(240.98,173.08)
  BOTTOM w0.102: UG6.H23 240.95,161.32 239.66,161.32 v2(239.6,161.26)
  BOTTOM w0.161: VRAM2.E12 241.36,173.45 241,173.08 v2(240.98,173.08)
VMC_WCK01: length 18.7
  IN4 w0.102: v2(253.8,172.13) 253.64,172.29 253.32,172.29 253.17,172.13 253.17,170.13 251.94,168.91 251.38,168.91 250.6,168.13 249.91,168.13 249.64,167.86 249.64,159.66 249.39,159.41 248.86,159.41 248.71,159.25 v2(248.71,159.15)
  BOTTOM w0.102: v2(248.71,159.15) 248.35,159.51 UG6.K13
  BOTTOM w0.114: v2(253.8,172.13) 253.94,172.27 254.29,172.27 254.35,172.33 254.76,172.33 VRAM3.R4
VMC_WCK01#: length 18.6
  IN4 w0.102: v2(253.82,172.75) 253.82,172.62 253.69,172.49 253.24,172.49 252.96,172.22 252.96,170.22 251.86,169.11 251.29,169.11 250.51,168.33 249.83,168.33 249.44,167.95 249.44,159.75 249.31,159.62 248.82,159.62 248.7,159.74 248.7,159.88 v2(248.76,159.94)
  BOTTOM w0.102: UG6.J13 248.26,160.13 248.26,159.99 248.44,159.81 248.66,159.81 248.76,159.91 v2(248.76,159.94)
  BOTTOM w0.114: VRAM3.R5 254.38,172.66 254.2,172.49 253.95,172.49 253.82,172.62 v2(253.82,172.75)
VMC_WCK23: length 18.7
  IN4 w0.102: v2(246.58,159.87) 246.37,159.66 246.23,159.66 246.11,159.77 246.11,159.95 246.5,160.34 246.5,165.41 246.82,165.73 246.82,166.59 247.69,167.46 247.69,168.18 248.88,169.37 249.68,169.37 250.85,170.54 250.85,171.82 250.66,172.01 250.66,172.45 250.78,172.58 251.2,172.58 251.26,172.51 v2(251.26,172.34)
  BOTTOM w0.102: v2(246.58,159.87) 246.25,160.21 UG6.J16 ; v2(251.26,172.34) 251.25,172.33 250.24,172.33 VRAM3.R11
VMC_WCK23#: length 18.7
  IN4 w0.102: v2(251.25,173.03) 251.25,172.88 251.15,172.78 250.7,172.78 250.45,172.54 250.45,171.93 250.65,171.73 250.65,170.62 249.6,169.57 248.8,169.57 247.49,168.26 247.49,167.55 246.61,166.67 246.61,165.81 246.3,165.49 246.3,160.43 245.91,160.03 245.91,159.69 246.08,159.51 246.08,159.37 v2(245.89,159.17)
  BOTTOM w0.102: UG6.K16 246.2,159.57 246.03,159.57 245.84,159.38 245.84,159.22 v2(245.89,159.17)
  BOTTOM w0.114: VRAM3.R10 250.65,172.67 251.01,172.67 251.25,172.91 v2(251.25,173.03)
VMC_WCK45: length 27.2
  IN4 w0.102: v2(236.1,159.15) 236.26,159.32 236.63,159.32 236.94,159.63 236.94,160.58 237.4,161.04 237.4,161.54 236.94,162 236.94,165.65 237.37,166.08 237.78,166.08 238.43,166.73 238.43,175.68 237.85,176.25 237.85,180.89 237.49,181.25 236.87,181.25 v2(236.69,181.43)
  BOTTOM w0.102: UG6.K31 235.75,159.5 v2(236.1,159.15)
  BOTTOM w0.114: v2(236.69,181.43) 236.58,181.33 235.76,181.33 VRAM2.R4
VMC_WCK45#: length 27.2
  IN4 w0.102: v2(236.64,180.73) 236.58,180.79 236.58,180.93 236.69,181.04 236.78,181.04 236.78,181.04 237.41,181.04 237.65,180.8 237.65,176.17 238.22,175.6 238.22,166.81 237.69,166.28 237.28,166.28 236.74,165.73 236.74,161.92 237.2,161.46 237.2,161.12 236.74,160.67 236.74,159.71 236.55,159.52 236.2,159.52 236.05,159.67 236.05,159.81 v2(236.12,159.88)
  BOTTOM w0.102: v2(236.12,159.88) 236.06,159.82 235.56,159.82 235.45,159.93 235.45,160.1 235.57,160.22 UG6.J31
  BOTTOM w0.114: VRAM2.R5 236.13,181 236.24,181.11 236.46,181.11 236.64,180.93 v2(236.64,180.73)
VMC_WCK67: length 32.9
  IN4 w0.102: v2(240.3,159.16) 240.28,159.18 240.28,159.33 240.4,159.45 240.68,159.45 240.91,159.68 240.91,161.81 241.32,162.22 241.32,164.68 240.7,165.29 240.7,167.83 242.18,169.31 243.39,169.31 244.1,170.02 244.1,175.5 243.66,175.95 240.68,175.95 240.37,175.63 239.12,175.63 238.43,176.32 238.43,180.59 238.65,180.81 239.14,180.81 v2(239.33,180.63)
  BOTTOM w0.102: v2(239.33,180.63) 239.35,180.61 240.29,180.61 VRAM2.R11 ; v2(240.3,159.16) 240.26,159.16 239.95,159.47 UG6.K25
VMC_WCK67#: length 32.8
  IN4 w0.102: v2(240.31,159.89) 240.31,159.76 240.42,159.66 240.59,159.66 240.7,159.77 240.7,161.9 241.11,162.31 241.11,164.59 240.5,165.21 240.5,167.92 242.09,169.51 243.3,169.51 243.9,170.11 243.9,175.41 243.57,175.74 240.76,175.74 240.45,175.43 239.04,175.43 238.23,176.24 238.23,180.68 238.57,181.02 239.23,181.02 239.33,181.12 v2(239.33,181.27)
  BOTTOM w0.102: v2(240.31,159.89) 240.25,159.82 239.81,159.82 239.71,159.93 239.71,160.12 239.81,160.22 UG6.J25
  BOTTOM w0.114: v2(239.33,181.27) 239.33,181.16 239.55,180.94 239.87,180.94 VRAM2.R10
VMC_WCKB01: length 37.6
  IN4 w0.102: v2(250.1,159.18) 250.26,159.34 250.44,159.34 250.73,159.63 252.85,159.63 253.39,160.17 253.39,160.87 253.22,161.03 253.22,162.15 253.78,162.7 253.78,164.21 254.02,164.45 254.5,164.45 254.88,164.06 255.63,164.06 256.15,164.58 256.96,164.58 257.59,165.21 258.17,165.21 258.65,165.68 258.65,167.41 260.51,169.28 260.51,175.31 258.96,176.86 258.96,177.96 258.11,178.82 257.42,178.82 257.22,178.62 256.85,178.62 256.26,179.21 254.64,179.21 254.34,179.5 254.34,181.08 254.12,181.3 253.79,181.3 v2(253.63,181.46)
  BOTTOM w0.102: v2(250.1,159.18) 249.75,159.52 UG6.K11
  BOTTOM w0.114: v2(253.63,181.46) 253.73,181.36 253.87,181.36 253.87,181.36 254.35,181.36 254.35,181.36 254.68,181.36 255.09,180.95 VRAM3.D4
VMC_WCKB01#: length 37.6
  IN4 w0.102: v2(253.63,180.85) 253.63,180.98 253.74,181.09 254.04,181.09 254.14,180.99 254.14,179.42 254.55,179 256.18,179 256.77,178.41 257.3,178.41 257.51,178.62 258.02,178.62 258.76,177.88 258.76,176.78 260.31,175.23 260.31,169.36 258.44,167.49 258.44,165.76 258.09,165.41 257.5,165.41 256.88,164.78 256.06,164.78 255.55,164.27 254.96,164.27 254.58,164.65 253.93,164.65 253.58,164.29 253.58,162.78 253.02,162.23 253.02,160.95 253.19,160.78 253.19,160.25 252.77,159.84 250.64,159.84 250.35,159.55 250.18,159.55 250.08,159.66 250.08,159.85 v2(250.1,159.87)
  BOTTOM w0.102: v2(250.1,159.87) 250.08,159.85 249.39,159.85 249.27,159.97 249.27,160.12 249.38,160.22 UG6.J11
  BOTTOM w0.114: v2(253.63,180.85) 253.63,180.89 253.89,181.14 254.26,181.14 254.38,181.03 VRAM3.D5
VMC_WCKB23: length 27
  IN4 w0.102: v2(251.1,180.45) 251.3,180.64 251.7,180.64 252.25,180.1 252.25,170.24 251.6,169.59 250.87,169.59 250.09,168.81 249.44,168.81 248.93,168.31 248.93,166.79 248.57,166.42 247.98,166.42 247.4,165.84 247.4,160.99 247.77,160.62 247.77,160.41 247.66,160.3 247.48,160.3 v2(247.26,160.53)
  BOTTOM w0.102: VRAM3.D11 250.26,180.56 250.99,180.56 v2(251.1,180.45) ; UG6.J14 247.57,160.22 v2(247.26,160.53)
VMC_WCKB23#: length 26.9
  IN4 w0.102: v2(251.16,181.04) 251.35,180.85 251.79,180.85 252.45,180.19 252.45,170.16 251.68,169.39 250.96,169.39 250.17,168.6 249.52,168.6 249.14,168.22 249.14,166.71 248.65,166.22 248.06,166.22 247.6,165.76 247.6,161.07 247.97,160.7 247.97,160.33 247.74,160.1 247.42,160.1 247.24,159.93 v2(247.24,159.92)
  BOTTOM w0.102: UG6.K14 247.64,159.52 v2(247.24,159.92)
  BOTTOM w0.114: v2(251.16,181.04) 251.07,181.04 250.97,180.95 VRAM3.D10
VMC_WCKB45: length 18
  IN4 w0.102: v2(236.61,173.06) 236.78,172.89 236.96,172.89 237.27,172.59 237.27,169.23 236,167.96 236,166.32 235.64,165.97 235.23,165.97 234.98,165.72 234.98,160.44 235.44,159.99 235.44,159.59 235.17,159.32 234.95,159.32 234.86,159.32 v2(234.7,159.16)
  BOTTOM w0.102: v2(234.7,159.16) 235.05,159.51 UG6.K32
  BOTTOM w0.114: v2(236.61,173.06) 236.6,173.06 235.74,173.06 VRAM2.D4
VMC_WCKB45#: length 18.1
  IN4 w0.102: v2(236.61,172.25) 236.56,172.3 236.56,172.58 236.67,172.69 236.88,172.69 237.07,172.5 237.07,169.32 235.8,168.05 235.8,166.41 235.56,166.17 235.15,166.17 234.78,165.8 234.78,160.36 235.23,159.9 235.23,159.68 235.08,159.53 234.95,159.53 234.8,159.53 234.65,159.68 234.65,159.82 v2(234.69,159.86)
  BOTTOM w0.102: v2(236.61,172.25) 236.76,172.4 236.76,172.59 236.67,172.68 236.14,172.68 VRAM2.D5 ; v2(234.69,159.86) 234.73,159.82 235.07,159.82 235.18,159.94 235.18,160.09 UG6.J32
VMC_WCKB67: length 16.7
  IN4 w0.102: v2(239.35,173.02) 239.34,173.02 239.18,172.87 238.95,172.87 238.67,172.58 238.67,164.64 238.95,164.35 238.95,161.07 239.42,160.6 239.42,159.84 239.26,159.68 238.93,159.68 238.88,159.72 238.85,159.75 v2(238.85,159.91)
  BOTTOM w0.102: VRAM2.D11 240.3,173.03 239.35,173.03 v2(239.35,173.02) ; UG6.J26 238.94,159.91 v2(238.85,159.91)
VMC_WCKB67#: length 16.6
  IN4 w0.102: v2(239.34,172.34) 239.37,172.37 239.37,172.52 239.23,172.66 239.03,172.66 238.87,172.5 238.87,164.72 239.16,164.43 239.16,161.15 239.63,160.68 239.63,159.76 239.34,159.48 238.91,159.48 238.83,159.4 238.83,159.21 v2(238.88,159.16)
  BOTTOM w0.102: UG6.K26 239.19,159.58 239.04,159.58 238.82,159.36 238.82,159.22 v2(238.88,159.16)
  BOTTOM w0.114: VRAM2.D10 239.58,172.7 239.34,172.46 v2(239.34,172.34)
VMD_CLK0: length 21.9
  IN4 w0.102: v2(267.75,148.29) 267.59,148.13 267.59,147.79 267.25,147.46 266.73,147.46 266.5,147.69 259.21,147.69 258.52,146.99 257.29,146.99 256.83,147.46 256.83,148.83 256.49,149.16 250.68,149.16 250.36,149.49 250.36,149.75 v2(250.07,150.04)
  BOTTOM w0.102: v2(250.07,150.04) 250.45,150.42 UG6.AC10 ; VRAM7.J10 268.1,147.95 v2(267.75,148.29)
VMD_CLK0#: length 21.9
  IN4 w0.102: v2(267,148.3) 267.06,148.35 267.24,148.35 267.38,148.2 267.38,147.88 267.17,147.66 266.82,147.66 266.58,147.89 259.13,147.89 258.43,147.2 257.38,147.2 257.03,147.54 257.03,148.91 256.57,149.37 250.77,149.37 250.56,149.57 250.56,149.94 250.66,150.05 250.82,150.05 v2(250.82,150.04)
  BOTTOM w0.102: v2(267,148.3) 267.15,148.3 267.38,148.07 VRAM7.K10 ; UG6.AC9 251.13,150.4 250.84,150.4 250.72,150.29 250.72,150.14 v2(250.82,150.04)
VMD_CLK1: length 27.3
  IN4 w0.102: v2(250.1,150.77) 250.22,150.77 250.34,150.89 250.34,151.14 250.56,151.37 256.4,151.37 256.81,151.78 256.81,152.42 256.67,152.55 256.67,153.1 257.26,153.69 265.66,153.69 266.38,154.41 267.72,154.41 268.2,154.88 268.2,158.55 267.99,158.75 267.71,158.75 267.48,158.98 267.48,159.29 267.38,159.39 v2(267.25,159.39)
  BOTTOM w0.102: v2(250.1,150.77) 250.45,151.12 UG6.AB10 ; v2(267.25,159.39) 267.25,158.82 VRAM5.J10
VMD_CLK1#: length 27.3
  IN4 w0.102: v2(250.8,150.78) 250.67,150.78 250.54,150.91 250.54,151.06 250.65,151.17 256.48,151.17 257.01,151.69 257.01,152.5 256.88,152.63 256.88,153.02 257.35,153.49 265.75,153.49 266.46,154.2 267.81,154.2 268.4,154.8 268.4,158.63 268.08,158.96 267.79,158.96 267.69,159.06 267.69,159.29 267.78,159.39 v2(267.89,159.39)
  BOTTOM w0.102: UG6.AB9 251.14,151.12 v2(250.8,150.78)
  BOTTOM w0.114: VRAM5.K10 267.89,158.93 v2(267.89,159.39)
VMD_DQ0: length 11.3
  IN2 w0.102: v2(255.14,141.5) 255.36,141.72 258.98,141.72 259.6,141.09 262.73,141.09 262.88,141.23 262.88,141.77 263.04,141.93 263.61,141.93 v2(263.99,142.31)
  BOTTOM w0.102: VRAM7.P2 264.01,142.31 v2(263.99,142.31) ; v2(255.14,141.5) 255.14,141.53 UG6.AR4
VMD_DQ1: length 20.5
  IN2 w0.102: v2(265.51,142.31) 265.75,142.07 265.75,140.04 264.39,138.67 253.93,138.67 251.88,140.73 251.88,141.99 v2(251.5,142.37)
  BOTTOM w0.102: v2(265.51,142.31) 265.51,142.3 265.87,141.95 VRAM7.M2 ; UG6.AP8 v2(251.5,142.37)
VMD_DQ2: length 16.9
  IN2 w0.102: v2(264.76,141.55) 264.76,139.96 264,139.2 257.08,139.2 256.56,139.72 254.28,139.72 253.26,140.74 253.26,142.01 v2(252.89,142.37)
  BOTTOM w0.102: VRAM7.N2 265.13,141.92 v2(264.76,141.55) ; v2(252.89,142.37) 253.24,142.72 UG6.AP6
VMD_DQ3: length 16.1
  IN2 w0.102: v2(264.75,143.08) 264.38,142.71 264.38,141.27 264.22,141.11 263.89,141.11 263.72,140.94 263.72,140.29 263.17,139.74 257.13,139.74 256.86,140.01 256.86,140.39 256.56,140.69 254.17,140.69 253.64,141.22 v2(253.64,141.61)
  BOTTOM w0.102: v2(264.75,143.08) 264.38,142.71 VRAM7.P3
  BOTTOM w0.161: UG6.AR6 253.25,142 v2(253.64,141.61)
VMD_DQ4: length 10.3
  IN2 w0.102: v2(253.65,143.69) 253.65,143.2 253.95,142.9 254.47,142.9 254.69,143.12 260.29,143.12 260.71,142.7 261.35,142.7 v2(261.74,143.08)
  BOTTOM w0.102: VRAM7.U3 262.11,142.7 261.74,143.07 v2(261.74,143.08) ; v2(253.65,143.69) 253.25,144.09 UG6.AM6
VMD_DQ5: length 7.5
  IN2 w0.102: v2(261.75,141.54) 261.36,141.92 259.7,141.92 259.64,141.98 256.07,141.98 v2(255.7,142.36)
  BOTTOM w0.102: VRAM7.U2 262.13,141.92 261.75,141.54 v2(261.75,141.54)
  BOTTOM w0.161: v2(255.7,142.36) 255.7,142.37 UG6.AP3
VMD_DQ6: length 8.1
  IN2 w0.102: v2(254.3,142.37) 254.75,142.82 260.03,142.82 260.54,142.31 260.95,142.31 v2(260.96,142.31)
  BOTTOM w0.102: UG6.AP5 253.95,142.72 v2(254.3,142.37) ; VRAM7.V3 261.35,142.7 260.97,142.31 v2(260.96,142.31)
VMD_DQ7: length 12.2
  IN2 w0.102: v2(250.79,143.77) 251.03,144.01 251.88,144.01 251.96,144.08 256.22,144.08 256.42,143.88 v2(260.91,143.88)
  BOTTOM w0.102: UG6.AM9 251.14,144.12 v2(250.79,143.77) ; VRAM7.U4 261.75,143.82 260.98,143.82 v2(260.91,143.88)
VMD_DQ8: length 19.5
  IN1 w0.102: 259.31,139.85 259.3,139.84 254.73,139.84 v2(254.29,140.28)
  IN1 w0.127: v2(271.49,141.58) 271.08,141.18 271.08,140.48 270.79,140.19 267.49,140.19 267.16,139.85 259.31,139.85
  BOTTOM w0.102: UG6.AU5 v2(254.29,140.28) ; VRAM7.E2 v2(271.49,141.58)
VMD_DQ9: length 24.9
  IN1 w0.102: v2(273.74,142.3) 273.39,141.96 273.39,140.27
  IN1 w0.127: v2(253.7,139.44) 253.7,139 254.6,138.1 267.88,138.1 268.22,138.44 271.71,138.44 273.39,140.11 273.39,140.27
  BOTTOM w0.102: VRAM7.B2 273.38,141.95 v2(273.74,142.3) ; UG6.AV6 253.25,139.89 v2(253.7,139.44)
VMD_DQ10: length 29.7
  IN1 w0.102: v2(274.58,143.06) 274.19,142.67 274.19,140.28
  IN1 w0.127: 274.19,140.28 274.19,140.08 271.62,137.52 252.3,137.52 250.95,138.86 v2(250.95,139.14)
  BOTTOM w0.161: UG6.AV9 250.95,139.72 v2(250.95,139.14) ; VRAM7.A3 274.19,142.7 274.29,142.79 274.31,142.79 v2(274.58,143.06)
VMD_DQ11: length 15.9
  IN1 w0.127: v2(270.01,141.57) 269.51,141.07 260.92,141.07 260.49,140.64 256.94,140.64 256.56,140.26 v2(255.7,140.26)
  BOTTOM w0.161: UG6.AU3 255.7,140.27 v2(255.7,140.26) ; v2(270.01,141.57) 269.63,141.95 VRAM7.G2
VMD_DQ12: length 19.7
  IN1 w0.102: v2(270.74,142.3) 270.12,142.3 269.75,141.93 268.89,141.93 260.59,141.93 259.57,140.91 255.72,140.91 255.46,140.66 254.13,140.66 253.73,140.26 v2(252.9,140.26)
  BOTTOM w0.102: VRAM7.F2 270.38,141.95 v2(270.74,142.3)
  BOTTOM w0.161: UG6.AU6 253.25,140.62 v2(252.9,140.26)
VMD_DQ13: length 22.2
  IN1 w0.102: v2(271.5,143.07) 271.14,142.7 260.6,142.7 259.65,141.75 255.94,141.75 255.11,140.93 252.17,140.93 v2(251.5,140.26)
  BOTTOM w0.102: v2(251.5,140.26) 251.85,140.61 UG6.AU8 ; v2(271.5,143.07) 271.5,143.07 VRAM7.E3
VMD_DQ14: length 26.9
  IN1 w0.102: v2(250.09,140.28) 250.65,140.28 251.88,141.5 251.88,142.1 252.61,142.84 259.33,142.84 260.78,144.29 273.06,144.29 273.51,143.83 v2(273.77,143.83)
  BOTTOM w0.102: UG6.AU10 250.43,140.62 v2(250.09,140.28)
  BOTTOM w0.161: v2(273.77,143.83) 273.39,143.45 VRAM7.B4
VMD_DQ15: length 22.8
  IN1 w0.102: v2(273,143.09) 272.62,143.47 260.76,143.47 259.26,141.97 254.02,141.97 254.01,141.99 253.36,141.99 252.67,141.99 v2(252.27,141.59)
  BOTTOM w0.102: VRAM7.B3 273.38,142.71 v2(273,143.09)
  BOTTOM w0.161: UG6.AR7 252.27,141.74 v2(252.27,141.59)
VMD_DQ16: length 10
  IN2 w0.102: v2(261.75,148.3) 261.29,147.84 260.64,147.84 260.05,147.25 255.07,147.25 254.34,147.98 253.74,147.98 v2(253.66,147.91)
  BOTTOM w0.102: UG6.AF6 253.25,148.27 253.62,147.91 v2(253.66,147.91) ; v2(261.75,148.3) 262.13,148.67 VRAM7.U11
VMD_DQ17: length 15.6
  IN2 w0.102: v2(264.75,149.82) 265.13,149.44 265.13,147.95 264.92,147.74 264.92,146.78 264.42,146.28 257.37,146.28 257.01,145.93 256.04,145.93 255.79,146.18 254.69,146.18 v2(254.29,146.58)
  BOTTOM w0.102: v2(264.75,149.83) 265.12,150.2 VRAM7.N13 ; UG6.AH5 v2(254.29,146.58)
VMD_DQ18: length 11.1
  IN2 w0.102: v2(255.69,146.57) 256.07,146.19 256.81,146.19 257.17,146.55 261.73,146.55 262.13,146.95 262.13,147.33 262.47,147.67 262.89,147.67 264.01,148.79 v2(264.01,149.06)
  BOTTOM w0.102: v2(264.01,149.06) 264.01,149.06 264.38,149.43 VRAM7.P12 ; UG6.AH3 255.35,146.91 v2(255.69,146.57)
VMD_DQ19: length 23.2
  IN2 w0.102: v2(265.51,150.59) 265.88,150.22 265.88,149.58 265.88,149.58 265.88,148.89 266.09,148.68 266.46,148.68 266.62,148.51 266.62,147.09 265.39,145.86 261.07,145.86 260.2,144.99 253.8,144.99 252.49,146.3 252.49,146.32 250.83,147.97 v2(250.79,147.97)
  BOTTOM w0.102: UG6.AF9 251.14,148.32 v2(250.79,147.97) ; VRAM7.M13 265.88,150.23 v2(265.51,150.59)
VMD_DQ20: length 11.1
  IN2 w0.102: v2(262.5,149.06) 262.12,149.44 260.17,149.44 259.99,149.26 253.49,149.26 v2(252.91,148.67)
  BOTTOM w0.102: v2(262.5,149.06) 262.5,149.07 VRAM7.U12 ; v2(252.91,148.67) 253.25,149.02 UG6.AE6
VMD_DQ21: length 12.1
  IN2 w0.114: v2(261.75,149.82) 261.36,150.21 260.31,150.21 259.66,149.56 252.85,149.56 252.36,149.07 251.92,149.07 v2(251.5,148.66)
  BOTTOM w0.102: VRAM7.U13 261.75,149.82 v2(261.75,149.82)
  BOTTOM w0.161: UG6.AE8 251.5,148.67 v2(251.5,148.66)
VMD_DQ22: length 8.2
  IN2 w0.102: v2(260.98,149.06) 260.49,149.06 259.82,148.39 257.07,148.39 256.95,148.27 254.72,148.27 v2(254.3,148.68)
  BOTTOM w0.102: UG6.AE5 253.96,149.02 v2(254.3,148.68) ; v2(260.98,149.06) 261,149.08 261.01,149.08 VRAM7.V12
VMD_DQ23: length 16.2
  IN2 w0.102: v2(263.99,150.59) 263.98,150.59 263.56,151.01 260.32,151.01 259.7,150.4 252.31,150.4 251.86,149.94 251.86,149.83 251.28,149.26 250.65,149.26 250.1,148.7 v2(250.1,148.67)
  BOTTOM w0.102: v2(263.99,150.59) 263.99,150.58 VRAM7.P13 ; v2(250.1,148.67) 250.45,149.02 UG6.AE10
VMD_DQ24: length 24.8
  IN1 w0.102: v2(273.02,149.07) 273.02,148.9 272.6,148.48 272.6,148.17 273.18,147.59 273.18,147.03 272.46,146.31 260.43,146.31 259.24,145.12 253.54,145.12 v2(252.89,144.47)
  BOTTOM w0.102: VRAM7.B12 273.02,149.09 v2(273.02,149.07) ; v2(252.89,144.47) 253.24,144.82 UG6.AL6
VMD_DQ25: length 23.4
  IN1 w0.102: v2(274.52,149.06) 274.17,148.71 274.17,146.55 273.28,145.66 260.96,145.66 259.33,144.03 256.2,144.03 255.76,144.47 v2(255.7,144.47)
  BOTTOM w0.102: UG6.AL3 v2(255.7,144.47)
  BOTTOM w0.161: VRAM7.A12 274.52,149.06 v2(274.52,149.06)
VMD_DQ26: length 23.1
  IN1 w0.102: v2(273.76,148.32) 273.38,147.94 273.38,147.18 273.51,147.06 273.51,146.54 272.91,145.94 260.67,145.94 259.58,144.85 254.68,144.85 v2(254.3,144.47)
  BOTTOM w0.102: v2(273.76,148.32) 273.39,148.7 VRAM7.B11
  BOTTOM w0.161: UG6.AL5 v2(254.3,144.47)
VMD_DQ27: length 30.1
  IN1 w0.102: v2(273.77,149.82) 274.11,149.48 274.72,149.48 275.03,149.16 275.03,146.92 273.45,145.34 265.51,145.34 265.51,145.35 261.21,145.35 259.4,143.54 256.39,143.54 255.84,144.08 251.88,144.08 v2(251.51,144.46)
  BOTTOM w0.102: v2(251.51,144.46) 251.85,144.81 UG6.AL8 ; v2(273.77,149.82) 273.39,150.2 VRAM7.B13
VMD_DQ28: length 20.7
  IN1 w0.102: v2(253.67,145.79) 253.76,145.88 254.61,145.88 254.91,146.18 256.69,146.18 257.08,146.57 259.3,146.57 260.47,147.74 270.2,147.74 270.39,147.92 270.39,148.49 270.59,148.69 270.61,148.69 270.61,148.69 270.93,148.69 271.13,148.69 v2(271.5,149.06)
  BOTTOM w0.102: UG6.AJ6 253.25,146.2 v2(253.67,145.79) ; VRAM7.E12 271.13,149.44 v2(271.5,149.06)
VMD_DQ29: length 23.8
  IN1 w0.102: v2(270.01,150.58) 269.63,150.21 260.85,150.21 258.72,148.08 257.1,148.08 256.46,147.44 254.57,147.44 254.35,147.22 252.83,147.22 251.84,146.23 251.84,145.68 251.51,145.35 250.98,145.35 v2(250.1,144.47)
  BOTTOM w0.102: UG6.AL10 v2(250.1,144.47) ; VRAM7.G13 269.63,150.21 v2(270.01,150.58)
VMD_DQ30: length 20.2
  IN1 w0.102: v2(270.75,149.85) 270.62,149.85 270.21,149.44 260.82,149.44 258.62,147.24 254.75,147.24 254.5,146.98 253.33,146.98 v2(252.91,146.57)
  BOTTOM w0.102: VRAM7.F13 270.72,149.85 v2(270.75,149.85) ; v2(252.91,146.57) 253.25,146.91 UG6.AH6
VMD_DQ31: length 23.6
  IN1 w0.102: v2(251.51,146.56) 251.96,147.01 251.96,147.95 252.3,148.29 256.74,148.29 256.85,148.4 258.23,148.4 260.81,150.98 271.08,150.98 v2(271.5,150.56)
  BOTTOM w0.102: v2(251.51,146.56) 251.85,146.91 UG6.AH8 ; v2(271.5,150.56) 271.49,150.56 VRAM7.E13
VMD_DQ32: length 27.6
  IN1 w0.102: v2(254.31,154.96) 254.68,154.6 256.03,154.6 257.03,155.6 257.86,155.6 260.26,158 260.26,158.56 260.66,158.95 260.66,159.43 262.2,160.97 273.71,160.97 274.23,161.49 274.23,162.74 274.13,162.85 274.13,163.92 v2(273.75,164.3)
  BOTTOM w0.102: UG6.T5 v2(254.31,154.96) ; v2(273.75,164.3) 273.38,164.68 VRAM5.U2
VMD_DQ33: length 29.8
  IN1 w0.102: v2(274.52,163.57) 275.07,163.02 275.07,161.58 273.89,160.4 262.71,160.4 261.22,158.92 261.04,158.92 260.54,158.41 260.54,157.69 259.33,156.47 259.33,155.33 258.79,154.8 256.78,154.8 256.32,154.34 254.37,154.34 253.73,154.98 v2(252.91,154.98)
  BOTTOM w0.161: VRAM5.V3 274.14,163.95 v2(274.52,163.57) ; UG6.T6 v2(252.91,154.98)
VMD_DQ34: length 25.1
  IN1 w0.102: v2(271.48,163.57) 271.47,163.57 271.09,163.95 260.81,163.95 260.27,163.41 260.27,160.85 259.35,159.92 259.35,159.11 258.93,158.69 257.65,158.69 256.78,157.82 256.78,156.89 256.58,156.69 254.37,156.69 v2(253.74,156.06)
  BOTTOM w0.102: v2(253.74,156.06) 253.25,156.55 UG6.P6 ; v2(271.48,163.57) 271.47,163.57 271.13,163.92 VRAM5.P3
VMD_DQ35: length 27.3
  IN1 w0.102: v2(251.5,154.97) 251.9,155.36 255.96,155.36 256.71,156.12 257.4,156.12 259.67,158.39 259.67,158.72 260.06,159.1 260.06,159.79 261.38,161.11 261.38,162.07 261.67,162.36 271.81,162.36 v2(273.01,163.56)
  BOTTOM w0.102: v2(273.01,163.56) 273.38,163.93 VRAM5.U3 ; v2(251.5,154.97) 251.85,155.32 UG6.T8
VMD_DQ36: length 23.4
  IN1 w0.102: v2(255.7,154.98) 256,154.98 256.88,155.86 257.63,155.86 259.93,158.16 259.93,158.63 260.36,159.06 260.36,159.62 262.16,161.42 273.26,161.42 273.44,161.6 273.44,162.51 v2(273.74,162.81)
  BOTTOM w0.102: v2(255.7,154.98) 255.36,155.32 UG6.T3 ; v2(273.74,162.81) 273.74,162.83 VRAM5.U4
VMD_DQ37: length 22.5
  IN1 w0.102: v2(254.3,157.07) 254.45,157.07 254.89,157.51 255.3,157.51 256.86,159.07 256.86,159.31 257.4,159.85 258.48,159.85 259.59,160.96 259.59,164.3 260.8,165.52 267.92,165.52 268.34,165.1 v2(270,165.1)
  BOTTOM w0.161: VRAM5.M2 269.63,164.72 270,165.09 v2(270,165.1) ; UG6.N5 v2(254.3,157.07)
VMD_DQ38: length 21.5
  IN1 w0.102: v2(255.69,157.08) 255.69,157.3 257.23,158.84 257.23,159.25 257.58,159.6 258.63,159.6 259.95,160.92 259.95,163.82 260.85,164.72 270.38,164.72 v2(270.75,164.35)
  BOTTOM w0.102: VRAM5.N2 270.4,164.7 v2(270.75,164.35)
  BOTTOM w0.161: UG6.N3 255.39,157.42 255.69,157.12 v2(255.69,157.08)
VMD_DQ39: length 26.4
  IN1 w0.102: v2(252.9,157.07) 253.06,157.07 253.45,157.46 254.39,157.46 254.63,157.69 254.63,158.21 255.2,158.78 255.84,158.78 256.65,159.59 256.65,160.53 257.06,160.94 257.26,160.94 257.59,161.27 257.59,161.38 257.91,161.7 258.73,161.7 259.18,162.15 259.18,164.65 260.88,166.35 267.55,166.35 268.41,165.49 270.9,165.49 271.33,165.06 v2(271.48,165.06)
  BOTTOM w0.102: VRAM5.P2 271.13,164.7 v2(271.48,165.06) ; v2(252.9,157.07) UG6.N6
VMD_DQ40: length 15.1
  IN2 w0.102: v2(262.52,163.57) 262.52,163.57 262.89,163.21 262.89,162.54 262.7,162.36 262.48,162.36 262.25,162.12 262.25,161.77 262.05,161.58 261.69,161.58 259.69,159.57 259.69,158.86 259.35,158.52 258,158.52 256.95,157.46 253.86,157.46 253.67,157.65 v2(253.67,157.85)
  BOTTOM w0.102: v2(253.67,157.85) 253.67,158.4 UG6.L6
  BOTTOM w0.161: v2(262.52,163.57) 262.52,163.57 262.15,163.95 VRAM5.B3
VMD_DQ41: length 21.6
  IN2 w0.102: v2(264.75,164.33) 265.13,163.95 265.72,163.95 265.88,163.79 265.88,163.72 265.89,163.71 265.89,162.95 265.88,162.95 265.88,162.47 265.71,162.29 265.71,161.63 264.81,160.73 261.89,160.73 260.22,159.05 260.22,158.47 258.19,156.44 252.12,156.44 v2(251.49,157.06)
  BOTTOM w0.102: VRAM5.F2 265.12,164.7 264.75,164.33 v2(264.75,164.33)
  BOTTOM w0.161: UG6.N8 v2(251.49,157.06)
VMD_DQ42: length 14
  IN2 w0.102: v2(261.75,162.79) 261.75,162.77 261.37,162.4 260.75,162.4 260.3,161.95 260.3,160.7 259.43,159.83 259.43,159.01 259.2,158.78 257.94,158.78 256.89,157.73 255,157.73 254.76,157.96 254.76,158.29 254.36,158.69 253.38,158.69 v2(252.9,159.16)
  BOTTOM w0.102: VRAM5.B4 262.13,163.17 v2(261.75,162.79) ; UG6.K6 253.25,159.51 v2(252.9,159.16)
VMD_DQ43: length 20.9
  IN2 w0.102: v2(264.01,163.57) 264.01,163.4 264.91,162.5 264.91,161.78 264.31,161.18 261.79,161.18 259.94,159.33 259.94,158.55 258.03,156.64 252.48,156.64 251.67,157.45 251.16,157.45 250.94,157.68 v2(250.94,158.18)
  BOTTOM w0.102: VRAM5.E3 264.01,163.58 v2(264.01,163.57) ; UG6.L9 250.94,158.61 v2(250.94,158.18)
VMD_DQ44: length 10.6
  IN2 w0.102: v2(261.75,164.34) 261.75,164.34 261.37,164.72 260.59,164.72 258.87,163 258.87,162.54 258.42,162.09 258.42,161.02 258.17,160.77 257.83,160.77 257.59,160.53 257.59,160.24 257.46,160.12 256.98,160.12 256.45,159.59 256.11,159.59 v2(255.69,159.17)
  BOTTOM w0.102: v2(255.69,159.17) 255.35,159.51 UG6.K3
  BOTTOM w0.161: VRAM5.B2 262.11,164.7 261.76,164.34 v2(261.75,164.34)
VMD_DQ45: length 11
  IN2 w0.102: v2(261,163.57) 261,163.56 260.27,163.56 259.46,162.75 259.46,160.83 258.43,159.81 257.2,159.81 256.5,159.1 256.28,159.1 255.97,158.79 254.68,158.79 v2(254.3,159.17)
  BOTTOM w0.102: UG6.K5 253.97,159.52 254.3,159.19 v2(254.3,159.17) ; v2(261,163.57) 261.01,163.57 261.38,163.93 VRAM5.A3
VMD_DQ46: length 13.9
  IN2 w0.102: v2(264,165.1) 263.56,165.54 263.56,166.17 263.36,166.37 260.6,166.37 258.01,163.78 257.42,163.78 256.81,163.17 256.81,161.91 256.8,161.89 256.8,161.04 256.33,160.58 v2(255.7,160.58)
  BOTTOM w0.102: UG6.J2 256.05,160.22 v2(255.7,160.58) ; v2(264,165.1) 264.38,164.72 VRAM5.E2
VMD_DQ47: length 20.8
  IN2 w0.102: v2(251.49,159.16) 252.21,159.88 254.21,159.88 255.01,160.68 255.25,160.68 256.11,161.54 256.11,162.22 255.97,162.36 255.97,162.92 256.8,163.76 256.8,164.67 257.31,165.17 258.06,165.17 259.59,166.71 264.56,166.71 265.14,166.13 265.14,165.47 265.5,165.11 v2(265.5,165.1)
  BOTTOM w0.102: v2(265.5,165.1) 265.5,165.08 265.88,164.71 VRAM5.G2 ; UG6.K8 v2(251.49,159.16)
VMD_DQ48: length 29.3
  IN1 w0.102: v2(252.32,149.85) 252.92,149.25 255.95,149.25 256.31,149.61 258.16,149.61 261.04,152.5 267.77,152.5 268.58,153.31 273.35,153.31 275.03,154.99 275.03,157.07 v2(274.58,157.52)
  BOTTOM w0.102: v2(274.58,157.52) 274.25,157.2 VRAM5.V12 ; UG6.AC7 252.32,150.19 v2(252.32,149.85)
VMD_DQ49: length 27.6
  IN1 w0.102: v2(273.76,158.31) 274.12,157.95 274.68,157.95 275.23,157.41 275.23,154.66 273.01,152.44 268.97,152.44 268.51,151.98 261.07,151.98 258.29,149.2 256.38,149.2 255.86,148.68 v2(255.7,148.68)
  BOTTOM w0.102: v2(255.7,148.68) 255.36,149.02 UG6.AE3
  BOTTOM w0.161: VRAM5.U11 273.39,157.95 273.75,158.31 v2(273.76,158.31)
VMD_DQ50: length 25.7
  IN1 w0.102: v2(273.02,157.57) 273.39,157.2 273.39,154.84 272.66,154.1 266.48,154.1 265.69,153.32 260.89,153.32 257.94,150.37 254,150.37 v2(253.64,150.01)
  BOTTOM w0.102: VRAM5.U12 273.38,157.21 v2(273.02,157.57)
  BOTTOM w0.161: v2(253.64,150.01) 253.25,150.4 UG6.AC6
VMD_DQ51: length 24.6
  IN1 w0.102: v2(273.78,156.82) 274.2,156.39 274.2,155.09 272.9,153.78 268.15,153.78 267.26,152.89 260.99,152.89 258.04,149.94 256.17,149.94 255.83,149.61 255.44,149.61 v2(255.06,149.98)
  BOTTOM w0.102: UG6.AC4 254.65,150.4 v2(255.06,149.98) ; v2(273.78,156.82) 273.4,156.45 VRAM5.U13
VMD_DQ52: length 19.5
  IN1 w0.102: v2(255.69,150.78) 256.11,151.2 258.29,151.2 261.01,153.92 265.64,153.92 266.09,154.37 270.6,154.37 271.25,155.02 271.25,155.79 v2(271.51,156.05)
  BOTTOM w0.102: UG6.AB3 v2(255.69,150.78) ; v2(271.51,156.05) 271.51,156.06 VRAM5.P13
VMD_DQ53: length 19
  IN1 w0.102: v2(270.01,156.05) 269.53,155.57 267.24,155.57 266.79,155.12 266.79,155.01 266.42,154.64 265.9,154.64 265.56,154.3 260.93,154.3 258.51,151.88 257.44,151.88 257.02,151.46 256.02,151.46 255.72,151.16 254.81,151.16 254.43,150.78 v2(254.3,150.78)
  BOTTOM w0.102: VRAM5.M13 270.01,156.06 v2(270.01,156.05) ; UG6.AB5 254.29,150.78 v2(254.3,150.78)
VMD_DQ54: length 21.3
  IN1 w0.102: v2(252.9,150.78) 253.5,151.38 255.53,151.38 255.89,151.75 256.74,151.75 257.45,152.45 258.63,152.45 260.88,154.71 265.41,154.71 266.14,155.44 266.61,155.44 267.6,156.43 270.36,156.43 v2(270.74,156.81)
  BOTTOM w0.102: v2(270.74,156.81) 270.38,156.45 VRAM5.N13 ; UG6.AB6 252.92,150.79 252.91,150.79 v2(252.9,150.78)
VMD_DQ55: length 25.5
  IN1 w0.102: v2(271.5,157.57) 271.1,157.96 262.3,157.96 262.14,157.81 262.14,157.41 261.94,157.2 261.56,157.2 261.31,156.95 261.31,156.6 261.16,156.45 260.73,156.45 260.47,156.19 260.47,155.49 258.76,153.78 256.83,153.78 256.08,153.03 256.08,152.71 255.86,152.48 252.76,152.48 252.03,151.76 252.03,151.31 v2(251.5,150.77)
  BOTTOM w0.102: VRAM5.P12 v2(271.5,157.57) ; UG6.AB8 251.85,151.12 v2(251.5,150.77)
VMD_DQ56: length 11.2
  IN2 w0.102: v2(260.9,156.85) 260.85,156.81 260.64,156.81 259.98,156.14 259.98,155.42 258.88,154.32 254.96,154.32 254.3,153.67 253.7,153.67 v2(252.89,152.86)
  BOTTOM w0.102: v2(260.9,156.85) 261.24,157.2 VRAM5.A12 ; UG6.W6 v2(252.89,152.86)
VMD_DQ57: length 19.8
  IN2 w0.102: v2(266.28,156.82) 265.87,156.41 265.87,155.27 262.69,152.09 260.97,152.09 260.06,151.18 254.02,151.18 253.02,152.18 252.54,152.18 252.22,152.5 v2(252.22,153.59)
  BOTTOM w0.102: VRAM5.G13 265.91,156.45 v2(266.28,156.82) ; v2(252.22,153.59) UG6.W8
VMD_DQ58: length 10.2
  IN2 w0.102: v2(254.31,152.87) 254.75,153.31 259.37,153.31 260.75,154.69 260.75,155.36 261.13,155.74 261.44,155.74 v2(261.75,156.05)
  BOTTOM w0.102: v2(254.31,152.87) 253.96,153.22 UG6.W5
  BOTTOM w0.254: VRAM5.B13 262.13,156.43 v2(261.75,156.05)
VMD_DQ59: length 15.5
  IN2 w0.102: v2(265.49,156.05) 265.37,156.05 264.65,155.33 264.65,154.9 262.24,152.49 260.56,152.49 259.45,151.38 254.4,151.38 v2(254.02,151.76)
  BOTTOM w0.102: VRAM5.F13 265.13,156.42 v2(265.49,156.05) ; v2(254.02,151.76) 253.26,152.52 UG6.Y6
VMD_DQ60: length 12.6
  IN2 w0.102: v2(255.7,152.86) 256.59,152.86 257.01,152.45 258.98,152.45 260.84,154.31 261.71,154.31 262.24,154.85 262.24,155.29 262.55,155.6 262.7,155.6 262.87,155.77 262.87,156.26 263.05,156.43 264.33,156.43 v2(264.73,156.82)
  BOTTOM w0.102: v2(264.73,156.82) 264.38,156.47 VRAM5.E13 ; UG6.W3 255.35,153.21 v2(255.7,152.86)
VMD_DQ61: length 13.9
  IN2 w0.102: v2(261.02,158.32) 260.45,157.74 260.45,157.39 258.65,155.59 256.98,155.59 256.77,155.38 253.98,155.38 253.19,154.59 251.12,154.59 v2(250.8,154.27)
  BOTTOM w0.102: UG6.U9 251.15,154.62 v2(250.8,154.27)
  BOTTOM w0.13: 261.75,158.32 v2(261.02,158.32)
  BOTTOM w0.161: VRAM5.B11 261.75,158.32
VMD_DQ62: length 10.9
  IN2 w0.102: v2(253.6,154.28) 253.86,154.54 258.58,154.54 259.61,155.57 259.61,156.13 260.73,157.25 261.41,157.25 261.75,157.58 v2(261.76,157.58)
  BOTTOM w0.102: VRAM5.B12 262.13,157.22 v2(261.76,157.58) ; v2(253.6,154.28) 253.26,154.62 UG6.U6
VMD_DQ63: length 17.2
  IN2 w0.102: v2(250.1,154.97) 250.5,155.36 252.97,155.36 253.25,155.63 256.58,155.63 256.85,155.9 258.08,155.9 260.52,158.34 260.52,158.59 260.7,158.77 262.82,158.77 264.01,157.58 v2(264.01,157.55)
  BOTTOM w0.102: v2(250.1,154.97) 250.45,155.31 UG6.T10 ; v2(264.01,157.55) 264.37,157.2 VRAM5.E12
VMD_WCK01: length 17.3
  IN4 w0.102: v2(263.75,144.9) 263.68,144.9 263.57,144.79 263.57,144.56 263.27,144.26 260.73,144.26 259.92,143.45 256.9,143.45 256.23,142.78 253.86,142.78 253.64,143 250.75,143 250.57,142.82 250.57,142.48 250.67,142.38 v2(250.8,142.38)
  BOTTOM w0.102: VRAM7.R4 263.63,143.54 263.96,143.87 263.96,144.69 v2(263.75,144.9) ; v2(250.8,142.38) 250.8,142.62 250.9,142.72 UG6.AP9
VMD_WCK01#: length 17.1
  IN4 w0.102: v2(250.1,142.37) 250.27,142.37 250.37,142.47 250.37,142.9 250.67,143.2 253.72,143.2 253.94,142.98 256.14,142.98 256.82,143.65 259.83,143.65 260.65,144.47 263.19,144.47 263.37,144.65 263.37,144.87 263.25,144.99 263.05,144.99 v2(262.95,144.89)
  BOTTOM w0.102: v2(250.1,142.37) 250.23,142.37 250.45,142.59 UG6.AP10 ; v2(262.95,144.89) 263.22,144.89 263.63,144.48 VRAM7.R5
VMD_WCK23: length 16.7
  IN4 w0.102: v2(250.1,146.58) 250.26,146.58 250.36,146.69 250.36,146.98 250.59,147.2 256.67,147.2 257.2,146.68 258.74,146.68 258.95,146.89 263.4,146.89 263.52,147.01 263.52,147.18 263.42,147.28 v2(263.3,147.28)
  BOTTOM w0.102: v2(250.1,146.58) 250.23,146.58 250.45,146.8 UG6.AH10
  BOTTOM w0.114: VRAM7.R11 263.63,148.59 263.29,148.25 263.29,147.29 v2(263.3,147.28)
VMD_WCK23#: length 16.7
  IN4 w0.102: v2(263.91,147.28) 263.82,147.28 263.72,147.18 263.72,146.92 263.49,146.69 259.03,146.69 258.83,146.48 257.11,146.48 256.59,147 250.68,147 250.57,146.89 250.57,146.66 250.67,146.56 v2(250.8,146.56)
  BOTTOM w0.102: UG6.AH9 251.15,146.91 v2(250.8,146.56) ; VRAM7.R10 263.63,148.18 263.73,148.28 263.91,148.28
  BOTTOM w0.114: 263.91,148.28 264.01,148.18 264.01,147.79 263.91,147.69 v2(263.91,147.28)
