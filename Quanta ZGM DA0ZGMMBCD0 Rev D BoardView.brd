# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
BGA1787-INTEL-TGL-H
  round 0.381 smd: A3(-24.406,-11.391) A4(-24.406,-10.737) A5(-24.406,-9.951) A36(-24.406,9.181) A37(-24.406,10.146) A39(-24.406,11.146) B2(-23.756,-12.037) B3(-23.756,-11.387) B39(-23.756,11.146) B40(-23.756,12.037) C1(-23.105,-12.687) C2(-23.105,-12.037) C40(-23.105,12.037) C41(-23.105,12.687) CN1(21.69,-12.687) CN41(21.768,12.687) CP1(22.448,-12.687) CP41(22.456,12.687) CR1(23.106,-12.687) CR2(23.106,-12.037) CR40(23.106,12.037) CR41(23.106,12.687) CT2(23.756,-12.037) CT3(23.756,-11.333) CT39(23.756,11.33) CT40(23.756,12.037) CU3(24.406,-11.333) CU4(24.406,-10.673) CU5(24.406,-9.906) CU36(24.406,9.795) CU38(24.406,10.562) CU39(24.406,11.33) D1(-22.293,-12.687) D41(-22.445,12.687) E1(-21.48,-12.687) E41(-21.632,12.687)
  round 0.305 smd: A6(-24.406,-9.164) A8(-24.406,-8.376) A9(-24.406,-7.589) A10(-24.406,-6.801) A11(-24.406,-6.014) A13(-24.406,-5.274) A14(-24.406,-4.384) A16(-24.406,-3.342) A17(-24.406,-2.453) A18(-24.406,-1.411) A20(-24.406,-0.521) A22(-24.406,0.52) A23(-24.406,1.41) A25(-24.406,2.452) A27(-24.406,3.342) A28(-24.406,4.383) A29(-24.406,5.273) A31(-24.406,6.314) A32(-24.406,7.204) A34(-24.406,8.246) AA12(-11.556,-5.531) AA34(-11.225,8.137) AA35(-11.225,8.787) AA36(-11.225,9.437) AA37(-11.225,10.087) AA38(-11.225,10.737) AA39(-11.225,11.387) AA40(-11.225,12.037) AA41(-11.225,12.687) AB1(-11.024,-12.687) AB2(-11.024,-12.037) AB3(-11.024,-11.387) AB4(-11.024,-10.737) AB5(-11.024,-10.087) AB6(-11.024,-9.336) AB7(-11.024,-8.686) AB8(-11.024,-8.036) AB9(-11.024,-7.386) AB10(-11.024,-6.736) AB11(-11.024,-6.086) AB12(-10.907,-5.436) AB33(-10.841,7.612) AC1(-10.257,-12.687) AC2(-10.257,-12.037) AC3(-10.257,-11.387) AC4(-10.257,-10.737) AC5(-10.257,-10.087) AC6(-10.257,-9.336) AC7(-10.257,-8.686) AC8(-10.257,-8.036) AC9(-10.257,-7.386) AC10(-10.257,-6.736) AC11(-10.257,-6.086) AC12(-10.257,-5.436) AC33(-10.073,7.612) AC34(-10.457,8.137) AC35(-10.457,8.787) AC36(-10.457,9.437) AC37(-10.457,10.087) AC38(-10.457,10.737) AC39(-10.457,11.387) AC40(-10.457,12.037) AC41(-10.457,12.687) AD1(-9.489,-12.687) AD2(-9.489,-12.037) AD3(-9.489,-11.387) AD4(-9.489,-10.737) AD5(-9.489,-10.087) AD6(-9.489,-9.336) AD7(-9.489,-8.686) AD8(-9.489,-8.036) AD9(-9.489,-7.386) AD10(-9.489,-6.736) AD11(-9.489,-6.086) AD12(-9.489,-5.436) AD34(-9.69,8.137) AD35(-9.69,8.787) AD36(-9.69,9.437) AD37(-9.69,10.087) AD38(-9.69,10.737) AD39(-9.69,11.387) AD40(-9.69,12.037) AD41(-9.69,12.687) AE33(-9.306,7.612) AE34(-8.922,8.137) AE35(-8.922,8.787) AE36(-8.922,9.437) AE37(-8.922,10.087) AE38(-8.922,10.737) AE39(-8.922,11.387) AE40(-8.922,12.037) AE41(-8.922,12.687) AF1(-8.588,-12.687) AF2(-8.588,-12.037) AF3(-8.588,-11.387) AF4(-8.588,-10.737) AF5(-8.588,-10.087) AF6(-8.588,-9.336) AF7(-8.588,-8.686) AF8(-8.588,-8.036) AF9(-8.588,-7.386) AF10(-8.588,-6.736) AF11(-8.588,-6.086) AF12(-8.588,-5.436) AF33(-8.539,7.612) AF34(-8.155,8.137) AF35(-8.155,8.787) AF36(-8.155,9.437) AF37(-8.155,10.087) AF38(-8.155,10.737) AF39(-8.155,11.387) AF40(-8.155,12.037) AF41(-8.155,12.687) AG1(-7.687,-12.687) AG2(-7.687,-12.037) AG3(-7.687,-11.387) AG4(-7.687,-10.737) AG5(-7.687,-10.087) AG6(-7.687,-9.336) AG7(-7.687,-8.686) AG8(-7.687,-8.036) AG9(-7.687,-7.386) AG10(-7.687,-6.736) AG11(-7.687,-6.086) AG12(-7.687,-5.436) AG33(-7.771,7.612) AG34(-7.388,8.137) AG35(-7.388,8.787) AG36(-7.388,9.437) AG37(-7.388,10.087) AG38(-7.388,10.737) AG39(-7.388,11.387) AG40(-7.388,12.037) AG41(-7.388,12.687) AH1(-6.92,-12.687) AH2(-6.92,-12.037) AH3(-6.92,-11.387) AH4(-6.92,-10.737) AH5(-6.92,-10.087) AH6(-6.92,-9.336) AH7(-6.92,-8.686) AH8(-6.92,-8.036) AH9(-6.92,-7.386) AH10(-6.92,-6.736) AH11(-6.92,-6.086) AH12(-6.92,-5.436) AH33(-7.004,7.612) AJ1(-6.152,-12.687) AJ2(-6.152,-12.037) AJ3(-6.152,-11.387) AJ4(-6.152,-10.737) AJ5(-6.152,-10.087) AJ6(-6.152,-9.336) AJ7(-6.152,-8.686) AJ8(-6.152,-8.036) AJ9(-6.152,-7.386) AJ10(-6.152,-6.736) AJ11(-6.152,-6.086) AJ12(-6.152,-5.436) AJ33(-6.236,7.612) AJ34(-6.62,8.137) AJ35(-6.62,8.787) AJ36(-6.62,9.437) AJ37(-6.62,10.087) AJ38(-6.62,10.737) AJ39(-6.62,11.387) AJ40(-6.62,12.037) AJ41(-6.62,12.687) AK34(-5.853,8.137) AK35(-5.853,8.787) AK36(-5.853,9.437) AK37(-5.853,10.087) AK38(-5.853,10.737) AK39(-5.853,11.387) AK40(-5.853,12.037) AK41(-5.853,12.687) AL1(-5.251,-12.687) AL2(-5.251,-12.037) AL3(-5.251,-11.387) AL4(-5.251,-10.737) AL5(-5.251,-10.087) AL6(-5.251,-9.336) AL7(-5.251,-8.686) AL8(-5.251,-8.036) AL9(-5.251,-7.386) AL10(-5.251,-6.736) AL11(-5.251,-6.086) AL12(-5.251,-5.436) AL33(-5.469,7.612) AL34(-5.085,8.137) AL35(-5.085,8.787) AL36(-5.085,9.437) AL37(-5.085,10.087) AL38(-5.085,10.737) AL39(-5.085,11.387) AL40(-5.085,12.037) AL41(-5.085,12.687) AM1(-4.35,-12.687) AM2(-4.35,-12.037) AM3(-4.35,-11.387) AM4(-4.35,-10.737) AM5(-4.35,-10.087) AM6(-4.35,-9.336) AM7(-4.35,-8.686) AM8(-4.35,-8.036) AM9(-4.35,-7.386) AM10(-4.35,-6.736) AM11(-4.35,-6.086) AM12(-4.35,-5.436) AM33(-4.702,7.612) AM34(-4.318,8.137) AM35(-4.318,8.787) AM36(-4.318,9.437) AM37(-4.318,10.087) AM38(-4.318,10.737) AM39(-4.318,11.387) AM40(-4.318,12.037) AM41(-4.318,12.687) AN1(-3.583,-12.687) AN2(-3.583,-12.037) AN3(-3.583,-11.387) AN4(-3.583,-10.737) AN5(-3.583,-10.087) AN6(-3.583,-9.336) AN7(-3.583,-8.686) AN8(-3.583,-8.036) AN9(-3.583,-7.386) AN10(-3.583,-6.736) AN11(-3.583,-6.086) AN12(-3.583,-5.436) AN33(-3.934,7.612) AN34(-3.55,8.137) AN35(-3.55,8.787) AN36(-3.55,9.437) AN37(-3.55,10.087) AN38(-3.55,10.737) AN39(-3.55,11.387) AN40(-3.55,12.037) AN41(-3.55,12.687) AP33(-3.167,7.612) AR1(-2.816,-12.687) AR2(-2.816,-12.037) AR3(-2.816,-11.387) AR4(-2.816,-10.737) AR5(-2.816,-10.087) AR6(-2.816,-9.336) AR7(-2.816,-8.686) AR8(-2.816,-8.036) AR9(-2.816,-7.386) AR10(-2.816,-6.736) AR11(-2.816,-6.086) AR12(-2.816,-5.436) AR33(-2.399,7.612) AR34(-2.783,8.137) AR35(-2.783,8.787) AR36(-2.783,9.437) AR37(-2.783,10.087) AR38(-2.783,10.737) AR39(-2.783,11.387) AR40(-2.783,12.037) AR41(-2.783,12.687) AT1(-2.048,-12.687) AT2(-2.048,-12.037) AT3(-2.048,-11.387) AT4(-2.048,-10.737) AT5(-2.048,-10.087) AT6(-2.048,-9.336) AT7(-2.048,-8.686) AT8(-2.048,-8.036) AT9(-2.048,-7.386) AT10(-2.048,-6.736) AT11(-2.048,-6.086) AT12(-2.048,-5.436) AT33(-1.632,7.612) AT34(-2.016,8.137) AT35(-2.016,8.787) AT36(-2.016,9.437) AT37(-2.016,10.087) AT38(-2.016,10.737) AT39(-2.016,11.387) AT40(-2.016,12.037) AT41(-2.016,12.687) AU1(-1.398,-12.687) AU2(-1.398,-12.037) AU3(-1.398,-11.387) AU4(-1.398,-10.737) AU5(-1.398,-10.087) AU6(-1.398,-9.336) AU7(-1.398,-8.686) AU8(-1.398,-8.036) AU9(-1.398,-7.386) AU10(-1.398,-6.736) AU11(-1.398,-6.086) AU12(-1.398,-5.436) AU34(-1.248,8.137) AU35(-1.248,8.787) AU36(-1.248,9.437) AU37(-1.248,10.087) AU38(-1.248,10.737) AU39(-1.248,11.387) AU40(-1.248,12.037) AU41(-1.248,12.687) AV1(-0.631,-12.687) AV2(-0.631,-12.037) AV3(-0.631,-11.387) AV4(-0.631,-10.737) AV5(-0.631,-10.087) AV6(-0.631,-9.336) AV7(-0.631,-8.686) AV8(-0.631,-8.036) AV9(-0.631,-7.386) AV10(-0.631,-6.736) AV11(-0.631,-6.086) AV12(-0.631,-5.436) AV33(-0.865,7.612) AV34(-0.481,8.137) AV35(-0.481,8.787) AV36(-0.481,9.437) AV37(-0.481,10.087) AV38(-0.481,10.737) AV39(-0.481,11.387) AV40(-0.481,12.037) AV41(-0.481,12.687) AW1(0.137,-12.687) AW2(0.137,-12.037) AW3(0.137,-11.387) AW4(0.137,-10.737) AW5(0.137,-10.087) AW6(0.137,-9.336) AW7(0.137,-8.686) AW8(0.137,-8.036) AW9(0.137,-7.386) AW10(0.137,-6.736) AW11(0.137,-6.086) AW12(0.137,-5.436) AW33(-0.097,7.612) AW34(0.287,8.137) AW35(0.287,8.787) AW36(0.287,9.437) AW37(0.287,10.087) AW38(0.287,10.737) AW39(0.287,11.387) AW40(0.287,12.037) AW41(0.287,12.687) AY1(0.904,-12.687) AY2(0.904,-12.037) AY3(0.904,-11.387) AY4(0.904,-10.737) AY5(0.904,-10.087) AY6(0.904,-9.336) AY7(0.904,-8.686) AY8(0.904,-8.036) AY9(0.904,-7.386) AY10(0.904,-6.736) AY11(0.904,-6.086) AY12(0.904,-5.436) AY33(0.67,7.612) B6(-23.756,-9.164) B8(-23.756,-8.376) B9(-23.756,-7.589) B10(-23.756,-6.801) B11(-23.756,-6.014) B13(-23.756,-5.274) B14(-23.756,-4.384) B16(-23.756,-3.342) B17(-23.756,-2.453) B18(-23.756,-1.411) B20(-23.756,-0.521) B22(-23.756,0.52) B23(-23.756,1.41) B25(-23.756,2.452) B27(-23.756,3.342) B28(-23.756,4.383) B29(-23.756,5.273) B31(-23.756,6.314) B32(-23.756,7.204) B34(-23.756,8.246) BA1(1.554,-12.687) BA2(1.554,-12.037) BA3(1.554,-11.387) BA4(1.554,-10.737) BA5(1.554,-10.087) BA6(1.554,-9.336) BA7(1.554,-8.686) BA8(1.554,-8.036) BA9(1.554,-7.386) BA10(1.554,-6.736) BA11(1.554,-6.086) BA12(1.554,-5.436) BA33(1.438,7.612) BA34(1.054,8.137) BA35(1.054,8.787) BA36(1.054,9.437) BA37(1.054,10.087) BA38(1.054,10.737) BA39(1.054,11.387) BA40(1.054,12.037) BA41(1.054,12.687) BB33(2.205,7.612) BB34(1.821,8.137) BB35(1.821,8.787) BB36(1.821,9.437) BB37(1.821,10.087) BB38(1.821,10.737) BB39(1.821,11.387) BB40(1.821,12.037) BB41(1.821,12.687) BC1(2.322,-12.687) BC2(2.322,-12.037) BC3(2.322,-11.387) BC4(2.322,-10.737) BC5(2.322,-10.087) BC6(2.322,-9.336) BC7(2.322,-8.686) BC8(2.322,-8.036) BC9(2.322,-7.386) BC10(2.322,-6.736) BC11(2.322,-6.086) BC12(2.322,-5.436) BC34(2.589,8.137) BC35(2.589,8.787) BC36(2.589,9.437) BC37(2.589,10.087) BC38(2.589,10.737) BC39(2.589,11.387) BC40(2.589,12.037) BC41(2.589,12.687) BD1(3.089,-12.687) BD2(3.089,-12.037) BD3(3.089,-11.387) BD4(3.089,-10.737) BD5(3.089,-10.087) BD6(3.089,-9.336) BD7(3.089,-8.686) BD8(3.089,-8.036) BD9(3.089,-7.386) BD10(3.089,-6.736) BD11(3.089,-6.086) BD12(3.089,-5.436) BD33(2.972,7.612) BD34(3.356,8.137) BD35(3.356,8.787) BD36(3.356,9.437) BD37(3.356,10.087) BD38(3.356,10.737) BD39(3.356,11.387) BD40(3.356,12.037) BD41(3.356,12.687) BE1(3.856,-12.687) BE2(3.856,-12.037) BE3(3.856,-11.387) BE4(3.856,-10.737) BE5(3.856,-10.087) BE6(3.856,-9.336) BE7(3.856,-8.686) BE8(3.856,-8.036) BE9(3.856,-7.386) BE10(3.856,-6.736) BE11(3.856,-6.086) BE12(3.856,-5.436) BE33(3.75,7.612) BE34(4.144,8.137) BE35(4.144,8.787) BE36(4.144,9.437) BE37(4.144,10.087) BE38(4.144,10.737) BE39(4.144,11.387) BE40(4.144,12.037) BE41(4.144,12.687) BF1(4.506,-12.687) BF2(4.506,-12.037) BF3(4.506,-11.387) BF4(4.506,-10.737) BF5(4.506,-10.087) BF6(4.506,-9.336) BF7(4.506,-8.686) BF8(4.506,-8.036) BF9(4.506,-7.386) BF10(4.506,-6.736) BF11(4.506,-6.086) BF12(4.506,-5.436) BF33(4.537,7.612) BG1(5.274,-12.687) BG2(5.274,-12.037) BG3(5.274,-11.387) BG4(5.274,-10.737) BG5(5.274,-10.087) BG6(5.274,-9.336) BG7(5.274,-8.686) BG8(5.274,-8.036) BG9(5.274,-7.386) BG10(5.274,-6.736) BG11(5.274,-6.086) BG12(5.274,-5.436) BG33(5.325,7.612) BG34(4.931,8.137) BG35(4.931,8.787) BG36(4.931,9.437) BG37(4.931,10.087) BG38(4.931,10.737) BG39(4.931,11.387) BG40(4.931,12.037) BG41(4.931,12.687) BH1(6.041,-12.687) BH2(6.041,-12.037) BH3(6.041,-11.387) BH4(6.041,-10.737) BH5(6.041,-10.087) BH6(6.041,-9.336) BH7(6.041,-8.686) BH8(6.041,-8.036) BH9(6.041,-7.386) BH10(6.041,-6.736) BH11(6.041,-6.086) BH12(6.041,-5.436) BH33(6.112,7.612) BH34(5.718,8.137) BH35(5.718,8.787) BH36(5.718,9.437) BH37(5.718,10.087) BH38(5.718,10.737) BH39(5.718,11.387) BH40(5.718,12.037) BH41(5.718,12.687) BJ34(6.506,8.137) BJ35(6.506,8.787) BJ36(6.506,9.437) BJ37(6.506,10.087) BJ38(6.506,10.737) BJ39(6.506,11.387) BJ40(6.506,12.037) BJ41(6.506,12.687) BK1(6.808,-12.687) BK2(6.808,-12.037) BK3(6.808,-11.387) BK4(6.808,-10.737) BK5(6.808,-10.087) BK6(6.808,-9.336) BK7(6.808,-8.686) BK8(6.808,-8.036) BK9(6.808,-7.386) BK10(6.808,-6.736) BK11(6.808,-6.086) BK12(6.808,-5.436) BK33(6.899,7.612) BK34(7.293,8.137) BK35(7.293,8.787) BK36(7.293,9.437) BK37(7.293,10.087) BK38(7.293,10.737) BK39(7.293,11.387) BK40(7.293,12.037) BK41(7.293,12.687) BL1(7.458,-12.687) BL2(7.458,-12.037) BL3(7.458,-11.387) BL4(7.458,-10.737) BL5(7.458,-10.087) BL6(7.458,-9.336) BL7(7.458,-8.686) BL8(7.458,-8.036) BL9(7.458,-7.386) BL10(7.458,-6.736) BL11(7.458,-6.086) BL12(7.458,-5.436) BL33(7.687,7.612) BL34(8.081,8.137) BL35(8.081,8.787) BL36(8.081,9.437) BL37(8.081,10.087) BL38(8.081,10.737) BL39(8.081,11.387) BL40(8.081,12.037) BL41(8.081,12.687) BM1(8.226,-12.687) BM2(8.226,-12.037) BM3(8.226,-11.387) BM4(8.226,-10.737) BM5(8.226,-10.087) BM6(8.226,-9.336) BM7(8.226,-8.686) BM8(8.226,-8.036) BM9(8.226,-7.386) BM10(8.226,-6.736) BM11(8.226,-6.086) BM12(8.226,-5.436) BM33(8.474,7.612) BN1(8.993,-12.687) BN2(8.993,-12.037) BN3(8.993,-11.387) BN4(8.993,-10.737) BN5(8.993,-10.087) BN6(8.993,-9.336) BN7(8.993,-8.686) BN8(8.993,-8.036) BN9(8.993,-7.386) BN10(8.993,-6.736) BN11(8.993,-6.086) BN12(8.993,-5.436) BN33(9.262,7.612) BN34(8.868,8.137) BN35(8.868,8.787) BN36(8.868,9.437) BN37(8.868,10.087) BN38(8.868,10.737) BN39(8.868,11.387) BN40(8.868,12.037) BN41(8.868,12.687) BP1(9.761,-12.687) BP2(9.761,-12.037) BP3(9.761,-11.387) BP4(9.761,-10.737) BP5(9.761,-10.087) BP6(9.761,-9.336) BP7(9.761,-8.686) BP8(9.761,-8.036) BP9(9.761,-7.386) BP10(9.761,-6.736) BP11(9.761,-6.086) BP12(9.761,-5.436) BP34(9.655,8.137) BP35(9.655,8.787) BP36(9.655,9.437) BP37(9.655,10.087) BP38(9.655,10.737) BP39(9.655,11.387) BP40(9.655,12.037) BP41(9.655,12.687) BR1(10.411,-12.687) BR2(10.411,-12.037) BR3(10.411,-11.387) BR4(10.411,-10.737) BR5(10.411,-10.087) BR6(10.411,-9.336) BR7(10.411,-8.686) BR8(10.411,-8.036) BR9(10.411,-7.386) BR10(10.411,-6.736) BR11(10.411,-6.086) BR12(10.411,-5.436) BR33(10.049,7.612) BR34(10.443,8.137) BR35(10.443,8.787) BR36(10.443,9.437) BR37(10.443,10.087) BR38(10.443,10.737) BR39(10.443,11.387) BR40(10.443,12.037) BR41(10.443,12.687) BT1(11.178,-12.687) BT2(11.178,-12.037) BT3(11.178,-11.387) BT4(11.178,-10.737) BT5(11.178,-10.087) BT6(11.178,-9.336) BT7(11.178,-8.686) BT8(11.178,-8.036) BT9(11.178,-7.386) BT10(11.178,-6.736) BT11(11.178,-6.086) BT12(11.178,-5.436) BT33(10.836,7.612) BT34(11.23,8.137) BT35(11.23,8.787) BT36(11.23,9.437) BT37(11.23,10.087) BT38(11.23,10.737) BT39(11.23,11.387) BT40(11.23,12.037) BT41(11.23,12.687) BU33(11.624,7.612) BU34(12.018,8.137) BU35(12.018,8.787) BU36(12.018,9.437) BU37(12.018,10.087) BU38(12.018,10.737) BU39(12.018,11.387) BU40(12.018,12.037) BU41(12.018,12.687) BV1(11.946,-12.687) BV2(11.946,-12.037) BV3(11.946,-11.387) BV4(11.946,-10.737) BV5(11.946,-10.087) BV6(11.946,-9.336) BV7(11.946,-8.686) BV8(11.946,-8.036) BV9(11.946,-7.386) BV10(11.946,-6.736) BV11(11.946,-6.086) BV12(11.946,-5.436) BV33(12.411,7.612) BW1(12.713,-12.687) BW2(12.713,-12.037) BW3(12.713,-11.387) BW4(12.713,-10.737) BW5(12.713,-10.087) BW6(12.713,-9.336) BW7(12.713,-8.686) BW8(12.713,-8.036) BW9(12.713,-7.386) BW10(12.713,-6.736) BW11(12.713,-6.086) BW12(12.713,-5.436) BW33(13.199,7.612) BW34(12.805,8.137) BW35(12.805,8.787) BW36(12.805,9.437) BW37(12.805,10.087) BW38(12.805,10.737) BW39(12.805,11.387) BW40(12.805,12.037) BW41(12.805,12.687) BY1(13.48,-12.687) BY2(13.48,-12.037) BY3(13.48,-11.387) BY4(13.48,-10.737) BY5(13.48,-10.087) BY6(13.48,-9.336) BY7(13.48,-8.686) BY8(13.48,-8.036) BY9(13.48,-7.386) BY10(13.48,-6.736) BY12(13.276,-5.761) BY34(13.592,8.137) BY35(13.592,8.787) BY36(13.592,9.437) BY37(13.592,10.087) BY38(13.592,10.737) BY39(13.592,11.387) BY40(13.592,12.037) BY41(13.592,12.687) C4(-23.105,-10.737) C5(-23.105,-9.951) C6(-23.105,-9.164) C8(-23.105,-8.376) C9(-23.105,-7.589) C10(-23.105,-6.801) C11(-23.105,-6.014) C13(-23.105,-5.274) C14(-23.105,-4.384) C16(-23.105,-3.342) C17(-23.105,-2.453) C18(-23.105,-1.411) C20(-23.105,-0.521) C22(-23.105,0.52) C23(-23.105,1.41) C25(-23.105,2.452) C27(-23.105,3.342) C28(-23.105,4.383) C29(-23.105,5.273) C31(-23.105,6.314) C32(-23.105,7.204) C34(-23.105,8.246) C36(-23.105,9.181) C37(-23.105,10.146) CA1(14.248,-12.687) CA2(14.248,-12.037) CA3(14.248,-11.387) CA4(14.248,-10.737) CA5(14.248,-10.087) CA6(14.248,-9.336) CA7(14.248,-8.686) CA8(14.248,-8.036) CA9(14.248,-7.386) CA10(14.248,-6.736) CA12(13.969,-5.71) CA13(13.969,-4.943) CA14(13.969,-4.175) CA16(13.969,-3.274) CA17(13.969,-2.373) CA18(13.969,-1.606) CA20(13.969,-0.705) CA21(13.969,0.196) CA22(13.969,1.108) CA23(13.969,2.021) CA24(13.969,2.788) CA25(13.969,3.555) CA27(13.969,4.323) CA28(13.969,5.09) CA30(13.969,5.858) CA31(13.969,6.625) CA33(13.969,7.393) CB12(14.619,-5.71) CB13(14.619,-4.943) CB14(14.619,-4.175) CB16(14.619,-3.274) CB17(14.619,-2.373) CB18(14.619,-1.606) CB20(14.619,-0.705) CB21(14.619,0.196) CB22(14.619,1.108) CB23(14.619,2.021) CB24(14.619,2.788) CB25(14.619,3.555) CB27(14.619,4.323) CB28(14.619,5.09) CB30(14.619,5.858) CB31(14.619,6.625) CB33(14.619,7.393) CB34(14.38,8.137) CB35(14.38,8.787) CB36(14.38,9.437) CB37(14.38,10.087) CB38(14.38,10.737) CB39(14.38,11.387) CB40(14.38,12.037) CB41(14.38,12.687) CC1(15.149,-12.687) CC2(15.149,-12.037) CC3(15.149,-11.387) CC4(15.149,-10.737) CC5(15.149,-10.087) CC6(15.149,-9.336) CC7(15.149,-8.686) CC8(15.149,-8.036) CC9(15.149,-7.386) CC10(15.149,-6.736) CC12(15.269,-5.71) CC13(15.269,-4.943) CC14(15.269,-4.175) CC16(15.269,-3.274) CC17(15.269,-2.373) CC18(15.269,-1.606) CC20(15.269,-0.705) CC21(15.269,0.196) CC22(15.269,1.108) CC23(15.269,2.021) CC24(15.269,2.788) CC25(15.269,3.555) CC27(15.269,4.323) CC28(15.269,5.09) CC30(15.269,5.858) CC31(15.269,6.625) CC33(15.269,7.393) CC34(15.167,8.137) CC35(15.167,8.787) CC36(15.167,9.437) CC37(15.167,10.087) CC38(15.167,10.737) CC39(15.167,11.387) CC40(15.167,12.037) CC41(15.167,12.687) CD1(16.05,-12.687) CD2(16.05,-12.037) CD3(16.05,-11.387) CD4(16.05,-10.737) CD5(16.05,-10.087) CD6(16.05,-9.336) CD7(16.05,-8.686) CD8(16.05,-8.036) CD9(16.05,-7.386) CD10(16.05,-6.736) CD12(15.919,-5.71) CD13(15.919,-4.943) CD14(15.919,-4.175) CD16(15.919,-3.274) CD17(15.919,-2.373) CD18(15.919,-1.606) CD20(15.919,-0.705) CD21(15.919,0.196) CD22(15.919,1.108) CD23(15.919,2.021) CD24(15.919,2.788) CD25(15.919,3.555) CD27(15.919,4.323) CD28(15.919,5.09) CD30(15.919,5.858) CD31(15.919,6.625) CD33(15.919,7.393) CD34(15.955,8.137) CD35(15.955,8.787) CD36(15.955,9.437) CD37(15.955,10.087) CD38(15.955,10.737) CD39(15.955,11.387) CD40(15.955,12.037) CD41(15.955,12.687) CE1(16.817,-12.687) CE2(16.817,-12.037) CE3(16.817,-11.387) CE4(16.817,-10.737) CE5(16.817,-10.087) CE6(16.817,-9.336) CE7(16.817,-8.686) CE8(16.817,-8.036) CE9(16.817,-7.386) CE10(16.817,-6.736) CE12(16.569,-5.71) CE13(16.569,-4.943) CE14(16.569,-4.175) CE16(16.569,-3.274) CE17(16.569,-2.373) CE18(16.569,-1.606) CE20(16.569,-0.705) CE21(16.569,0.196) CE22(16.569,1.108) CE23(16.569,2.021) CE24(16.569,2.788) CE25(16.569,3.555) CE27(16.569,4.323) CE28(16.569,5.09) CE30(16.569,5.858) CE31(16.569,6.625) CE33(16.569,7.393) CE34(16.722,8.137) CE35(16.722,8.787) CE36(16.722,9.437) CE37(16.722,10.087) CE38(16.722,10.737) CE39(16.722,11.387) CE40(16.722,12.037) CE41(16.722,12.687) CF1(17.584,-12.687) CF2(17.584,-12.037) CF3(17.584,-11.387) CF4(17.584,-10.737) CF5(17.584,-10.087) CF6(17.584,-9.336) CF7(17.584,-8.686) CF8(17.584,-8.036) CF9(17.584,-7.386) CF10(17.584,-6.736) CF12(17.219,-5.71) CF13(17.219,-4.943) CF14(17.219,-4.175) CF16(17.219,-3.274) CF17(17.219,-2.373) CF18(17.219,-1.606) CF20(17.219,-0.705) CF21(17.219,0.196) CF22(17.219,1.108) CF23(17.219,2.021) CF24(17.219,2.788) CF25(17.219,3.555) CF27(17.219,4.323) CF28(17.219,5.09) CF30(17.219,5.858) CF31(17.219,6.625) CF33(17.219,7.393) CF34(17.285,8.462) CF35(17.285,9.112) CF36(17.285,9.762) CF38(17.372,10.737) CF39(17.372,11.387) CF40(17.372,12.037) CF41(17.372,12.687) CG12(17.869,-5.71) CG13(17.869,-4.943) CG14(17.869,-4.175) CG16(17.869,-3.274) CG17(17.869,-2.373) CG18(17.869,-1.606) CG20(17.869,-0.705) CG21(17.869,0.196) CG22(17.869,1.108) CG23(17.869,2.021) CG24(17.869,2.788) CG25(17.869,3.555) CG27(17.869,4.323) CG28(17.869,5.09) CG30(17.869,5.858) CG31(17.869,6.625) CG33(17.869,7.393) CG34(17.848,8.137) CG35(17.848,8.787) CG36(17.848,9.437) CG37(17.848,10.087) CG38(18.035,10.737) CG39(18.035,11.387) CG40(18.035,12.037) CG41(18.035,12.687) CH1(18.486,-12.687) CH2(18.486,-12.037) CH3(18.486,-11.387) CH4(18.486,-10.737) CH5(18.486,-10.087) CH6(18.486,-9.336) CH7(18.486,-8.686) CH8(18.486,-8.036) CH9(18.486,-7.386) CH10(18.486,-6.736) CH12(18.519,-5.71) CH13(18.519,-4.943) CH14(18.519,-4.175) CH16(18.519,-3.274) CH17(18.519,-2.373) CH18(18.519,-1.606) CH20(18.519,-0.705) CH21(18.519,0.196) CH22(18.519,1.108) CH23(18.519,2.021) CH24(18.519,2.788) CH25(18.519,3.555) CH27(18.519,4.323) CH28(18.519,5.09) CH30(18.519,5.858) CH31(18.519,6.625) CH33(18.519,7.393) CH34(18.519,8.26) CH35(18.519,9.027) CH36(18.519,9.795) CH38(18.698,10.737) CH39(18.698,11.387) CH40(18.698,12.037) CH41(18.698,12.687) CJ1(19.387,-12.687) CJ2(19.387,-12.037) CJ3(19.387,-11.387) CJ4(19.387,-10.737) CJ5(19.387,-10.087) CJ6(19.387,-9.336) CJ7(19.387,-8.686) CJ8(19.387,-8.036) CJ9(19.387,-7.386) CJ10(19.387,-6.736) CJ12(19.169,-5.71) CJ13(19.169,-4.943) CJ14(19.169,-4.175) CJ16(19.169,-3.274) CJ17(19.169,-2.373) CJ18(19.169,-1.606) CJ20(19.169,-0.705) CJ21(19.169,0.196) CJ22(19.169,1.108) CJ23(19.169,2.021) CJ24(19.169,2.788) CJ25(19.169,3.555) CJ27(19.169,4.323) CJ28(19.169,5.09) CJ30(19.169,5.858) CJ31(19.169,6.625) CJ33(19.169,7.393) CJ34(19.169,8.26) CJ35(19.169,9.027) CJ36(19.169,9.795) CJ38(19.466,10.737) CJ39(19.466,11.387) CJ40(19.466,12.037) CJ41(19.466,12.687) CK1(20.154,-12.687) CK2(20.154,-12.037) CK3(20.154,-11.387) CK4(20.154,-10.737) CK5(20.154,-10.087) CK6(20.154,-9.336) CK7(20.154,-8.686) CK8(20.154,-8.036) CK9(20.154,-7.386) CK10(20.154,-6.736) CK12(19.819,-5.71) CK13(19.819,-4.943) CK14(19.819,-4.175) CK16(19.819,-3.274) CK17(19.819,-2.373) CK18(19.819,-1.606) CK20(19.819,-0.705) CK21(19.819,0.196) CK22(19.819,1.108) CK23(19.819,2.021) CK24(19.819,2.788) CK25(19.819,3.555) CK27(19.819,4.323) CK28(19.819,5.09) CK30(19.819,5.858) CK31(19.819,6.625) CK33(19.819,7.393) CK34(19.819,8.26) CK35(19.819,9.027) CK36(19.819,9.795) CL12(20.469,-5.71) CL13(20.469,-4.943) CL14(20.469,-4.175) CL16(20.469,-3.274) CL17(20.469,-2.373) CL18(20.469,-1.606) CL20(20.469,-0.705) CL21(20.469,0.196) CL22(20.469,1.108) CL23(20.469,2.021) CL24(20.469,2.788) CL25(20.469,3.555) CL27(20.469,4.323) CL28(20.469,5.09) CL30(20.469,5.858) CL31(20.469,6.625) CL33(20.469,7.393) CL34(20.469,8.26) CL35(20.469,9.027) CL36(20.469,9.795) CL38(20.233,10.737) CL39(20.233,11.387) CL40(20.233,12.037) CL41(20.233,12.687) CM1(20.921,-12.687) CM2(20.921,-12.037) CM3(20.921,-11.387) CM4(20.921,-10.737) CM5(20.921,-10.087) CM6(20.921,-9.336) CM7(20.921,-8.686) CM8(20.921,-8.036) CM9(20.921,-7.386) CM10(20.921,-6.736) CM12(21.119,-5.71) CM13(21.119,-4.943) CM14(21.119,-4.175) CM16(21.119,-3.274) CM17(21.119,-2.373) CM18(21.119,-1.606) CM20(21.119,-0.705) CM21(21.119,0.196) CM22(21.119,1.108) CM23(21.119,2.021) CM24(21.119,2.788) CM25(21.119,3.555) CM27(21.119,4.323) CM28(21.119,5.09) CM30(21.119,5.858) CM31(21.119,6.625) CM33(21.119,7.393) CM34(21.119,8.26) CM35(21.119,9.027) CM36(21.119,9.795) CM38(21,10.737) CM39(21,11.387) CM40(21,12.037) CM41(21,12.687) CN3(21.69,-11.387) CN4(21.69,-10.737) CN5(21.69,-10.087) CN6(21.689,-9.336) CN7(21.689,-8.686) CN8(21.689,-8.036) CN9(21.689,-7.386) CN10(21.689,-6.736) CN12(21.769,-5.71) CN13(21.769,-4.943) CN14(21.769,-4.175) CN16(21.769,-3.274) CN17(21.769,-2.373) CN18(21.769,-1.606) CN20(21.769,-0.705) CN21(21.769,0.196) CN22(21.769,1.108) CN23(21.769,2.021) CN24(21.769,2.788) CN25(21.769,3.555) CN27(21.769,4.323) CN28(21.769,5.09) CN30(21.769,5.858) CN31(21.769,6.625) CN33(21.769,7.393) CN34(21.769,8.26) CN35(21.769,9.027) CN36(21.769,9.795) CN38(21.768,10.737) CN39(21.768,11.387) CP3(22.448,-11.333) CP4(22.448,-10.673) CP5(22.456,-9.906) CP7(22.456,-8.8) CP8(22.456,-8.012) CP9(22.456,-7.225) CP11(22.456,-6.457) CP12(22.456,-5.69) CP13(22.456,-4.923) CP14(22.456,-4.155) CP16(22.456,-3.388) CP17(22.456,-2.495) CP18(22.456,-1.606) CP20(22.456,-0.705) CP21(22.456,0.196) CP22(22.456,0.934) CP23(22.456,1.943) CP24(22.456,2.593) CP25(22.456,3.243) CP27(22.456,4.008) CP28(22.456,4.775) CP30(22.456,5.543) CP31(22.456,6.31) CP32(22.456,6.96) CP33(22.456,7.727) CP34(22.456,8.377) CP35(22.456,9.145) CP36(22.456,9.795) CP38(22.456,10.562) CP39(22.456,11.33) CR4(23.106,-10.673) CR5(23.106,-9.906) CR7(23.106,-8.8) CR8(23.106,-8.012) CR9(23.106,-7.225) CR11(23.106,-6.457) CR12(23.106,-5.69) CR13(23.106,-4.923) CR14(23.106,-4.155) CR16(23.106,-3.388) CR17(23.106,-2.495) CR18(23.106,-1.606) CR20(23.106,-0.705) CR21(23.106,0.196) CR22(23.106,0.934) CR23(23.106,1.943) CR24(23.106,2.593) CR25(23.106,3.243) CR27(23.106,4.008) CR28(23.106,4.775) CR30(23.106,5.543) CR31(23.106,6.31) CR32(23.106,6.96) CR33(23.106,7.727) CR34(23.106,8.377) CR35(23.106,9.145) CR36(23.106,9.795) CR38(23.106,10.562) CT7(23.756,-8.8) CT8(23.756,-8.012) CT9(23.756,-7.225) CT11(23.756,-6.457) CT12(23.756,-5.69) CT13(23.756,-4.923) CT14(23.756,-4.155) CT16(23.756,-3.388) CT17(23.756,-2.495) CT18(23.756,-1.606) CT20(23.756,-0.705) CT21(23.756,0.196) CT22(23.756,0.934) CT23(23.756,1.943) CT24(23.756,2.593) CT25(23.756,3.243) CT27(23.756,4.008) CT28(23.756,4.775) CT30(23.756,5.543) CT31(23.756,6.31) CT32(23.756,6.96) CT33(23.756,7.727) CT34(23.756,8.377) CT35(23.756,9.145) CU7(24.406,-8.8) CU8(24.406,-8.012) CU9(24.406,-7.225) CU11(24.406,-6.457) CU12(24.406,-5.69) CU13(24.406,-4.923) CU14(24.406,-4.155) CU16(24.406,-3.388) CU17(24.406,-2.495) CU18(24.406,-1.606) CU20(24.406,-0.705) CU21(24.406,0.196) CU22(24.406,0.934) CU23(24.406,1.943) CU24(24.406,2.593) CU25(24.406,3.243) CU27(24.406,4.008) CU28(24.406,4.775) CU30(24.406,5.543) CU31(24.406,6.31) CU32(24.406,6.96) CU33(24.406,7.727) CU34(24.406,8.377) CU35(24.406,9.145) D3(-22.293,-11.387) D4(-22.293,-10.737) D5(-22.293,-10.087) D6(-22.455,-9.164) D8(-22.455,-8.376) D9(-22.455,-7.589) D10(-22.455,-6.801) D11(-22.455,-6.014) D13(-22.455,-5.274) D14(-22.455,-4.384) D16(-22.455,-3.342) D17(-22.455,-2.453) D18(-22.455,-1.411) D20(-22.455,-0.521) D22(-22.455,0.52) D23(-22.455,1.41) D25(-22.455,2.452) D27(-22.455,3.342) D28(-22.455,4.383) D29(-22.455,5.273) D31(-22.455,6.314) D32(-22.455,7.204) D34(-22.455,8.246) D36(-22.455,9.181) D37(-22.455,10.146) D39(-22.455,11.146) E3(-21.48,-11.387) E4(-21.48,-10.737) E5(-21.48,-10.087) E6(-21.805,-9.164) E8(-21.805,-8.376) E9(-21.805,-7.589) E10(-21.805,-6.801) E11(-21.805,-6.014) E13(-21.805,-5.274) E14(-21.805,-4.384) E16(-21.805,-3.342) E17(-21.805,-2.453) E18(-21.805,-1.411) E20(-21.805,-0.521) E22(-21.805,0.52) E23(-21.805,1.41) E25(-21.805,2.452) E27(-21.805,3.342) E28(-21.805,4.383) E29(-21.805,5.273) E31(-21.805,6.314) E32(-21.805,7.204) E34(-21.805,8.246) E36(-21.805,9.181) E37(-21.805,10.146) E39(-21.805,11.146) F6(-21.155,-9.164) F8(-21.155,-8.376) F9(-21.155,-7.589) F10(-21.155,-6.801) F11(-21.155,-6.014) F13(-21.155,-5.274) F14(-21.155,-4.384) F16(-21.155,-3.342) F17(-21.155,-2.453) F18(-21.155,-1.411) F20(-21.155,-0.521) F22(-21.155,0.52) F23(-21.155,1.41) F25(-21.155,2.452) F27(-21.155,3.342) F28(-21.155,4.383) F29(-21.155,5.273) F31(-21.155,6.314) F32(-21.155,7.204) F34(-21.155,8.246) F36(-21.155,9.181) F37(-21.155,10.146) F39(-21.155,11.146) G1(-20.267,-12.687) G2(-20.267,-12.037) G3(-20.267,-11.387) G4(-20.267,-10.737) G5(-20.267,-10.087) G6(-20.267,-9.336) G7(-20.267,-8.686) G8(-20.267,-8.036) G9(-20.267,-7.386) G10(-20.267,-6.736) G11(-20.267,-6.086) G13(-20.436,-4.968) G15(-20.436,-3.895) G17(-20.436,-2.676) G18(-20.436,-1.609) G20(-20.436,-0.39) G22(-20.436,0.677) G24(-20.436,1.896) G26(-20.436,2.963) G28(-20.436,4.182) G29(-20.436,5.249) G31(-20.436,6.468) G33(-20.433,7.487) G34(-20.433,8.137) G35(-20.433,8.787) G36(-20.433,9.437) G37(-20.433,10.087) G38(-20.433,10.737) G39(-20.433,11.387) G40(-20.433,12.037) G41(-20.433,12.687) H1(-19.5,-12.687) H2(-19.5,-12.037) H3(-19.5,-11.387) H4(-19.5,-10.737) H5(-19.5,-10.087) H6(-19.5,-9.336) H7(-19.5,-8.686) H8(-19.5,-8.036) H9(-19.5,-7.386) H10(-19.5,-6.736) H11(-19.5,-6.086) H13(-19.785,-4.968) H15(-19.785,-3.895) H17(-19.785,-2.676) H18(-19.785,-1.609) H20(-19.785,-0.39) H22(-19.785,0.677) H24(-19.785,1.896) H26(-19.785,2.963) H28(-19.785,4.182) H29(-19.785,5.249) H31(-19.785,6.468) H33(-19.666,7.487) H34(-19.666,8.137) H35(-19.666,8.787) H36(-19.666,9.437) H37(-19.666,10.087) H38(-19.666,10.737) H39(-19.666,11.387) H40(-19.666,12.037) H41(-19.666,12.687) J13(-19.135,-4.968) J15(-19.135,-3.895) J17(-19.135,-2.676) J18(-19.135,-1.609) J20(-19.135,-0.39) J22(-19.135,0.677) J24(-19.135,1.896) J26(-19.135,2.963) J28(-19.135,4.182) J29(-19.135,5.249) J31(-19.135,6.468) J33(-18.899,7.487) J34(-18.899,8.137) J35(-18.899,8.787) J36(-18.899,9.437) J37(-18.899,10.087) J38(-18.899,10.737) J39(-18.899,11.387) J40(-18.899,12.037) J41(-18.899,12.687) K1(-18.598,-12.687) K2(-18.598,-12.037) K3(-18.598,-11.387) K4(-18.598,-10.737) K5(-18.598,-10.087) K6(-18.598,-9.336) K7(-18.598,-8.686) K8(-18.598,-8.036) K9(-18.598,-7.386) K10(-18.598,-6.736) K11(-18.598,-6.086) K13(-18.485,-4.968) K15(-18.485,-3.895) K17(-18.485,-2.676) K18(-18.485,-1.609) K20(-18.485,-0.39) K22(-18.485,0.677) K24(-18.485,1.896) K26(-18.485,2.963) K28(-18.485,4.182) K29(-18.485,5.249) K31(-18.485,6.468) L1(-17.697,-12.687) L2(-17.697,-12.037) L3(-17.697,-11.387) L4(-17.697,-10.737) L5(-17.697,-10.087) L6(-17.697,-9.336) L7(-17.697,-8.686) L8(-17.697,-8.036) L9(-17.697,-7.386) L10(-17.697,-6.736) L11(-17.697,-6.086) L13(-17.835,-4.968) L15(-17.835,-3.895) L17(-17.835,-2.676) L18(-17.835,-1.609) L20(-17.835,-0.39) L22(-17.835,0.677) L24(-17.835,1.896) L26(-17.835,2.963) L28(-17.835,4.182) L29(-17.835,5.249) L31(-17.835,6.468) L33(-18.131,7.487) L34(-18.131,8.137) L35(-18.131,8.787) L36(-18.131,9.437) L37(-18.131,10.087) L38(-18.131,10.737) L39(-18.131,11.387) L40(-18.131,12.037) L41(-18.131,12.687) M13(-17.184,-4.968) M15(-17.184,-3.895) M17(-17.184,-2.676) M18(-17.184,-1.609) M20(-17.184,-0.39) M22(-17.184,0.677) M24(-17.184,1.896) M26(-17.184,2.963) M28(-17.184,4.182) M29(-17.184,5.249) M31(-17.184,6.468) M33(-17.364,7.487) M34(-17.364,8.137) M35(-17.364,8.787) M36(-17.364,9.437) M37(-17.364,10.087) M38(-17.364,10.737) M39(-17.364,11.387) M40(-17.364,12.037) M41(-17.364,12.687) N1(-16.93,-12.687) N2(-16.93,-12.037) N3(-16.93,-11.387) N4(-16.93,-10.737) N5(-16.93,-10.087) N6(-16.93,-9.336) N7(-16.93,-8.686) N8(-16.93,-8.036) N9(-16.93,-7.386) N10(-16.93,-6.736) N11(-16.93,-6.086) N13(-16.534,-4.968) N15(-16.534,-3.895) N17(-16.534,-2.676) N18(-16.534,-1.609) N20(-16.534,-0.39) N22(-16.534,0.677) N24(-16.534,1.896) N26(-16.534,2.963) N28(-16.534,4.182) N29(-16.534,5.249) N31(-16.534,6.468) N33(-16.596,7.487) N34(-16.596,8.137) N35(-16.596,8.787) N36(-16.596,9.437) N37(-16.596,10.087) N38(-16.596,10.737) N39(-16.596,11.387) N40(-16.596,12.037) N41(-16.596,12.687) P1(-16.163,-12.687) P2(-16.163,-12.037) P3(-16.163,-11.387) P4(-16.163,-10.737) P5(-16.163,-10.087) P6(-16.163,-9.336) P7(-16.163,-8.686) P8(-16.163,-8.036) P9(-16.163,-7.386) P10(-16.163,-6.736) P11(-16.163,-6.086) P13(-15.884,-4.968) P15(-15.884,-3.895) P17(-15.884,-2.676) P18(-15.884,-1.609) P20(-15.884,-0.39) P22(-15.884,0.677) P24(-15.884,1.896) P26(-15.884,2.963) P28(-15.884,4.182) P29(-15.884,5.249) P31(-15.884,6.468) P33(-15.829,7.487) P34(-15.829,8.137) P35(-15.829,8.787) P36(-15.829,9.437) P37(-15.829,10.087) P38(-15.829,10.737) P39(-15.829,11.387) P40(-15.829,12.037) P41(-15.829,12.687) R1(-15.262,-12.687) R2(-15.262,-12.037) R3(-15.262,-11.387) R4(-15.262,-10.737) R5(-15.262,-10.087) R6(-15.262,-9.336) R7(-15.262,-8.686) R8(-15.262,-8.036) R9(-15.262,-7.386) R10(-15.262,-6.736) R11(-15.262,-6.086) R13(-15.234,-4.968) R15(-15.234,-3.895) R17(-15.234,-2.676) R18(-15.234,-1.609) R20(-15.234,-0.39) R22(-15.234,0.677) R24(-15.234,1.896) R26(-15.234,2.963) R28(-15.234,4.182) R29(-15.234,5.249) R31(-15.234,6.468) R33(-15.061,7.487) R34(-15.061,8.137) R35(-15.061,8.787) R36(-15.061,9.437) R37(-15.061,10.087) R38(-15.061,10.737) R39(-15.061,11.387) R40(-15.061,12.037) R41(-15.061,12.687) T13(-14.583,-4.968) T15(-14.583,-3.895) T17(-14.583,-2.676) T18(-14.583,-1.609) T20(-14.583,-0.39) T22(-14.583,0.677) T24(-14.583,1.896) T26(-14.583,2.963) T28(-14.583,4.182) T29(-14.583,5.249) T31(-14.583,6.468) U1(-14.361,-12.687) U2(-14.361,-12.037) U3(-14.361,-11.387) U4(-14.361,-10.737) U5(-14.361,-10.087) U6(-14.361,-9.336) U7(-14.361,-8.686) U8(-14.361,-8.036) U9(-14.361,-7.386) U10(-14.361,-6.736) U11(-14.361,-6.086) U13(-13.933,-4.968) U15(-13.933,-3.895) U17(-13.933,-2.676) U18(-13.933,-1.609) U20(-13.933,-0.39) U22(-13.933,0.677) U24(-13.933,1.896) U26(-13.933,2.963) U28(-13.933,4.182) U29(-13.933,5.249) U31(-13.933,6.468) U33(-14.294,7.487) U34(-14.294,8.137) U35(-14.294,8.787) U36(-14.294,9.437) U37(-14.294,10.087) U38(-14.294,10.737) U39(-14.294,11.387) U40(-14.294,12.037) U41(-14.294,12.687) V1(-13.593,-12.687) V2(-13.593,-12.037) V3(-13.593,-11.387) V4(-13.593,-10.737) V5(-13.593,-10.087) V6(-13.593,-9.336) V7(-13.593,-8.686) V8(-13.593,-8.036) V9(-13.593,-7.386) V10(-13.593,-6.736) V11(-13.593,-6.086) V12(-13.154,-5.606) V13(-13.283,-4.968) V15(-13.283,-3.895) V17(-13.283,-2.676) V18(-13.283,-1.609) V20(-13.283,-0.39) V22(-13.283,0.677) V24(-13.283,1.896) V26(-13.283,2.963) V28(-13.283,4.182) V29(-13.283,5.249) V31(-13.283,6.468) V33(-13.527,7.487) V34(-13.527,8.137) V35(-13.527,8.787) V36(-13.527,9.437) V37(-13.527,10.087) V38(-13.527,10.737) V39(-13.527,11.387) V40(-13.527,12.037) V41(-13.527,12.687) W1(-12.826,-12.687) W2(-12.826,-12.037) W3(-12.826,-11.387) W4(-12.826,-10.737) W5(-12.826,-10.087) W6(-12.826,-9.336) W7(-12.826,-8.686) W8(-12.826,-8.036) W9(-12.826,-7.386) W10(-12.826,-6.736) W11(-12.724,-6.094) W13(-12.633,-4.968) W15(-12.633,-3.895) W17(-12.633,-2.676) W18(-12.633,-1.609) W20(-12.633,-0.39) W22(-12.633,0.677) W24(-12.633,1.896) W26(-12.633,2.963) W28(-12.633,4.182) W29(-12.633,5.249) W31(-12.633,6.468) W33(-12.759,7.487) W34(-12.759,8.137) W35(-12.759,8.787) W36(-12.759,9.437) W37(-12.759,10.087) W38(-12.759,10.737) W39(-12.759,11.387) W40(-12.759,12.037) W41(-12.759,12.687) Y1(-11.925,-12.687) Y2(-11.925,-12.037) Y3(-11.925,-11.387) Y4(-11.925,-10.737) Y5(-11.925,-10.087) Y6(-11.925,-9.336) Y7(-11.925,-8.686) Y8(-11.925,-8.036) Y9(-11.925,-7.386) Y10(-11.925,-6.736) Y11(-11.925,-6.086) Y12(-12.308,-5.531) Y13(-11.982,-4.968) Y15(-11.982,-3.895) Y17(-11.982,-2.676) Y18(-11.982,-1.609) Y20(-11.982,-0.39) Y22(-11.982,0.677) Y24(-11.982,1.896) Y26(-11.982,2.963) Y28(-11.982,4.182) Y29(-11.982,5.249) Y31(-11.982,6.468) Y33(-11.992,7.487) Y34(-11.992,8.137) Y35(-11.992,8.787) Y36(-11.992,9.437) Y37(-11.992,10.087) Y38(-11.992,10.737) Y39(-11.992,11.387) Y40(-11.992,12.037) Y41(-11.992,12.687)
  round 0.406 smd: A40(-24.406,12.037) B41(-23.777,12.687) CT1(23.756,-12.687) CT41(23.756,12.687) CU2(24.406,-12.037) CU40(24.406,12.037)
  round 0.356 smd: B4(-23.756,-10.737) B5(-23.756,-9.951) B36(-23.756,9.181) B37(-23.756,10.146) C3(-23.105,-11.387) C39(-23.105,11.146) CN2(21.69,-12.037) CN40(21.768,12.037) CP2(22.448,-12.037) CP40(22.456,12.037) CR3(23.106,-11.333) CR39(23.106,11.33) CT4(23.756,-10.673) CT5(23.756,-9.906) CT36(23.756,9.795) CT38(23.756,10.562) D2(-22.293,-12.037) D40(-22.455,12.037) E2(-21.48,-12.037) E40(-21.805,12.037) F40(-21.155,12.037)
BGA2714-NVIDIA-N20Y-ES-A1
  round 0.305 smd: A2(-19.25,-18.55) A3(-19.25,-17.85) A4(-19.25,-17.15) A5(-19.25,-16.45) A6(-19.25,-15.75) A7(-19.25,-15.05) A8(-19.25,-14.35) A9(-19.25,-13.65) A10(-19.25,-12.95) A11(-19.25,-12.25) A12(-19.25,-11.55) A13(-19.25,-10.85) A14(-19.25,-10.15) A15(-19.25,-9.45) A16(-19.25,-8.75) A17(-19.25,-8.05) A18(-19.25,-7.35) A19(-19.25,-6.65) A20(-19.25,-5.95) A21(-19.25,-5.25) A22(-19.25,-4.55) A23(-19.25,-3.85) A24(-19.25,-3.15) A25(-19.25,-2.45) A26(-19.25,-1.75) A27(-19.25,-1.05) A28(-19.25,-0.35) A29(-19.25,0.35) A30(-19.25,1.05) A31(-19.25,1.75) A32(-19.25,2.45) A33(-19.25,3.15) A34(-19.25,3.85) A35(-19.25,4.55) A36(-19.25,5.25) A37(-19.25,5.95) A38(-19.25,6.65) A39(-19.25,7.35) A40(-19.25,8.05) A41(-19.25,8.75) A42(-19.25,9.45) A43(-19.25,10.15) A44(-19.25,10.85) A45(-19.25,11.55) A46(-19.25,12.25) A47(-19.25,12.95) A48(-19.25,13.65) A49(-19.25,14.35) A50(-19.25,15.05) A51(-19.25,15.75) A52(-19.25,16.45) A53(-19.25,17.15) A54(-19.25,17.85) A55(-19.25,18.55) AA1(-5.25,-19.25) AA2(-5.25,-18.55) AA4(-5.25,-17.15) AA6(-5.25,-15.75) AA8(-5.25,-14.35) AA10(-5.25,-12.95) AA13(-5.25,-10.85) AA14(-5.25,-10.15) AA15(-5.25,-9.45) AA16(-5.25,-8.75) AA17(-5.25,-8.05) AA18(-5.25,-7.35) AA19(-5.25,-6.65) AA20(-5.25,-5.95) AA21(-5.25,-5.25) AA22(-5.25,-4.55) AA23(-5.25,-3.85) AA24(-5.25,-3.15) AA25(-5.25,-2.45) AA26(-5.25,-1.75) AA27(-5.25,-1.05) AA28(-5.25,-0.35) AA29(-5.25,0.35) AA30(-5.25,1.05) AA31(-5.25,1.75) AA32(-5.25,2.45) AA33(-5.25,3.15) AA34(-5.25,3.85) AA35(-5.25,4.55) AA36(-5.25,5.25) AA37(-5.25,5.95) AA38(-5.25,6.65) AA39(-5.25,7.35) AA40(-5.25,8.05) AA41(-5.25,8.75) AA42(-5.25,9.45) AA43(-5.25,10.15) AA44(-5.25,10.85) AA47(-5.25,12.95) AA49(-5.25,14.35) AA51(-5.25,15.75) AA53(-5.25,17.15) AA55(-5.25,18.55) AA56(-5.25,19.25) AB1(-4.55,-19.25) AB2(-4.55,-18.55) AB3(-4.55,-17.85) AB4(-4.55,-17.15) AB5(-4.55,-16.45) AB6(-4.55,-15.75) AB7(-4.55,-15.05) AB8(-4.55,-14.35) AB9(-4.55,-13.65) AB10(-4.55,-12.95) AB11(-4.55,-12.25) AB13(-4.55,-10.85) AB14(-4.55,-10.15) AB15(-4.55,-9.45) AB16(-4.55,-8.75) AB17(-4.55,-8.05) AB18(-4.55,-7.35) AB19(-4.55,-6.65) AB20(-4.55,-5.95) AB21(-4.55,-5.25) AB22(-4.55,-4.55) AB23(-4.55,-3.85) AB24(-4.55,-3.15) AB25(-4.55,-2.45) AB26(-4.55,-1.75) AB27(-4.55,-1.05) AB28(-4.55,-0.35) AB29(-4.55,0.35) AB30(-4.55,1.05) AB31(-4.55,1.75) AB32(-4.55,2.45) AB33(-4.55,3.15) AB34(-4.55,3.85) AB35(-4.55,4.55) AB36(-4.55,5.25) AB37(-4.55,5.95) AB38(-4.55,6.65) AB39(-4.55,7.35) AB40(-4.55,8.05) AB41(-4.55,8.75) AB42(-4.55,9.45) AB43(-4.55,10.15) AB44(-4.55,10.85) AB46(-4.55,12.25) AB47(-4.55,12.95) AB48(-4.55,13.65) AB49(-4.55,14.35) AB50(-4.55,15.05) AB51(-4.55,15.75) AB52(-4.55,16.45) AB53(-4.55,17.15) AB54(-4.55,17.85) AB55(-4.55,18.55) AB56(-4.55,19.25) AC1(-3.85,-19.25) AC2(-3.85,-18.55) AC3(-3.85,-17.85) AC4(-3.85,-17.15) AC5(-3.85,-16.45) AC6(-3.85,-15.75) AC7(-3.85,-15.05) AC8(-3.85,-14.35) AC9(-3.85,-13.65) AC10(-3.85,-12.95) AC11(-3.85,-12.25) AC13(-3.85,-10.85) AC14(-3.85,-10.15) AC15(-3.85,-9.45) AC16(-3.85,-8.75) AC17(-3.85,-8.05) AC18(-3.85,-7.35) AC19(-3.85,-6.65) AC20(-3.85,-5.95) AC21(-3.85,-5.25) AC22(-3.85,-4.55) AC23(-3.85,-3.85) AC24(-3.85,-3.15) AC25(-3.85,-2.45) AC26(-3.85,-1.75) AC27(-3.85,-1.05) AC28(-3.85,-0.35) AC29(-3.85,0.35) AC30(-3.85,1.05) AC31(-3.85,1.75) AC32(-3.85,2.45) AC33(-3.85,3.15) AC34(-3.85,3.85) AC35(-3.85,4.55) AC36(-3.85,5.25) AC37(-3.85,5.95) AC38(-3.85,6.65) AC39(-3.85,7.35) AC40(-3.85,8.05) AC41(-3.85,8.75) AC42(-3.85,9.45) AC43(-3.85,10.15) AC44(-3.85,10.85) AC46(-3.85,12.25) AC47(-3.85,12.95) AC48(-3.85,13.65) AC49(-3.85,14.35) AC50(-3.85,15.05) AC51(-3.85,15.75) AC52(-3.85,16.45) AC53(-3.85,17.15) AC54(-3.85,17.85) AC55(-3.85,18.55) AC56(-3.85,19.25) AD1(-3.15,-19.25) AD2(-3.15,-18.55) AD4(-3.15,-17.15) AD6(-3.15,-15.75) AD8(-3.15,-14.35) AD10(-3.15,-12.95) AD13(-3.15,-10.85) AD14(-3.15,-10.15) AD15(-3.15,-9.45) AD16(-3.15,-8.75) AD17(-3.15,-8.05) AD18(-3.15,-7.35) AD19(-3.15,-6.65) AD20(-3.15,-5.95) AD21(-3.15,-5.25) AD22(-3.15,-4.55) AD23(-3.15,-3.85) AD24(-3.15,-3.15) AD25(-3.15,-2.45) AD26(-3.15,-1.75) AD27(-3.15,-1.05) AD28(-3.15,-0.35) AD29(-3.15,0.35) AD30(-3.15,1.05) AD31(-3.15,1.75) AD32(-3.15,2.45) AD33(-3.15,3.15) AD34(-3.15,3.85) AD35(-3.15,4.55) AD36(-3.15,5.25) AD37(-3.15,5.95) AD38(-3.15,6.65) AD39(-3.15,7.35) AD40(-3.15,8.05) AD41(-3.15,8.75) AD42(-3.15,9.45) AD43(-3.15,10.15) AD44(-3.15,10.85) AD47(-3.15,12.95) AD49(-3.15,14.35) AD51(-3.15,15.75) AD53(-3.15,17.15) AD55(-3.15,18.55) AD56(-3.15,19.25) AE1(-2.45,-19.25) AE2(-2.45,-18.55) AE3(-2.45,-17.85) AE4(-2.45,-17.15) AE5(-2.45,-16.45) AE6(-2.45,-15.75) AE7(-2.45,-15.05) AE8(-2.45,-14.35) AE9(-2.45,-13.65) AE10(-2.45,-12.95) AE11(-2.45,-12.25) AE13(-2.45,-10.85) AE14(-2.45,-10.15) AE15(-2.45,-9.45) AE16(-2.45,-8.75) AE17(-2.45,-8.05) AE18(-2.45,-7.35) AE19(-2.45,-6.65) AE20(-2.45,-5.95) AE21(-2.45,-5.25) AE22(-2.45,-4.55) AE23(-2.45,-3.85) AE24(-2.45,-3.15) AE25(-2.45,-2.45) AE26(-2.45,-1.75) AE27(-2.45,-1.05) AE28(-2.45,-0.35) AE29(-2.45,0.35) AE30(-2.45,1.05) AE31(-2.45,1.75) AE32(-2.45,2.45) AE33(-2.45,3.15) AE34(-2.45,3.85) AE35(-2.45,4.55) AE36(-2.45,5.25) AE37(-2.45,5.95) AE38(-2.45,6.65) AE39(-2.45,7.35) AE40(-2.45,8.05) AE41(-2.45,8.75) AE42(-2.45,9.45) AE43(-2.45,10.15) AE44(-2.45,10.85) AE46(-2.45,12.25) AE47(-2.45,12.95) AE48(-2.45,13.65) AE49(-2.45,14.35) AE50(-2.45,15.05) AE51(-2.45,15.75) AE52(-2.45,16.45) AE53(-2.45,17.15) AE54(-2.45,17.85) AE55(-2.45,18.55) AE56(-2.45,19.25) AF1(-1.75,-19.25) AF2(-1.75,-18.55) AF3(-1.75,-17.85) AF4(-1.75,-17.15) AF5(-1.75,-16.45) AF6(-1.75,-15.75) AF7(-1.75,-15.05) AF8(-1.75,-14.35) AF9(-1.75,-13.65) AF10(-1.75,-12.95) AF11(-1.75,-12.25) AF13(-1.75,-10.85) AF14(-1.75,-10.15) AF15(-1.75,-9.45) AF16(-1.75,-8.75) AF17(-1.75,-8.05) AF18(-1.75,-7.35) AF19(-1.75,-6.65) AF20(-1.75,-5.95) AF21(-1.75,-5.25) AF22(-1.75,-4.55) AF23(-1.75,-3.85) AF24(-1.75,-3.15) AF25(-1.75,-2.45) AF26(-1.75,-1.75) AF27(-1.75,-1.05) AF28(-1.75,-0.35) AF29(-1.75,0.35) AF30(-1.75,1.05) AF31(-1.75,1.75) AF32(-1.75,2.45) AF33(-1.75,3.15) AF34(-1.75,3.85) AF35(-1.75,4.55) AF36(-1.75,5.25) AF37(-1.75,5.95) AF38(-1.75,6.65) AF39(-1.75,7.35) AF40(-1.75,8.05) AF41(-1.75,8.75) AF42(-1.75,9.45) AF43(-1.75,10.15) AF44(-1.75,10.85) AF46(-1.75,12.25) AF47(-1.75,12.95) AF48(-1.75,13.65) AF49(-1.75,14.35) AF50(-1.75,15.05) AF51(-1.75,15.75) AF52(-1.75,16.45) AF53(-1.75,17.15) AF54(-1.75,17.85) AF55(-1.75,18.55) AF56(-1.75,19.25) AG1(-1.05,-19.25) AG2(-1.05,-18.55) AG4(-1.05,-17.15) AG6(-1.05,-15.75) AG8(-1.05,-14.35) AG10(-1.05,-12.95) AG13(-1.05,-10.85) AG14(-1.05,-10.15) AG15(-1.05,-9.45) AG16(-1.05,-8.75) AG17(-1.05,-8.05) AG18(-1.05,-7.35) AG19(-1.05,-6.65) AG20(-1.05,-5.95) AG21(-1.05,-5.25) AG22(-1.05,-4.55) AG23(-1.05,-3.85) AG24(-1.05,-3.15) AG25(-1.05,-2.45) AG26(-1.05,-1.75) AG27(-1.05,-1.05) AG28(-1.05,-0.35) AG29(-1.05,0.35) AG30(-1.05,1.05) AG31(-1.05,1.75) AG32(-1.05,2.45) AG33(-1.05,3.15) AG34(-1.05,3.85) AG35(-1.05,4.55) AG36(-1.05,5.25) AG37(-1.05,5.95) AG38(-1.05,6.65) AG39(-1.05,7.35) AG40(-1.05,8.05) AG41(-1.05,8.75) AG42(-1.05,9.45) AG43(-1.05,10.15) AG44(-1.05,10.85) AG47(-1.05,12.95) AG49(-1.05,14.35) AG51(-1.05,15.75) AG53(-1.05,17.15) AG55(-1.05,18.55) AG56(-1.05,19.25) AH1(-0.35,-19.25) AH2(-0.35,-18.55) AH3(-0.35,-17.85) AH4(-0.35,-17.15) AH5(-0.35,-16.45) AH6(-0.35,-15.75) AH7(-0.35,-15.05) AH8(-0.35,-14.35) AH9(-0.35,-13.65) AH10(-0.35,-12.95) AH11(-0.35,-12.25) AH13(-0.35,-10.85) AH14(-0.35,-10.15) AH15(-0.35,-9.45) AH16(-0.35,-8.75) AH17(-0.35,-8.05) AH18(-0.35,-7.35) AH19(-0.35,-6.65) AH20(-0.35,-5.95) AH21(-0.35,-5.25) AH22(-0.35,-4.55) AH23(-0.35,-3.85) AH24(-0.35,-3.15) AH25(-0.35,-2.45) AH26(-0.35,-1.75) AH27(-0.35,-1.05) AH28(-0.35,-0.35) AH29(-0.35,0.35) AH30(-0.35,1.05) AH31(-0.35,1.75) AH32(-0.35,2.45) AH33(-0.35,3.15) AH34(-0.35,3.85) AH35(-0.35,4.55) AH36(-0.35,5.25) AH37(-0.35,5.95) AH38(-0.35,6.65) AH39(-0.35,7.35) AH40(-0.35,8.05) AH41(-0.35,8.75) AH42(-0.35,9.45) AH43(-0.35,10.15) AH44(-0.35,10.85) AH46(-0.35,12.25) AH47(-0.35,12.95) AH48(-0.35,13.65) AH49(-0.35,14.35) AH50(-0.35,15.05) AH51(-0.35,15.75) AH52(-0.35,16.45) AH53(-0.35,17.15) AH54(-0.35,17.85) AH55(-0.35,18.55) AH56(-0.35,19.25) AJ1(0.35,-19.25) AJ2(0.35,-18.55) AJ3(0.35,-17.85) AJ4(0.35,-17.15) AJ5(0.35,-16.45) AJ6(0.35,-15.75) AJ7(0.35,-15.05) AJ8(0.35,-14.35) AJ9(0.35,-13.65) AJ10(0.35,-12.95) AJ11(0.35,-12.25) AJ13(0.35,-10.85) AJ14(0.35,-10.15) AJ15(0.35,-9.45) AJ16(0.35,-8.75) AJ17(0.35,-8.05) AJ18(0.35,-7.35) AJ19(0.35,-6.65) AJ20(0.35,-5.95) AJ21(0.35,-5.25) AJ22(0.35,-4.55) AJ23(0.35,-3.85) AJ24(0.35,-3.15) AJ25(0.35,-2.45) AJ26(0.35,-1.75) AJ27(0.35,-1.05) AJ28(0.35,-0.35) AJ29(0.35,0.35) AJ30(0.35,1.05) AJ31(0.35,1.75) AJ32(0.35,2.45) AJ33(0.35,3.15) AJ34(0.35,3.85) AJ35(0.35,4.55) AJ36(0.35,5.25) AJ37(0.35,5.95) AJ38(0.35,6.65) AJ39(0.35,7.35) AJ40(0.35,8.05) AJ41(0.35,8.75) AJ42(0.35,9.45) AJ43(0.35,10.15) AJ44(0.35,10.85) AJ46(0.35,12.25) AJ47(0.35,12.95) AJ48(0.35,13.65) AJ49(0.35,14.35) AJ50(0.35,15.05) AJ51(0.35,15.75) AJ52(0.35,16.45) AJ53(0.35,17.15) AJ54(0.35,17.85) AJ55(0.35,18.55) AJ56(0.35,19.25) AK1(1.05,-19.25) AK2(1.05,-18.55) AK4(1.05,-17.15) AK6(1.05,-15.75) AK8(1.05,-14.35) AK10(1.05,-12.95) AK13(1.05,-10.85) AK14(1.05,-10.15) AK15(1.05,-9.45) AK16(1.05,-8.75) AK17(1.05,-8.05) AK18(1.05,-7.35) AK19(1.05,-6.65) AK20(1.05,-5.95) AK21(1.05,-5.25) AK22(1.05,-4.55) AK23(1.05,-3.85) AK24(1.05,-3.15) AK25(1.05,-2.45) AK26(1.05,-1.75) AK27(1.05,-1.05) AK28(1.05,-0.35) AK29(1.05,0.35) AK30(1.05,1.05) AK31(1.05,1.75) AK32(1.05,2.45) AK33(1.05,3.15) AK34(1.05,3.85) AK35(1.05,4.55) AK36(1.05,5.25) AK37(1.05,5.95) AK38(1.05,6.65) AK39(1.05,7.35) AK40(1.05,8.05) AK41(1.05,8.75) AK42(1.05,9.45) AK43(1.05,10.15) AK44(1.05,10.85) AK47(1.05,12.95) AK49(1.05,14.35) AK51(1.05,15.75) AK53(1.05,17.15) AK55(1.05,18.55) AK56(1.05,19.25) AL1(1.75,-19.25) AL2(1.75,-18.55) AL3(1.75,-17.85) AL4(1.75,-17.15) AL5(1.75,-16.45) AL6(1.75,-15.75) AL7(1.75,-15.05) AL8(1.75,-14.35) AL9(1.75,-13.65) AL10(1.75,-12.95) AL11(1.75,-12.25) AL13(1.75,-10.85) AL14(1.75,-10.15) AL15(1.75,-9.45) AL16(1.75,-8.75) AL17(1.75,-8.05) AL18(1.75,-7.35) AL19(1.75,-6.65) AL20(1.75,-5.95) AL21(1.75,-5.25) AL22(1.75,-4.55) AL23(1.75,-3.85) AL24(1.75,-3.15) AL25(1.75,-2.45) AL26(1.75,-1.75) AL27(1.75,-1.05) AL28(1.75,-0.35) AL29(1.75,0.35) AL30(1.75,1.05) AL31(1.75,1.75) AL32(1.75,2.45) AL33(1.75,3.15) AL34(1.75,3.85) AL35(1.75,4.55) AL36(1.75,5.25) AL37(1.75,5.95) AL38(1.75,6.65) AL39(1.75,7.35) AL40(1.75,8.05) AL41(1.75,8.75) AL42(1.75,9.45) AL43(1.75,10.15) AL44(1.75,10.85) AL46(1.75,12.25) AL47(1.75,12.95) AL48(1.75,13.65) AL49(1.75,14.35) AL50(1.75,15.05) AL51(1.75,15.75) AL52(1.75,16.45) AL53(1.75,17.15) AL54(1.75,17.85) AL55(1.75,18.55) AL56(1.75,19.25) AM1(2.45,-19.25) AM2(2.45,-18.55) AM3(2.45,-17.85) AM4(2.45,-17.15) AM5(2.45,-16.45) AM6(2.45,-15.75) AM7(2.45,-15.05) AM8(2.45,-14.35) AM9(2.45,-13.65) AM10(2.45,-12.95) AM11(2.45,-12.25) AM13(2.45,-10.85) AM14(2.45,-10.15) AM15(2.45,-9.45) AM16(2.45,-8.75) AM17(2.45,-8.05) AM18(2.45,-7.35) AM19(2.45,-6.65) AM20(2.45,-5.95) AM21(2.45,-5.25) AM22(2.45,-4.55) AM23(2.45,-3.85) AM24(2.45,-3.15) AM25(2.45,-2.45) AM26(2.45,-1.75) AM27(2.45,-1.05) AM28(2.45,-0.35) AM29(2.45,0.35) AM30(2.45,1.05) AM31(2.45,1.75) AM32(2.45,2.45) AM33(2.45,3.15) AM34(2.45,3.85) AM35(2.45,4.55) AM36(2.45,5.25) AM37(2.45,5.95) AM38(2.45,6.65) AM39(2.45,7.35) AM40(2.45,8.05) AM41(2.45,8.75) AM42(2.45,9.45) AM43(2.45,10.15) AM44(2.45,10.85) AM46(2.45,12.25) AM47(2.45,12.95) AM48(2.45,13.65) AM49(2.45,14.35) AM50(2.45,15.05) AM51(2.45,15.75) AM52(2.45,16.45) AM53(2.45,17.15) AM54(2.45,17.85) AM55(2.45,18.55) AM56(2.45,19.25) AN1(3.15,-19.25) AN2(3.15,-18.55) AN4(3.15,-17.15) AN6(3.15,-15.75) AN8(3.15,-14.35) AN10(3.15,-12.95) AN13(3.15,-10.85) AN14(3.15,-10.15) AN15(3.15,-9.45) AN16(3.15,-8.75) AN17(3.15,-8.05) AN18(3.15,-7.35) AN19(3.15,-6.65) AN20(3.15,-5.95) AN21(3.15,-5.25) AN22(3.15,-4.55) AN23(3.15,-3.85) AN24(3.15,-3.15) AN25(3.15,-2.45) AN26(3.15,-1.75) AN27(3.15,-1.05) AN28(3.15,-0.35) AN29(3.15,0.35) AN30(3.15,1.05) AN31(3.15,1.75) AN32(3.15,2.45) AN33(3.15,3.15) AN34(3.15,3.85) AN35(3.15,4.55) AN36(3.15,5.25) AN37(3.15,5.95) AN38(3.15,6.65) AN39(3.15,7.35) AN40(3.15,8.05) AN41(3.15,8.75) AN42(3.15,9.45) AN43(3.15,10.15) AN44(3.15,10.85) AN47(3.15,12.95) AN49(3.15,14.35) AN51(3.15,15.75) AN53(3.15,17.15) AN55(3.15,18.55) AN56(3.15,19.25) AP1(3.85,-19.25) AP2(3.85,-18.55) AP3(3.85,-17.85) AP4(3.85,-17.15) AP5(3.85,-16.45) AP6(3.85,-15.75) AP7(3.85,-15.05) AP8(3.85,-14.35) AP9(3.85,-13.65) AP10(3.85,-12.95) AP11(3.85,-12.25) AP13(3.85,-10.85) AP14(3.85,-10.15) AP15(3.85,-9.45) AP16(3.85,-8.75) AP17(3.85,-8.05) AP18(3.85,-7.35) AP19(3.85,-6.65) AP20(3.85,-5.95) AP21(3.85,-5.25) AP22(3.85,-4.55) AP23(3.85,-3.85) AP24(3.85,-3.15) AP25(3.85,-2.45) AP26(3.85,-1.75) AP27(3.85,-1.05) AP28(3.85,-0.35) AP29(3.85,0.35) AP30(3.85,1.05) AP31(3.85,1.75) AP32(3.85,2.45) AP33(3.85,3.15) AP34(3.85,3.85) AP35(3.85,4.55) AP36(3.85,5.25) AP37(3.85,5.95) AP38(3.85,6.65) AP39(3.85,7.35) AP40(3.85,8.05) AP41(3.85,8.75) AP42(3.85,9.45) AP43(3.85,10.15) AP44(3.85,10.85) AP46(3.85,12.25) AP47(3.85,12.95) AP48(3.85,13.65) AP49(3.85,14.35) AP50(3.85,15.05) AP51(3.85,15.75) AP52(3.85,16.45) AP53(3.85,17.15) AP54(3.85,17.85) AP55(3.85,18.55) AP56(3.85,19.25) AR1(4.55,-19.25) AR2(4.55,-18.55) AR3(4.55,-17.85) AR4(4.55,-17.15) AR5(4.55,-16.45) AR6(4.55,-15.75) AR7(4.55,-15.05) AR8(4.55,-14.35) AR9(4.55,-13.65) AR10(4.55,-12.95) AR11(4.55,-12.25) AR13(4.55,-10.85) AR14(4.55,-10.15) AR15(4.55,-9.45) AR16(4.55,-8.75) AR17(4.55,-8.05) AR18(4.55,-7.35) AR19(4.55,-6.65) AR20(4.55,-5.95) AR21(4.55,-5.25) AR22(4.55,-4.55) AR23(4.55,-3.85) AR24(4.55,-3.15) AR25(4.55,-2.45) AR26(4.55,-1.75) AR27(4.55,-1.05) AR28(4.55,-0.35) AR29(4.55,0.35) AR30(4.55,1.05) AR31(4.55,1.75) AR32(4.55,2.45) AR33(4.55,3.15) AR34(4.55,3.85) AR35(4.55,4.55) AR36(4.55,5.25) AR37(4.55,5.95) AR38(4.55,6.65) AR39(4.55,7.35) AR40(4.55,8.05) AR41(4.55,8.75) AR42(4.55,9.45) AR43(4.55,10.15) AR44(4.55,10.85) AR46(4.55,12.25) AR47(4.55,12.95) AR48(4.55,13.65) AR49(4.55,14.35) AR50(4.55,15.05) AR51(4.55,15.75) AR52(4.55,16.45) AR53(4.55,17.15) AR54(4.55,17.85) AR55(4.55,18.55) AR56(4.55,19.25) AT1(5.25,-19.25) AT2(5.25,-18.55) AT4(5.25,-17.15) AT6(5.25,-15.75) AT8(5.25,-14.35) AT10(5.25,-12.95) AT13(5.25,-10.85) AT14(5.25,-10.15) AT15(5.25,-9.45) AT16(5.25,-8.75) AT17(5.25,-8.05) AT18(5.25,-7.35) AT19(5.25,-6.65) AT20(5.25,-5.95) AT21(5.25,-5.25) AT22(5.25,-4.55) AT23(5.25,-3.85) AT24(5.25,-3.15) AT25(5.25,-2.45) AT26(5.25,-1.75) AT27(5.25,-1.05) AT28(5.25,-0.35) AT29(5.25,0.35) AT30(5.25,1.05) AT31(5.25,1.75) AT32(5.25,2.45) AT33(5.25,3.15) AT34(5.25,3.85) AT35(5.25,4.55) AT36(5.25,5.25) AT37(5.25,5.95) AT38(5.25,6.65) AT39(5.25,7.35) AT40(5.25,8.05) AT41(5.25,8.75) AT42(5.25,9.45) AT43(5.25,10.15) AT44(5.25,10.85) AT47(5.25,12.95) AT49(5.25,14.35) AT51(5.25,15.75) AT53(5.25,17.15) AT55(5.25,18.55) AT56(5.25,19.25) AU1(5.95,-19.25) AU2(5.95,-18.55) AU3(5.95,-17.85) AU4(5.95,-17.15) AU5(5.95,-16.45) AU6(5.95,-15.75) AU7(5.95,-15.05) AU8(5.95,-14.35) AU9(5.95,-13.65) AU10(5.95,-12.95) AU11(5.95,-12.25) AU13(5.95,-10.85) AU14(5.95,-10.15) AU15(5.95,-9.45) AU16(5.95,-8.75) AU17(5.95,-8.05) AU18(5.95,-7.35) AU19(5.95,-6.65) AU20(5.95,-5.95) AU21(5.95,-5.25) AU22(5.95,-4.55) AU23(5.95,-3.85) AU24(5.95,-3.15) AU25(5.95,-2.45) AU26(5.95,-1.75) AU27(5.95,-1.05) AU28(5.95,-0.35) AU29(5.95,0.35) AU30(5.95,1.05) AU31(5.95,1.75) AU32(5.95,2.45) AU33(5.95,3.15) AU34(5.95,3.85) AU35(5.95,4.55) AU36(5.95,5.25) AU37(5.95,5.95) AU38(5.95,6.65) AU39(5.95,7.35) AU40(5.95,8.05) AU41(5.95,8.75) AU42(5.95,9.45) AU43(5.95,10.15) AU44(5.95,10.85) AU46(5.95,12.25) AU47(5.95,12.95) AU48(5.95,13.65) AU49(5.95,14.35) AU50(5.95,15.05) AU51(5.95,15.75) AU52(5.95,16.45) AU53(5.95,17.15) AU54(5.95,17.85) AU55(5.95,18.55) AU56(5.95,19.25) AV1(6.65,-19.25) AV2(6.65,-18.55) AV3(6.65,-17.85) AV4(6.65,-17.15) AV5(6.65,-16.45) AV6(6.65,-15.75) AV7(6.65,-15.05) AV8(6.65,-14.35) AV9(6.65,-13.65) AV10(6.65,-12.95) AV11(6.65,-12.25) AV13(6.65,-10.85) AV14(6.65,-10.15) AV15(6.65,-9.45) AV16(6.65,-8.75) AV17(6.65,-8.05) AV18(6.65,-7.35) AV19(6.65,-6.65) AV20(6.65,-5.95) AV21(6.65,-5.25) AV22(6.65,-4.55) AV23(6.65,-3.85) AV24(6.65,-3.15) AV25(6.65,-2.45) AV26(6.65,-1.75) AV27(6.65,-1.05) AV28(6.65,-0.35) AV29(6.65,0.35) AV30(6.65,1.05) AV31(6.65,1.75) AV32(6.65,2.45) AV33(6.65,3.15) AV34(6.65,3.85) AV35(6.65,4.55) AV36(6.65,5.25) AV37(6.65,5.95) AV38(6.65,6.65) AV39(6.65,7.35) AV40(6.65,8.05) AV41(6.65,8.75) AV42(6.65,9.45) AV43(6.65,10.15) AV44(6.65,10.85) AV46(6.65,12.25) AV47(6.65,12.95) AV48(6.65,13.65) AV49(6.65,14.35) AV50(6.65,15.05) AV51(6.65,15.75) AV52(6.65,16.45) AV53(6.65,17.15) AV54(6.65,17.85) AV55(6.65,18.55) AV56(6.65,19.25) AW2(7.35,-18.55) AW4(7.35,-17.15) AW6(7.35,-15.75) AW8(7.35,-14.35) AW10(7.35,-12.95) AW13(7.35,-10.85) AW14(7.35,-10.15) AW15(7.35,-9.45) AW16(7.35,-8.75) AW17(7.35,-8.05) AW18(7.35,-7.35) AW19(7.35,-6.65) AW20(7.35,-5.95) AW21(7.35,-5.25) AW22(7.35,-4.55) AW23(7.35,-3.85) AW24(7.35,-3.15) AW25(7.35,-2.45) AW26(7.35,-1.75) AW27(7.35,-1.05) AW28(7.35,-0.35) AW29(7.35,0.35) AW30(7.35,1.05) AW31(7.35,1.75) AW32(7.35,2.45) AW33(7.35,3.15) AW34(7.35,3.85) AW35(7.35,4.55) AW36(7.35,5.25) AW37(7.35,5.95) AW38(7.35,6.65) AW39(7.35,7.35) AW40(7.35,8.05) AW41(7.35,8.75) AW42(7.35,9.45) AW43(7.35,10.15) AW44(7.35,10.85) AW47(7.35,12.95) AW49(7.35,14.35) AW51(7.35,15.75) AW53(7.35,17.15) AW55(7.35,18.55) AW56(7.35,19.25) AY1(8.05,-19.25) AY2(8.05,-18.55) AY3(8.05,-17.85) AY4(8.05,-17.15) AY5(8.05,-16.45) AY6(8.05,-15.75) AY7(8.05,-15.05) AY8(8.05,-14.35) AY9(8.05,-13.65) AY10(8.05,-12.95) AY11(8.05,-12.25) AY13(8.05,-10.85) AY14(8.05,-10.15) AY15(8.05,-9.45) AY16(8.05,-8.75) AY17(8.05,-8.05) AY18(8.05,-7.35) AY19(8.05,-6.65) AY20(8.05,-5.95) AY21(8.05,-5.25) AY22(8.05,-4.55) AY23(8.05,-3.85) AY24(8.05,-3.15) AY25(8.05,-2.45) AY26(8.05,-1.75) AY27(8.05,-1.05) AY28(8.05,-0.35) AY29(8.05,0.35) AY30(8.05,1.05) AY31(8.05,1.75) AY32(8.05,2.45) AY33(8.05,3.15) AY34(8.05,3.85) AY35(8.05,4.55) AY36(8.05,5.25) AY37(8.05,5.95) AY38(8.05,6.65) AY39(8.05,7.35) AY40(8.05,8.05) AY41(8.05,8.75) AY42(8.05,9.45) AY43(8.05,10.15) AY44(8.05,10.85) AY46(8.05,12.25) AY47(8.05,12.95) AY48(8.05,13.65) AY49(8.05,14.35) AY50(8.05,15.05) AY51(8.05,15.75) AY52(8.05,16.45) AY53(8.05,17.15) AY54(8.05,17.85) AY55(8.05,18.55) AY56(8.05,19.25) B1(-18.55,-19.25) B2(-18.55,-18.55) B3(-18.55,-17.85) B4(-18.55,-17.15) B5(-18.55,-16.45) B6(-18.55,-15.75) B7(-18.55,-15.05) B8(-18.55,-14.35) B9(-18.55,-13.65) B10(-18.55,-12.95) B11(-18.55,-12.25) B12(-18.55,-11.55) B13(-18.55,-10.85) B14(-18.55,-10.15) B15(-18.55,-9.45) B16(-18.55,-8.75) B17(-18.55,-8.05) B18(-18.55,-7.35) B19(-18.55,-6.65) B20(-18.55,-5.95) B21(-18.55,-5.25) B22(-18.55,-4.55) B23(-18.55,-3.85) B24(-18.55,-3.15) B25(-18.55,-2.45) B26(-18.55,-1.75) B27(-18.55,-1.05) B28(-18.55,-0.35) B29(-18.55,0.35) B30(-18.55,1.05) B31(-18.55,1.75) B32(-18.55,2.45) B33(-18.55,3.15) B34(-18.55,3.85) B35(-18.55,4.55) B36(-18.55,5.25) B37(-18.55,5.95) B38(-18.55,6.65) B39(-18.55,7.35) B40(-18.55,8.05) B41(-18.55,8.75) B42(-18.55,9.45) B43(-18.55,10.15) B44(-18.55,10.85) B45(-18.55,11.55) B46(-18.55,12.25) B47(-18.55,12.95) B48(-18.55,13.65) B49(-18.55,14.35) B50(-18.55,15.05) B51(-18.55,15.75) B52(-18.55,16.45) B53(-18.55,17.15) B54(-18.55,17.85) B55(-18.55,18.55) B56(-18.55,19.25) BA1(8.75,-19.25) BA2(8.75,-18.55) BA3(8.75,-17.85) BA4(8.75,-17.15) BA5(8.75,-16.45) BA6(8.75,-15.75) BA7(8.75,-15.05) BA8(8.75,-14.35) BA9(8.75,-13.65) BA10(8.75,-12.95) BA11(8.75,-12.25) BA13(8.75,-10.85) BA14(8.75,-10.15) BA15(8.75,-9.45) BA16(8.75,-8.75) BA17(8.75,-8.05) BA18(8.75,-7.35) BA19(8.75,-6.65) BA20(8.75,-5.95) BA21(8.75,-5.25) BA22(8.75,-4.55) BA23(8.75,-3.85) BA24(8.75,-3.15) BA25(8.75,-2.45) BA26(8.75,-1.75) BA27(8.75,-1.05) BA28(8.75,-0.35) BA29(8.75,0.35) BA30(8.75,1.05) BA31(8.75,1.75) BA32(8.75,2.45) BA33(8.75,3.15) BA34(8.75,3.85) BA35(8.75,4.55) BA36(8.75,5.25) BA37(8.75,5.95) BA38(8.75,6.65) BA39(8.75,7.35) BA40(8.75,8.05) BA41(8.75,8.75) BA42(8.75,9.45) BA43(8.75,10.15) BA44(8.75,10.85) BA46(8.75,12.25) BA47(8.75,12.95) BA48(8.75,13.65) BA49(8.75,14.35) BA50(8.75,15.05) BA51(8.75,15.75) BA52(8.75,16.45) BA53(8.75,17.15) BA54(8.75,17.85) BA55(8.75,18.55) BA56(8.75,19.25) BB2(9.45,-18.55) BB4(9.45,-17.15) BB6(9.45,-15.75) BB8(9.45,-14.35) BB10(9.45,-12.95) BB13(9.45,-10.85) BB14(9.45,-10.15) BB15(9.45,-9.45) BB16(9.45,-8.75) BB17(9.45,-8.05) BB18(9.45,-7.35) BB19(9.45,-6.65) BB20(9.45,-5.95) BB21(9.45,-5.25) BB22(9.45,-4.55) BB23(9.45,-3.85) BB24(9.45,-3.15) BB25(9.45,-2.45) BB26(9.45,-1.75) BB27(9.45,-1.05) BB28(9.45,-0.35) BB29(9.45,0.35) BB30(9.45,1.05) BB31(9.45,1.75) BB32(9.45,2.45) BB33(9.45,3.15) BB34(9.45,3.85) BB35(9.45,4.55) BB36(9.45,5.25) BB37(9.45,5.95) BB38(9.45,6.65) BB39(9.45,7.35) BB40(9.45,8.05) BB41(9.45,8.75) BB42(9.45,9.45) BB43(9.45,10.15) BB44(9.45,10.85) BB47(9.45,12.95) BB49(9.45,14.35) BB51(9.45,15.75) BB53(9.45,17.15) BB55(9.45,18.55) BB56(9.45,19.25) BC1(10.15,-19.25) BC2(10.15,-18.55) BC3(10.15,-17.85) BC4(10.15,-17.15) BC5(10.15,-16.45) BC6(10.15,-15.75) BC7(10.15,-15.05) BC8(10.15,-14.35) BC9(10.15,-13.65) BC10(10.15,-12.95) BC11(10.15,-12.25) BC13(10.15,-10.85) BC14(10.15,-10.15) BC15(10.15,-9.45) BC16(10.15,-8.75) BC17(10.15,-8.05) BC18(10.15,-7.35) BC19(10.15,-6.65) BC20(10.15,-5.95) BC21(10.15,-5.25) BC22(10.15,-4.55) BC23(10.15,-3.85) BC24(10.15,-3.15) BC25(10.15,-2.45) BC26(10.15,-1.75) BC27(10.15,-1.05) BC28(10.15,-0.35) BC29(10.15,0.35) BC30(10.15,1.05) BC31(10.15,1.75) BC32(10.15,2.45) BC33(10.15,3.15) BC34(10.15,3.85) BC35(10.15,4.55) BC36(10.15,5.25) BC37(10.15,5.95) BC38(10.15,6.65) BC39(10.15,7.35) BC40(10.15,8.05) BC41(10.15,8.75) BC42(10.15,9.45) BC43(10.15,10.15) BC44(10.15,10.85) BC46(10.15,12.25) BC47(10.15,12.95) BC48(10.15,13.65) BC49(10.15,14.35) BC50(10.15,15.05) BC51(10.15,15.75) BC52(10.15,16.45) BC53(10.15,17.15) BC54(10.15,17.85) BC55(10.15,18.55) BC56(10.15,19.25) BD1(10.85,-19.25) BD2(10.85,-18.55) BD3(10.85,-17.85) BD4(10.85,-17.15) BD5(10.85,-16.45) BD6(10.85,-15.75) BD7(10.85,-15.05) BD8(10.85,-14.35) BD9(10.85,-13.65) BD10(10.85,-12.95) BD11(10.85,-12.25) BD13(10.85,-10.85) BD14(10.85,-10.15) BD15(10.85,-9.45) BD16(10.85,-8.75) BD17(10.85,-8.05) BD18(10.85,-7.35) BD19(10.85,-6.65) BD20(10.85,-5.95) BD21(10.85,-5.25) BD22(10.85,-4.55) BD23(10.85,-3.85) BD24(10.85,-3.15) BD25(10.85,-2.45) BD26(10.85,-1.75) BD27(10.85,-1.05) BD28(10.85,-0.35) BD29(10.85,0.35) BD30(10.85,1.05) BD31(10.85,1.75) BD32(10.85,2.45) BD33(10.85,3.15) BD34(10.85,3.85) BD35(10.85,4.55) BD36(10.85,5.25) BD37(10.85,5.95) BD38(10.85,6.65) BD39(10.85,7.35) BD40(10.85,8.05) BD41(10.85,8.75) BD42(10.85,9.45) BD43(10.85,10.15) BD44(10.85,10.85) BD46(10.85,12.25) BD47(10.85,12.95) BD48(10.85,13.65) BD49(10.85,14.35) BD50(10.85,15.05) BD51(10.85,15.75) BD52(10.85,16.45) BD53(10.85,17.15) BD54(10.85,17.85) BD55(10.85,18.55) BD56(10.85,19.25) BE2(11.55,-18.55) BE4(11.55,-17.15) BE6(11.55,-15.75) BE8(11.55,-14.35) BE10(11.55,-12.95) BE47(11.55,12.95) BE49(11.55,14.35) BE51(11.55,15.75) BE53(11.55,17.15) BE55(11.55,18.55) BE56(11.55,19.25) BF1(12.25,-19.25) BF2(12.25,-18.55) BF3(12.25,-17.85) BF4(12.25,-17.15) BF5(12.25,-16.45) BF6(12.25,-15.75) BF7(12.25,-15.05) BF8(12.25,-14.35) BF9(12.25,-13.65) BF10(12.25,-12.95) BF11(12.25,-12.25) BF13(12.25,-10.85) BF14(12.25,-10.15) BF16(12.25,-8.75) BF17(12.25,-8.05) BF19(12.25,-6.65) BF20(12.25,-5.95) BF22(12.25,-4.55) BF23(12.25,-3.85) BF25(12.25,-2.45) BF26(12.25,-1.75) BF28(12.25,-0.35) BF29(12.25,0.35) BF31(12.25,1.75) BF32(12.25,2.45) BF34(12.25,3.85) BF35(12.25,4.55) BF37(12.25,5.95) BF38(12.25,6.65) BF40(12.25,8.05) BF41(12.25,8.75) BF43(12.25,10.15) BF44(12.25,10.85) BF46(12.25,12.25) BF47(12.25,12.95) BF48(12.25,13.65) BF49(12.25,14.35) BF50(12.25,15.05) BF51(12.25,15.75) BF52(12.25,16.45) BF53(12.25,17.15) BF54(12.25,17.85) BF55(12.25,18.55) BF56(12.25,19.25) BG1(12.95,-19.25) BG2(12.95,-18.55) BG3(12.95,-17.85) BG4(12.95,-17.15) BG5(12.95,-16.45) BG6(12.95,-15.75) BG7(12.95,-15.05) BG8(12.95,-14.35) BG9(12.95,-13.65) BG10(12.95,-12.95) BG11(12.95,-12.25) BG12(12.95,-11.55) BG13(12.95,-10.85) BG14(12.95,-10.15) BG15(12.95,-9.45) BG16(12.95,-8.75) BG17(12.95,-8.05) BG18(12.95,-7.35) BG19(12.95,-6.65) BG20(12.95,-5.95) BG21(12.95,-5.25) BG22(12.95,-4.55) BG23(12.95,-3.85) BG24(12.95,-3.15) BG25(12.95,-2.45) BG26(12.95,-1.75) BG27(12.95,-1.05) BG28(12.95,-0.35) BG29(12.95,0.35) BG30(12.95,1.05) BG31(12.95,1.75) BG32(12.95,2.45) BG33(12.95,3.15) BG34(12.95,3.85) BG35(12.95,4.55) BG36(12.95,5.25) BG37(12.95,5.95) BG38(12.95,6.65) BG39(12.95,7.35) BG40(12.95,8.05) BG41(12.95,8.75) BG42(12.95,9.45) BG43(12.95,10.15) BG44(12.95,10.85) BG45(12.95,11.55) BG46(12.95,12.25) BG47(12.95,12.95) BG48(12.95,13.65) BG49(12.95,14.35) BG50(12.95,15.05) BG51(12.95,15.75) BG52(12.95,16.45) BG53(12.95,17.15) BG54(12.95,17.85) BG55(12.95,18.55) BG56(12.95,19.25) BH1(13.65,-19.25) BH2(13.65,-18.55) BH4(13.65,-17.15) BH6(13.65,-15.75) BH8(13.65,-14.35) BH10(13.65,-12.95) BH11(13.65,-12.25) BH13(13.65,-10.85) BH14(13.65,-10.15) BH16(13.65,-8.75) BH17(13.65,-8.05) BH19(13.65,-6.65) BH20(13.65,-5.95) BH22(13.65,-4.55) BH23(13.65,-3.85) BH25(13.65,-2.45) BH26(13.65,-1.75) BH28(13.65,-0.35) BH29(13.65,0.35) BH31(13.65,1.75) BH32(13.65,2.45) BH34(13.65,3.85) BH35(13.65,4.55) BH37(13.65,5.95) BH38(13.65,6.65) BH40(13.65,8.05) BH41(13.65,8.75) BH43(13.65,10.15) BH44(13.65,10.85) BH46(13.65,12.25) BH47(13.65,12.95) BH49(13.65,14.35) BH51(13.65,15.75) BH53(13.65,17.15) BH55(13.65,18.55) BH56(13.65,19.25) BJ1(14.35,-19.25) BJ2(14.35,-18.55) BJ3(14.35,-17.85) BJ4(14.35,-17.15) BJ5(14.35,-16.45) BJ6(14.35,-15.75) BJ7(14.35,-15.05) BJ8(14.35,-14.35) BJ9(14.35,-13.65) BJ10(14.35,-12.95) BJ11(14.35,-12.25) BJ12(14.35,-11.55) BJ13(14.35,-10.85) BJ14(14.35,-10.15) BJ15(14.35,-9.45) BJ16(14.35,-8.75) BJ17(14.35,-8.05) BJ18(14.35,-7.35) BJ19(14.35,-6.65) BJ20(14.35,-5.95) BJ21(14.35,-5.25) BJ22(14.35,-4.55) BJ23(14.35,-3.85) BJ24(14.35,-3.15) BJ25(14.35,-2.45) BJ26(14.35,-1.75) BJ27(14.35,-1.05) BJ28(14.35,-0.35) BJ29(14.35,0.35) BJ30(14.35,1.05) BJ31(14.35,1.75) BJ32(14.35,2.45) BJ33(14.35,3.15) BJ34(14.35,3.85) BJ35(14.35,4.55) BJ36(14.35,5.25) BJ37(14.35,5.95) BJ38(14.35,6.65) BJ39(14.35,7.35) BJ40(14.35,8.05) BJ41(14.35,8.75) BJ42(14.35,9.45) BJ43(14.35,10.15) BJ44(14.35,10.85) BJ45(14.35,11.55) BJ46(14.35,12.25) BJ47(14.35,12.95) BJ48(14.35,13.65) BJ49(14.35,14.35) BJ50(14.35,15.05) BJ51(14.35,15.75) BJ52(14.35,16.45) BJ53(14.35,17.15) BJ54(14.35,17.85) BJ55(14.35,18.55) BJ56(14.35,19.25) BK1(15.05,-19.25) BK2(15.05,-18.55) BK3(15.05,-17.85) BK4(15.05,-17.15) BK5(15.05,-16.45) BK6(15.05,-15.75) BK7(15.05,-15.05) BK8(15.05,-14.35) BK10(15.05,-12.95) BK11(15.05,-12.25) BK13(15.05,-10.85) BK14(15.05,-10.15) BK16(15.05,-8.75) BK17(15.05,-8.05) BK19(15.05,-6.65) BK20(15.05,-5.95) BK22(15.05,-4.55) BK23(15.05,-3.85) BK25(15.05,-2.45) BK26(15.05,-1.75) BK28(15.05,-0.35) BK29(15.05,0.35) BK30(15.05,1.05) BK31(15.05,1.75) BK32(15.05,2.45) BK33(15.05,3.15) BK34(15.05,3.85) BK35(15.05,4.55) BK36(15.05,5.25) BK37(15.05,5.95) BK38(15.05,6.65) BK39(15.05,7.35) BK40(15.05,8.05) BK41(15.05,8.75) BK42(15.05,9.45) BK43(15.05,10.15) BK44(15.05,10.85) BK45(15.05,11.55) BK46(15.05,12.25) BK47(15.05,12.95) BK49(15.05,14.35) BK50(15.05,15.05) BK51(15.05,15.75) BK52(15.05,16.45) BK53(15.05,17.15) BK54(15.05,17.85) BK55(15.05,18.55) BK56(15.05,19.25) BL1(15.75,-19.25) BL2(15.75,-18.55) BL4(15.75,-17.15) BL6(15.75,-15.75) BL7(15.75,-15.05) BL8(15.75,-14.35) BL9(15.75,-13.65) BL10(15.75,-12.95) BL11(15.75,-12.25) BL12(15.75,-11.55) BL13(15.75,-10.85) BL14(15.75,-10.15) BL15(15.75,-9.45) BL16(15.75,-8.75) BL17(15.75,-8.05) BL18(15.75,-7.35) BL19(15.75,-6.65) BL20(15.75,-5.95) BL21(15.75,-5.25) BL22(15.75,-4.55) BL23(15.75,-3.85) BL24(15.75,-3.15) BL25(15.75,-2.45) BL26(15.75,-1.75) BL27(15.75,-1.05) BL28(15.75,-0.35) BL29(15.75,0.35) BL30(15.75,1.05) BL31(15.75,1.75) BL32(15.75,2.45) BL33(15.75,3.15) BL34(15.75,3.85) BL35(15.75,4.55) BL36(15.75,5.25) BL37(15.75,5.95) BL38(15.75,6.65) BL39(15.75,7.35) BL40(15.75,8.05) BL41(15.75,8.75) BL42(15.75,9.45) BL43(15.75,10.15) BL44(15.75,10.85) BL45(15.75,11.55) BL46(15.75,12.25) BL47(15.75,12.95) BL48(15.75,13.65) BL49(15.75,14.35) BL50(15.75,15.05) BL51(15.75,15.75) BL53(15.75,17.15) BL55(15.75,18.55) BL56(15.75,19.25) BM1(16.45,-19.25) BM2(16.45,-18.55) BM3(16.45,-17.85) BM4(16.45,-17.15) BM5(16.45,-16.45) BM7(16.45,-15.05) BM8(16.45,-14.35) BM10(16.45,-12.95) BM11(16.45,-12.25) BM13(16.45,-10.85) BM14(16.45,-10.15) BM16(16.45,-8.75) BM17(16.45,-8.05) BM19(16.45,-6.65) BM20(16.45,-5.95) BM22(16.45,-4.55) BM23(16.45,-3.85) BM25(16.45,-2.45) BM26(16.45,-1.75) BM28(16.45,-0.35) BM29(16.45,0.35) BM30(16.45,1.05) BM31(16.45,1.75) BM32(16.45,2.45) BM33(16.45,3.15) BM34(16.45,3.85) BM35(16.45,4.55) BM36(16.45,5.25) BM37(16.45,5.95) BM38(16.45,6.65) BM39(16.45,7.35) BM40(16.45,8.05) BM41(16.45,8.75) BM42(16.45,9.45) BM43(16.45,10.15) BM44(16.45,10.85) BM45(16.45,11.55) BM46(16.45,12.25) BM47(16.45,12.95) BM48(16.45,13.65) BM49(16.45,14.35) BM50(16.45,15.05) BM52(16.45,16.45) BM53(16.45,17.15) BM54(16.45,17.85) BM55(16.45,18.55) BM56(16.45,19.25) BN1(17.15,-19.25) BN2(17.15,-18.55) BN3(17.15,-17.85) BN4(17.15,-17.15) BN5(17.15,-16.45) BN6(17.15,-15.75) BN7(17.15,-15.05) BN8(17.15,-14.35) BN9(17.15,-13.65) BN10(17.15,-12.95) BN11(17.15,-12.25) BN12(17.15,-11.55) BN13(17.15,-10.85) BN14(17.15,-10.15) BN15(17.15,-9.45) BN16(17.15,-8.75) BN17(17.15,-8.05) BN18(17.15,-7.35) BN19(17.15,-6.65) BN20(17.15,-5.95) BN21(17.15,-5.25) BN22(17.15,-4.55) BN23(17.15,-3.85) BN24(17.15,-3.15) BN25(17.15,-2.45) BN26(17.15,-1.75) BN27(17.15,-1.05) BN28(17.15,-0.35) BN29(17.15,0.35) BN30(17.15,1.05) BN31(17.15,1.75) BN32(17.15,2.45) BN33(17.15,3.15) BN34(17.15,3.85) BN35(17.15,4.55) BN36(17.15,5.25) BN37(17.15,5.95) BN38(17.15,6.65) BN39(17.15,7.35) BN40(17.15,8.05) BN41(17.15,8.75) BN42(17.15,9.45) BN43(17.15,10.15) BN44(17.15,10.85) BN45(17.15,11.55) BN46(17.15,12.25) BN47(17.15,12.95) BN48(17.15,13.65) BN49(17.15,14.35) BN50(17.15,15.05) BN51(17.15,15.75) BN52(17.15,16.45) BN53(17.15,17.15) BN54(17.15,17.85) BN55(17.15,18.55) BN56(17.15,19.25) BP1(17.85,-19.25) BP2(17.85,-18.55) BP3(17.85,-17.85) BP4(17.85,-17.15) BP5(17.85,-16.45) BP7(17.85,-15.05) BP8(17.85,-14.35) BP10(17.85,-12.95) BP11(17.85,-12.25) BP13(17.85,-10.85) BP14(17.85,-10.15) BP16(17.85,-8.75) BP17(17.85,-8.05) BP19(17.85,-6.65) BP20(17.85,-5.95) BP22(17.85,-4.55) BP23(17.85,-3.85) BP25(17.85,-2.45) BP26(17.85,-1.75) BP28(17.85,-0.35) BP29(17.85,0.35) BP31(17.85,1.75) BP32(17.85,2.45) BP33(17.85,3.15) BP34(17.85,3.85) BP35(17.85,4.55) BP36(17.85,5.25) BP37(17.85,5.95) BP38(17.85,6.65) BP39(17.85,7.35) BP40(17.85,8.05) BP41(17.85,8.75) BP42(17.85,9.45) BP43(17.85,10.15) BP44(17.85,10.85) BP45(17.85,11.55) BP46(17.85,12.25) BP47(17.85,12.95) BP48(17.85,13.65) BP49(17.85,14.35) BP50(17.85,15.05) BP52(17.85,16.45) BP53(17.85,17.15) BP54(17.85,17.85) BP55(17.85,18.55) BP56(17.85,19.25) BR1(18.55,-19.25) BR2(18.55,-18.55) BR3(18.55,-17.85) BR4(18.55,-17.15) BR5(18.55,-16.45) BR6(18.55,-15.75) BR7(18.55,-15.05) BR8(18.55,-14.35) BR9(18.55,-13.65) BR10(18.55,-12.95) BR11(18.55,-12.25) BR12(18.55,-11.55) BR13(18.55,-10.85) BR14(18.55,-10.15) BR15(18.55,-9.45) BR16(18.55,-8.75) BR17(18.55,-8.05) BR18(18.55,-7.35) BR19(18.55,-6.65) BR20(18.55,-5.95) BR21(18.55,-5.25) BR22(18.55,-4.55) BR23(18.55,-3.85) BR24(18.55,-3.15) BR25(18.55,-2.45) BR26(18.55,-1.75) BR27(18.55,-1.05) BR28(18.55,-0.35) BR29(18.55,0.35) BR30(18.55,1.05) BR31(18.55,1.75) BR32(18.55,2.45) BR33(18.55,3.15) BR34(18.55,3.85) BR35(18.55,4.55) BR36(18.55,5.25) BR37(18.55,5.95) BR38(18.55,6.65) BR39(18.55,7.35) BR40(18.55,8.05) BR41(18.55,8.75) BR42(18.55,9.45) BR43(18.55,10.15) BR44(18.55,10.85) BR45(18.55,11.55) BR46(18.55,12.25) BR47(18.55,12.95) BR48(18.55,13.65) BR49(18.55,14.35) BR50(18.55,15.05) BR51(18.55,15.75) BR52(18.55,16.45) BR53(18.55,17.15) BR54(18.55,17.85) BR55(18.55,18.55) BR56(18.55,19.25) BT2(19.25,-18.55) BT3(19.25,-17.85) BT4(19.25,-17.15) BT5(19.25,-16.45) BT7(19.25,-15.05) BT8(19.25,-14.35) BT10(19.25,-12.95) BT11(19.25,-12.25) BT13(19.25,-10.85) BT14(19.25,-10.15) BT16(19.25,-8.75) BT17(19.25,-8.05) BT19(19.25,-6.65) BT20(19.25,-5.95) BT22(19.25,-4.55) BT23(19.25,-3.85) BT25(19.25,-2.45) BT26(19.25,-1.75) BT28(19.25,-0.35) BT29(19.25,0.35) BT30(19.25,1.05) BT32(19.25,2.45) BT34(19.25,3.85) BT36(19.25,5.25) BT38(19.25,6.65) BT40(19.25,8.05) BT42(19.25,9.45) BT44(19.25,10.85) BT46(19.25,12.25) BT48(19.25,13.65) BT50(19.25,15.05) BT51(19.25,15.75) BT52(19.25,16.45) BT53(19.25,17.15) BT54(19.25,17.85) BT55(19.25,18.55) C1(-17.85,-19.25) C2(-17.85,-18.55) C3(-17.85,-17.85) C4(-17.85,-17.15) C5(-17.85,-16.45) C7(-17.85,-15.05) C8(-17.85,-14.35) C10(-17.85,-12.95) C11(-17.85,-12.25) C13(-17.85,-10.85) C14(-17.85,-10.15) C16(-17.85,-8.75) C17(-17.85,-8.05) C19(-17.85,-6.65) C20(-17.85,-5.95) C22(-17.85,-4.55) C23(-17.85,-3.85) C25(-17.85,-2.45) C26(-17.85,-1.75) C28(-17.85,-0.35) C29(-17.85,0.35) C31(-17.85,1.75) C32(-17.85,2.45) C34(-17.85,3.85) C35(-17.85,4.55) C37(-17.85,5.95) C38(-17.85,6.65) C40(-17.85,8.05) C41(-17.85,8.75) C43(-17.85,10.15) C44(-17.85,10.85) C46(-17.85,12.25) C47(-17.85,12.95) C49(-17.85,14.35) C50(-17.85,15.05) C52(-17.85,16.45) C53(-17.85,17.15) C54(-17.85,17.85) C55(-17.85,18.55) C56(-17.85,19.25) D1(-17.15,-19.25) D2(-17.15,-18.55) D3(-17.15,-17.85) D4(-17.15,-17.15) D5(-17.15,-16.45) D6(-17.15,-15.75) D7(-17.15,-15.05) D8(-17.15,-14.35) D9(-17.15,-13.65) D10(-17.15,-12.95) D11(-17.15,-12.25) D12(-17.15,-11.55) D13(-17.15,-10.85) D14(-17.15,-10.15) D15(-17.15,-9.45) D16(-17.15,-8.75) D17(-17.15,-8.05) D18(-17.15,-7.35) D19(-17.15,-6.65) D20(-17.15,-5.95) D21(-17.15,-5.25) D22(-17.15,-4.55) D23(-17.15,-3.85) D24(-17.15,-3.15) D25(-17.15,-2.45) D26(-17.15,-1.75) D27(-17.15,-1.05) D28(-17.15,-0.35) D29(-17.15,0.35) D30(-17.15,1.05) D31(-17.15,1.75) D32(-17.15,2.45) D33(-17.15,3.15) D34(-17.15,3.85) D35(-17.15,4.55) D36(-17.15,5.25) D37(-17.15,5.95) D38(-17.15,6.65) D39(-17.15,7.35) D40(-17.15,8.05) D41(-17.15,8.75) D42(-17.15,9.45) D43(-17.15,10.15) D44(-17.15,10.85) D45(-17.15,11.55) D46(-17.15,12.25) D47(-17.15,12.95) D48(-17.15,13.65) D49(-17.15,14.35) D50(-17.15,15.05) D51(-17.15,15.75) D52(-17.15,16.45) D53(-17.15,17.15) D54(-17.15,17.85) D55(-17.15,18.55) D56(-17.15,19.25) E1(-16.45,-19.25) E2(-16.45,-18.55) E3(-16.45,-17.85) E4(-16.45,-17.15) E5(-16.45,-16.45) E7(-16.45,-15.05) E8(-16.45,-14.35) E10(-16.45,-12.95) E11(-16.45,-12.25) E13(-16.45,-10.85) E14(-16.45,-10.15) E16(-16.45,-8.75) E17(-16.45,-8.05) E19(-16.45,-6.65) E20(-16.45,-5.95) E22(-16.45,-4.55) E23(-16.45,-3.85) E25(-16.45,-2.45) E26(-16.45,-1.75) E28(-16.45,-0.35) E29(-16.45,0.35) E31(-16.45,1.75) E32(-16.45,2.45) E34(-16.45,3.85) E35(-16.45,4.55) E37(-16.45,5.95) E38(-16.45,6.65) E40(-16.45,8.05) E41(-16.45,8.75) E43(-16.45,10.15) E44(-16.45,10.85) E46(-16.45,12.25) E47(-16.45,12.95) E49(-16.45,14.35) E50(-16.45,15.05) E52(-16.45,16.45) E53(-16.45,17.15) E54(-16.45,17.85) E55(-16.45,18.55) E56(-16.45,19.25) F1(-15.75,-19.25) F2(-15.75,-18.55) F4(-15.75,-17.15) F6(-15.75,-15.75) F7(-15.75,-15.05) F8(-15.75,-14.35) F9(-15.75,-13.65) F10(-15.75,-12.95) F11(-15.75,-12.25) F12(-15.75,-11.55) F13(-15.75,-10.85) F14(-15.75,-10.15) F15(-15.75,-9.45) F16(-15.75,-8.75) F17(-15.75,-8.05) F18(-15.75,-7.35) F19(-15.75,-6.65) F20(-15.75,-5.95) F21(-15.75,-5.25) F22(-15.75,-4.55) F23(-15.75,-3.85) F24(-15.75,-3.15) F25(-15.75,-2.45) F26(-15.75,-1.75) F27(-15.75,-1.05) F28(-15.75,-0.35) F29(-15.75,0.35) F30(-15.75,1.05) F31(-15.75,1.75) F32(-15.75,2.45) F33(-15.75,3.15) F34(-15.75,3.85) F35(-15.75,4.55) F36(-15.75,5.25) F37(-15.75,5.95) F38(-15.75,6.65) F39(-15.75,7.35) F40(-15.75,8.05) F41(-15.75,8.75) F42(-15.75,9.45) F43(-15.75,10.15) F44(-15.75,10.85) F45(-15.75,11.55) F46(-15.75,12.25) F47(-15.75,12.95) F48(-15.75,13.65) F49(-15.75,14.35) F50(-15.75,15.05) F51(-15.75,15.75) F53(-15.75,17.15) F55(-15.75,18.55) F56(-15.75,19.25) G1(-15.05,-19.25) G2(-15.05,-18.55) G3(-15.05,-17.85) G4(-15.05,-17.15) G5(-15.05,-16.45) G6(-15.05,-15.75) G7(-15.05,-15.05) G8(-15.05,-14.35) G10(-15.05,-12.95) G11(-15.05,-12.25) G13(-15.05,-10.85) G14(-15.05,-10.15) G16(-15.05,-8.75) G17(-15.05,-8.05) G19(-15.05,-6.65) G20(-15.05,-5.95) G22(-15.05,-4.55) G23(-15.05,-3.85) G25(-15.05,-2.45) G26(-15.05,-1.75) G28(-15.05,-0.35) G29(-15.05,0.35) G31(-15.05,1.75) G32(-15.05,2.45) G34(-15.05,3.85) G35(-15.05,4.55) G37(-15.05,5.95) G38(-15.05,6.65) G40(-15.05,8.05) G41(-15.05,8.75) G43(-15.05,10.15) G44(-15.05,10.85) G46(-15.05,12.25) G47(-15.05,12.95) G49(-15.05,14.35) G50(-15.05,15.05) G51(-15.05,15.75) G52(-15.05,16.45) G53(-15.05,17.15) G54(-15.05,17.85) G55(-15.05,18.55) G56(-15.05,19.25) H1(-14.35,-19.25) H2(-14.35,-18.55) H3(-14.35,-17.85) H4(-14.35,-17.15) H5(-14.35,-16.45) H6(-14.35,-15.75) H7(-14.35,-15.05) H8(-14.35,-14.35) H9(-14.35,-13.65) H10(-14.35,-12.95) H11(-14.35,-12.25) H12(-14.35,-11.55) H13(-14.35,-10.85) H14(-14.35,-10.15) H15(-14.35,-9.45) H16(-14.35,-8.75) H17(-14.35,-8.05) H18(-14.35,-7.35) H19(-14.35,-6.65) H20(-14.35,-5.95) H21(-14.35,-5.25) H22(-14.35,-4.55) H23(-14.35,-3.85) H24(-14.35,-3.15) H25(-14.35,-2.45) H26(-14.35,-1.75) H27(-14.35,-1.05) H28(-14.35,-0.35) H29(-14.35,0.35) H30(-14.35,1.05) H31(-14.35,1.75) H32(-14.35,2.45) H33(-14.35,3.15) H34(-14.35,3.85) H35(-14.35,4.55) H36(-14.35,5.25) H37(-14.35,5.95) H38(-14.35,6.65) H39(-14.35,7.35) H40(-14.35,8.05) H41(-14.35,8.75) H42(-14.35,9.45) H43(-14.35,10.15) H44(-14.35,10.85) H45(-14.35,11.55) H46(-14.35,12.25) H47(-14.35,12.95) H48(-14.35,13.65) H49(-14.35,14.35) H50(-14.35,15.05) H51(-14.35,15.75) H52(-14.35,16.45) H53(-14.35,17.15) H54(-14.35,17.85) H55(-14.35,18.55) H56(-14.35,19.25) J1(-13.65,-19.25) J2(-13.65,-18.55) J4(-13.65,-17.15) J6(-13.65,-15.75) J8(-13.65,-14.35) J10(-13.65,-12.95) J11(-13.65,-12.25) J13(-13.65,-10.85) J14(-13.65,-10.15) J16(-13.65,-8.75) J17(-13.65,-8.05) J19(-13.65,-6.65) J20(-13.65,-5.95) J22(-13.65,-4.55) J23(-13.65,-3.85) J25(-13.65,-2.45) J26(-13.65,-1.75) J28(-13.65,-0.35) J29(-13.65,0.35) J31(-13.65,1.75) J32(-13.65,2.45) J34(-13.65,3.85) J35(-13.65,4.55) J37(-13.65,5.95) J38(-13.65,6.65) J40(-13.65,8.05) J41(-13.65,8.75) J43(-13.65,10.15) J44(-13.65,10.85) J46(-13.65,12.25) J47(-13.65,12.95) J49(-13.65,14.35) J51(-13.65,15.75) J53(-13.65,17.15) J55(-13.65,18.55) J56(-13.65,19.25) K1(-12.95,-19.25) K2(-12.95,-18.55) K3(-12.95,-17.85) K4(-12.95,-17.15) K5(-12.95,-16.45) K6(-12.95,-15.75) K7(-12.95,-15.05) K8(-12.95,-14.35) K9(-12.95,-13.65) K10(-12.95,-12.95) K11(-12.95,-12.25) K12(-12.95,-11.55) K13(-12.95,-10.85) K14(-12.95,-10.15) K15(-12.95,-9.45) K16(-12.95,-8.75) K17(-12.95,-8.05) K18(-12.95,-7.35) K19(-12.95,-6.65) K20(-12.95,-5.95) K21(-12.95,-5.25) K22(-12.95,-4.55) K23(-12.95,-3.85) K24(-12.95,-3.15) K25(-12.95,-2.45) K26(-12.95,-1.75) K27(-12.95,-1.05) K28(-12.95,-0.35) K29(-12.95,0.35) K30(-12.95,1.05) K31(-12.95,1.75) K32(-12.95,2.45) K33(-12.95,3.15) K34(-12.95,3.85) K35(-12.95,4.55) K36(-12.95,5.25) K37(-12.95,5.95) K38(-12.95,6.65) K39(-12.95,7.35) K40(-12.95,8.05) K41(-12.95,8.75) K42(-12.95,9.45) K43(-12.95,10.15) K44(-12.95,10.85) K45(-12.95,11.55) K46(-12.95,12.25) K47(-12.95,12.95) K48(-12.95,13.65) K49(-12.95,14.35) K50(-12.95,15.05) K51(-12.95,15.75) K52(-12.95,16.45) K53(-12.95,17.15) K54(-12.95,17.85) K55(-12.95,18.55) K56(-12.95,19.25) L1(-12.25,-19.25) L2(-12.25,-18.55) L3(-12.25,-17.85) L4(-12.25,-17.15) L5(-12.25,-16.45) L6(-12.25,-15.75) L7(-12.25,-15.05) L8(-12.25,-14.35) L9(-12.25,-13.65) L10(-12.25,-12.95) L11(-12.25,-12.25) L13(-12.25,-10.85) L14(-12.25,-10.15) L16(-12.25,-8.75) L17(-12.25,-8.05) L19(-12.25,-6.65) L20(-12.25,-5.95) L22(-12.25,-4.55) L23(-12.25,-3.85) L25(-12.25,-2.45) L26(-12.25,-1.75) L28(-12.25,-0.35) L29(-12.25,0.35) L31(-12.25,1.75) L32(-12.25,2.45) L34(-12.25,3.85) L35(-12.25,4.55) L37(-12.25,5.95) L38(-12.25,6.65) L40(-12.25,8.05) L41(-12.25,8.75) L43(-12.25,10.15) L44(-12.25,10.85) L46(-12.25,12.25) L47(-12.25,12.95) L48(-12.25,13.65) L49(-12.25,14.35) L50(-12.25,15.05) L51(-12.25,15.75) L52(-12.25,16.45) L53(-12.25,17.15) L54(-12.25,17.85) L55(-12.25,18.55) L56(-12.25,19.25) M1(-11.55,-19.25) M2(-11.55,-18.55) M4(-11.55,-17.15) M6(-11.55,-15.75) M8(-11.55,-14.35) M10(-11.55,-12.95) M47(-11.55,12.95) M49(-11.55,14.35) M51(-11.55,15.75) M53(-11.55,17.15) M55(-11.55,18.55) M56(-11.55,19.25) N1(-10.85,-19.25) N2(-10.85,-18.55) N3(-10.85,-17.85) N4(-10.85,-17.15) N5(-10.85,-16.45) N6(-10.85,-15.75) N7(-10.85,-15.05) N8(-10.85,-14.35) N9(-10.85,-13.65) N10(-10.85,-12.95) N11(-10.85,-12.25) N13(-10.85,-10.85) N14(-10.85,-10.15) N15(-10.85,-9.45) N16(-10.85,-8.75) N17(-10.85,-8.05) N18(-10.85,-7.35) N19(-10.85,-6.65) N20(-10.85,-5.95) N21(-10.85,-5.25) N22(-10.85,-4.55) N23(-10.85,-3.85) N24(-10.85,-3.15) N25(-10.85,-2.45) N26(-10.85,-1.75) N27(-10.85,-1.05) N28(-10.85,-0.35) N29(-10.85,0.35) N30(-10.85,1.05) N31(-10.85,1.75) N32(-10.85,2.45) N33(-10.85,3.15) N34(-10.85,3.85) N35(-10.85,4.55) N36(-10.85,5.25) N37(-10.85,5.95) N38(-10.85,6.65) N39(-10.85,7.35) N40(-10.85,8.05) N41(-10.85,8.75) N42(-10.85,9.45) N43(-10.85,10.15) N44(-10.85,10.85) N46(-10.85,12.25) N47(-10.85,12.95) N48(-10.85,13.65) N49(-10.85,14.35) N50(-10.85,15.05) N51(-10.85,15.75) N52(-10.85,16.45) N53(-10.85,17.15) N54(-10.85,17.85) N55(-10.85,18.55) N56(-10.85,19.25) P1(-10.15,-19.25) P2(-10.15,-18.55) P3(-10.15,-17.85) P4(-10.15,-17.15) P5(-10.15,-16.45) P6(-10.15,-15.75) P7(-10.15,-15.05) P8(-10.15,-14.35) P9(-10.15,-13.65) P10(-10.15,-12.95) P11(-10.15,-12.25) P13(-10.15,-10.85) P14(-10.15,-10.15) P15(-10.15,-9.45) P16(-10.15,-8.75) P17(-10.15,-8.05) P18(-10.15,-7.35) P19(-10.15,-6.65) P20(-10.15,-5.95) P21(-10.15,-5.25) P22(-10.15,-4.55) P23(-10.15,-3.85) P24(-10.15,-3.15) P25(-10.15,-2.45) P26(-10.15,-1.75) P27(-10.15,-1.05) P28(-10.15,-0.35) P29(-10.15,0.35) P30(-10.15,1.05) P31(-10.15,1.75) P32(-10.15,2.45) P33(-10.15,3.15) P34(-10.15,3.85) P35(-10.15,4.55) P36(-10.15,5.25) P37(-10.15,5.95) P38(-10.15,6.65) P39(-10.15,7.35) P40(-10.15,8.05) P41(-10.15,8.75) P42(-10.15,9.45) P43(-10.15,10.15) P44(-10.15,10.85) P46(-10.15,12.25) P47(-10.15,12.95) P48(-10.15,13.65) P49(-10.15,14.35) P50(-10.15,15.05) P51(-10.15,15.75) P52(-10.15,16.45) P53(-10.15,17.15) P54(-10.15,17.85) P55(-10.15,18.55) P56(-10.15,19.25) R1(-9.45,-19.25) R2(-9.45,-18.55) R4(-9.45,-17.15) R6(-9.45,-15.75) R8(-9.45,-14.35) R10(-9.45,-12.95) R13(-9.45,-10.85) R14(-9.45,-10.15) R15(-9.45,-9.45) R16(-9.45,-8.75) R17(-9.45,-8.05) R18(-9.45,-7.35) R19(-9.45,-6.65) R20(-9.45,-5.95) R21(-9.45,-5.25) R22(-9.45,-4.55) R23(-9.45,-3.85) R24(-9.45,-3.15) R25(-9.45,-2.45) R26(-9.45,-1.75) R27(-9.45,-1.05) R28(-9.45,-0.35) R29(-9.45,0.35) R30(-9.45,1.05) R31(-9.45,1.75) R32(-9.45,2.45) R33(-9.45,3.15) R34(-9.45,3.85) R35(-9.45,4.55) R36(-9.45,5.25) R37(-9.45,5.95) R38(-9.45,6.65) R39(-9.45,7.35) R40(-9.45,8.05) R41(-9.45,8.75) R42(-9.45,9.45) R43(-9.45,10.15) R44(-9.45,10.85) R47(-9.45,12.95) R49(-9.45,14.35) R51(-9.45,15.75) R53(-9.45,17.15) R55(-9.45,18.55) R56(-9.45,19.25) T1(-8.75,-19.25) T2(-8.75,-18.55) T3(-8.75,-17.85) T4(-8.75,-17.15) T5(-8.75,-16.45) T6(-8.75,-15.75) T7(-8.75,-15.05) T8(-8.75,-14.35) T9(-8.75,-13.65) T10(-8.75,-12.95) T11(-8.75,-12.25) T13(-8.75,-10.85) T14(-8.75,-10.15) T15(-8.75,-9.45) T16(-8.75,-8.75) T17(-8.75,-8.05) T18(-8.75,-7.35) T19(-8.75,-6.65) T20(-8.75,-5.95) T21(-8.75,-5.25) T22(-8.75,-4.55) T23(-8.75,-3.85) T24(-8.75,-3.15) T25(-8.75,-2.45) T26(-8.75,-1.75) T27(-8.75,-1.05) T28(-8.75,-0.35) T29(-8.75,0.35) T30(-8.75,1.05) T31(-8.75,1.75) T32(-8.75,2.45) T33(-8.75,3.15) T34(-8.75,3.85) T35(-8.75,4.55) T36(-8.75,5.25) T37(-8.75,5.95) T38(-8.75,6.65) T39(-8.75,7.35) T40(-8.75,8.05) T41(-8.75,8.75) T42(-8.75,9.45) T43(-8.75,10.15) T44(-8.75,10.85) T46(-8.75,12.25) T47(-8.75,12.95) T48(-8.75,13.65) T49(-8.75,14.35) T50(-8.75,15.05) T51(-8.75,15.75) T52(-8.75,16.45) T53(-8.75,17.15) T54(-8.75,17.85) T55(-8.75,18.55) T56(-8.75,19.25) U1(-8.05,-19.25) U2(-8.05,-18.55) U3(-8.05,-17.85) U4(-8.05,-17.15) U5(-8.05,-16.45) U6(-8.05,-15.75) U7(-8.05,-15.05) U8(-8.05,-14.35) U9(-8.05,-13.65) U10(-8.05,-12.95) U11(-8.05,-12.25) U13(-8.05,-10.85) U14(-8.05,-10.15) U15(-8.05,-9.45) U16(-8.05,-8.75) U17(-8.05,-8.05) U18(-8.05,-7.35) U19(-8.05,-6.65) U20(-8.05,-5.95) U21(-8.05,-5.25) U22(-8.05,-4.55) U23(-8.05,-3.85) U24(-8.05,-3.15) U25(-8.05,-2.45) U26(-8.05,-1.75) U27(-8.05,-1.05) U28(-8.05,-0.35) U29(-8.05,0.35) U30(-8.05,1.05) U31(-8.05,1.75) U32(-8.05,2.45) U33(-8.05,3.15) U34(-8.05,3.85) U35(-8.05,4.55) U36(-8.05,5.25) U37(-8.05,5.95) U38(-8.05,6.65) U39(-8.05,7.35) U40(-8.05,8.05) U41(-8.05,8.75) U42(-8.05,9.45) U43(-8.05,10.15) U44(-8.05,10.85) U46(-8.05,12.25) U47(-8.05,12.95) U48(-8.05,13.65) U49(-8.05,14.35) U50(-8.05,15.05) U51(-8.05,15.75) U52(-8.05,16.45) U53(-8.05,17.15) U54(-8.05,17.85) U55(-8.05,18.55) U56(-8.05,19.25) V1(-7.35,-19.25) V2(-7.35,-18.55) V4(-7.35,-17.15) V6(-7.35,-15.75) V8(-7.35,-14.35) V10(-7.35,-12.95) V13(-7.35,-10.85) V14(-7.35,-10.15) V15(-7.35,-9.45) V16(-7.35,-8.75) V17(-7.35,-8.05) V18(-7.35,-7.35) V19(-7.35,-6.65) V20(-7.35,-5.95) V21(-7.35,-5.25) V22(-7.35,-4.55) V23(-7.35,-3.85) V24(-7.35,-3.15) V25(-7.35,-2.45) V26(-7.35,-1.75) V27(-7.35,-1.05) V28(-7.35,-0.35) V29(-7.35,0.35) V30(-7.35,1.05) V31(-7.35,1.75) V32(-7.35,2.45) V33(-7.35,3.15) V34(-7.35,3.85) V35(-7.35,4.55) V36(-7.35,5.25) V37(-7.35,5.95) V38(-7.35,6.65) V39(-7.35,7.35) V40(-7.35,8.05) V41(-7.35,8.75) V42(-7.35,9.45) V43(-7.35,10.15) V44(-7.35,10.85) V47(-7.35,12.95) V49(-7.35,14.35) V51(-7.35,15.75) V53(-7.35,17.15) V55(-7.35,18.55) V56(-7.35,19.25) W1(-6.65,-19.25) W2(-6.65,-18.55) W3(-6.65,-17.85) W4(-6.65,-17.15) W5(-6.65,-16.45) W6(-6.65,-15.75) W7(-6.65,-15.05) W8(-6.65,-14.35) W9(-6.65,-13.65) W10(-6.65,-12.95) W11(-6.65,-12.25) W13(-6.65,-10.85) W14(-6.65,-10.15) W15(-6.65,-9.45) W16(-6.65,-8.75) W17(-6.65,-8.05) W18(-6.65,-7.35) W19(-6.65,-6.65) W20(-6.65,-5.95) W21(-6.65,-5.25) W22(-6.65,-4.55) W23(-6.65,-3.85) W24(-6.65,-3.15) W25(-6.65,-2.45) W26(-6.65,-1.75) W27(-6.65,-1.05) W28(-6.65,-0.35) W29(-6.65,0.35) W30(-6.65,1.05) W31(-6.65,1.75) W32(-6.65,2.45) W33(-6.65,3.15) W34(-6.65,3.85) W35(-6.65,4.55) W36(-6.65,5.25) W37(-6.65,5.95) W38(-6.65,6.65) W39(-6.65,7.35) W40(-6.65,8.05) W41(-6.65,8.75) W42(-6.65,9.45) W43(-6.65,10.15) W44(-6.65,10.85) W46(-6.65,12.25) W47(-6.65,12.95) W48(-6.65,13.65) W49(-6.65,14.35) W50(-6.65,15.05) W51(-6.65,15.75) W52(-6.65,16.45) W53(-6.65,17.15) W54(-6.65,17.85) W55(-6.65,18.55) W56(-6.65,19.25) Y1(-5.95,-19.25) Y2(-5.95,-18.55) Y3(-5.95,-17.85) Y4(-5.95,-17.15) Y5(-5.95,-16.45) Y6(-5.95,-15.75) Y7(-5.95,-15.05) Y8(-5.95,-14.35) Y9(-5.95,-13.65) Y10(-5.95,-12.95) Y11(-5.95,-12.25) Y13(-5.95,-10.85) Y14(-5.95,-10.15) Y15(-5.95,-9.45) Y16(-5.95,-8.75) Y17(-5.95,-8.05) Y18(-5.95,-7.35) Y19(-5.95,-6.65) Y20(-5.95,-5.95) Y21(-5.95,-5.25) Y22(-5.95,-4.55) Y23(-5.95,-3.85) Y24(-5.95,-3.15) Y25(-5.95,-2.45) Y26(-5.95,-1.75) Y27(-5.95,-1.05) Y28(-5.95,-0.35) Y29(-5.95,0.35) Y30(-5.95,1.05) Y31(-5.95,1.75) Y32(-5.95,2.45) Y33(-5.95,3.15) Y34(-5.95,3.85) Y35(-5.95,4.55) Y36(-5.95,5.25) Y37(-5.95,5.95) Y38(-5.95,6.65) Y39(-5.95,7.35) Y40(-5.95,8.05) Y41(-5.95,8.75) Y42(-5.95,9.45) Y43(-5.95,10.15) Y44(-5.95,10.85) Y46(-5.95,12.25) Y47(-5.95,12.95) Y48(-5.95,13.65) Y49(-5.95,14.35) Y50(-5.95,15.05) Y51(-5.95,15.75) Y52(-5.95,16.45) Y53(-5.95,17.15) Y54(-5.95,17.85) Y55(-5.95,18.55) Y56(-5.95,19.25)
