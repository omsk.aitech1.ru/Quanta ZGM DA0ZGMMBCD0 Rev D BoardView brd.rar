# Allegro board Quanta ZGM DA0ZGMMBCD0 Rev D BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N82538249: length 2.7
  TOP w0.14: U2.1 201.82,187.58 202.11,187.87 R70.2 202.75,188.48 v1(202.95,188.68)
N82555593: length 1
  TOP w0.14: v1(203.97,43.52) 204.22,43.78 204.85,43.78
N82846357: length 0.8
  TOP w0.14: 159.64,74 v1(159.64,73.24)
N82850179: length 5
  TOP w0.14: R420.2 317.96,70.24 318.03,70.3 v1(318.77,70.3)
  BOTTOM w0.14: CN10.35 316.7,69.41 317.29,70 318.47,70 318.77,70.3 v1(318.77,70.3)
N82850432: length 0.9
  TOP w0.14: v1(111.26,123.41) 111.51,123.15 112.02,123.15
N82853033:
  vias: v1(112.91,132.04)
N82853047: length 2.4
  BOTTOM w0.14: v1(114.56,136.36) 114.81,136.11 114.81,134.07
N82984178: length 2.4
  BOTTOM w0.14: U44.1 263.66,125.97 263.77,126.09 R813.2 263.77,127.07 263.89,127.19 263.89,127.56 R812.2
N82987111: length 5.1
  TOP w0.14: v1(279.44,74.09) 279.95,74.09 R381.1
  BOTTOM w0.14: v1(279.44,74.09) 277.77,74.09 276.62,75.24 CN12.58
N82987114: length 5.1
  TOP w0.14: R366.1 279.85,74.74 v1(279.45,74.74)
  BOTTOM w0.14: v1(279.45,74.74) 277.9,74.74 276.91,75.74 CN12.60
N82991704: length 2.2
  TOP w0.14: U23.3 167.06,70.5 166.54,69.98 166,69.98 R429.1
N83064721: length 3.2
  TOP w0.14: PC15.1 229.32,208.07 PR82.1 229.32,206.96 v1(228.97,206.6)
  BOTTOM w0.14: v1(228.97,206.6) 229.45,207.09 PR399.2
N83065191: length 3.6
  TOP w0.14: PR7.1 227.26,216.02 PR6.2 PR5.1 225.74,216.02 225.2,215.48 PR17.2 224.7,215.48 224.33,215.11 PC1.1
N83065260: length 4.1
  TOP w0.14: PR17.1 225.09,215.03 PR16.1 226.13,214.71 226.88,214.71 226.99,214.82 226.99,214.82 227.76,214.82 228.39,214.19 PU2.23
N83065359: length 4.4
  TOP w0.14: PU2.24 227.99,214.17 227.61,214.54 227.05,214.54 226.98,214.47 225.49,214.47 PR25.1 224.87,214.1 224.62,213.85 PR32.1
N83065483: length 2.5
  TOP w0.178: PU2.8 230.79,209.69 231.02,209.46 231.42,209.46 231.79,209.1 PR73.2
N83068063: length 1.4
  TOP w0.14: 224.54,204.05 v1(225.94,204.05)
N83068069: length 13.2
  TOP w0.14: PR26.2 222.5,213.87 222.38,213.75 222.03,213.75 221.47,213.19 221.47,210.63 221.92,210.17 221.92,206.69 v1(222.77,205.84) 223.65,204.97 PQ11.3
N83072148: length 3
  TOP w0.14: v1(32.52,53.43) 32.87,53.78 R609.1 ; R609.1 33.1,54.32 33.37,54.59 Q54.2 ; R609.1 R590.1
N83075521:
  vias: v1(285.88,119.41) v3(285.7,121.67) v3(285.7,120.88) v3(285.7,120.09) v3(286.49,121.67) v3(286.49,120.88) v3(286.49,120.09)
N83075806: length 1.9
  TOP w0.203: PR120.2 291.83,120.92 291.58,120.68 291.49,120.68 291.37,120.56 PR121.2 291.34,120.23 PR123.1
N83075884: length 3.2
  TOP w0.203: PR120.1 291.38,121.85 PC99.2 291.25,121.99 v1(290.81,121.99) 290.5,122.31 PU7.11
  BOTTOM w0.203: PR516.1 290.86,121.94 v1(290.81,121.99)
N83075891: length 2.8
  TOP w0.14: v1(292.74,120.36) 292.61,120.36 292.51,120.26 PR121.1
  TOP w0.203: PR121.1 291.82,120.41 292.17,120.76 292.17,121.42 291.83,121.76 PC99.1
N83076272: length 0.7
  TOP w0.203: PR123.2 291.34,118.69 v1(291.14,118.49)
  vias: v1(283.34,133.44) v3(283.81,132.09) v3(283.81,131.26) v3(284.97,133.04) v3(285.75,133.01) v3(286.54,133.01) v3(287.31,133.03)
N83080882: length 3.4
  TOP w0.14: PC96.1 289.99,125.11 290.07,125.18 290.07,125.95 v1(290.33,126.2)
  TOP w0.203: PU7.13 289.28,123.56 289.99,124.27 PC96.1
N83081355: length 1.9
  TOP w0.203: PU7.10 290.22,121.86 290.81,121.27 v1(290.81,120.63)
  vias: v1(289.73,121.01)
N83081712: length 6.8
  TOP w0.14: v1(291.84,123.57) 291.39,124.02 PR118.1
  TOP w0.203: v1(288.89,119.92) 288.83,119.98 PU7.7
  IN1 w0.203: v1(291.84,123.57) 291.84,122.37 289.39,119.92 v1(288.89,119.92)
N83083660: length 10
  TOP w0.203: PR124.2 v1(288.69,118.54) 288.19,118.54 287.99,118.74 287.99,119.62 287.93,119.68 PU7.5
  BOTTOM w0.203: v1(288.69,118.54) 288.57,118.54 287.96,119.15 v1(287.96,124.35)
  vias: v1(287.5,125.94) v3(288.68,126.79) v3(288.66,125.98) v3(288.7,125.18) v3(289.41,127.19) v3(289.41,126.4) v3(289.41,125.63)
N83085661:
  vias: v1(300.84,104.05) v3(300.41,105.68) v3(300.41,104.89) v3(301.2,105.68) v3(301.2,104.89)
N83085739: length 1.6
  TOP w0.203: PU8.13 v1(297.67,101.61)
  BOTTOM w0.254: v1(297.67,101.61) 297.68,101.63 PC402.1
N83085803: length 1.1
  BOTTOM w0.508: PR537.1 300.28,101.66 v3(299.8,102.15)
N83085805: length 1.3
  BOTTOM w0.508: PR537.2 299.67,100.01 299.44,99.78 PC409.1
N83085807: length 7.2
  TOP w0.203: v1(299.22,105.83) 299.22,105.62 299.02,105.43 PU8.5
  IN1 w0.508: v1(299.08,101.37) 299.08,102.97 299.22,103.1 v1(299.22,105.83)
  BOTTOM w0.203: PR517.2 299.3,105.75 v1(299.22,105.83)
  BOTTOM w0.508: PC409.2 v1(299.08,101.37)
N83085819:
  vias: v1(294.01,101.56) v3(294.34,100.93) v3(294.34,100.14) v3(294.34,99.35) v3(295.11,101.04)
N83085845: length 3.5
  TOP w0.203: PR128.2 295.88,104.75 v1(296.24,104.38) 296.24,104.27 296.51,104.01 PU8.10
  BOTTOM w0.14: PR531.1 295.71,105.19 v1(295.41,105.5)
  BOTTOM w0.203: PR531.1 296.01,104.61 v1(296.24,104.38)
N83085921: length 0.6
  BOTTOM w0.203: v1(294.21,103.54) 294.35,103.41 PR533.1
N83085945: length 1.4
  TOP w0.254: PU8.7 298.12,105.44 297.72,105.83 PR125.1
N83085968: length 17.9
  TOP w0.203: PR126.2 295.92,105.65 v1(296.45,105.12) 296.45,104.88 296.87,104.46 PU8.9
  IN2 w0.203: v1(305.12,98.32) 303.97,99.47 302.31,99.47 301.17,100.62 301.17,101.89 299.72,103.34 298.23,103.34 v1(296.45,105.12)
  BOTTOM w0.14: v1(296.55,106.39) 296.45,106.29 v1(296.45,105.12)
  BOTTOM w0.203: v1(305.12,98.32) 304.15,99.29 PQ72.2 ; v1(296.45,105.12) 296.75,104.81 PC397.2
N83085998: length 3.7
  TOP w0.254: PC121.2 296.03,102.62 PR129.1 295.66,102.99 PR532.1 295.94,103.96 296.34,103.56 PU8.11
N83090046: length 3.4
  TOP w0.14: R430.2 165.08,69.44 166.75,69.44 167.01,69.7 U23.5
N83090076: length 2
  TOP w0.14: R586.2 170.69,55.68 171.11,56.09 U23.37
N83090094: length 1.9
  TOP w0.14: U23.39 171.91,55.74 R587.2
N83090107: length 4.4
  TOP w0.14: U23.40 172.31,56.24 R583.2 R1190.2 172.85,54.74 173.23,54.36 173.71,54.36 173.95,54.6 R596.2
N83091465: length 27
  TOP w0.254: PR281.2 157.2,62.51 157.48,62.22 157.48,61.72 157.86,61.34 157.86,60.05 158.07,59.83 158.07,58.96 159.41,57.62 164.9,57.62 165.8,56.72 165.8,52.02 170.12,47.7 171.57,47.7 v1(172.14,47.13)
  BOTTOM w0.14: PR633.1 172.35,46.92 v1(172.14,47.13)
N83092641: length 3.9
  BOTTOM w0.508: v3(70.84,52.85) v1(69.57,52.85) 68.1,52.85 67.41,52.16 v3(67.41,51.93)
N83092840: length 2.6
  TOP w0.203: PU17.4 68.9,52.33 PC225.2 PR305.1
N83092971: length 1.2
  TOP w0.203: PC217.1 68.5,56.06 PU17.12
N83092973: length 1.3
  TOP w0.203: PC218.1 69.51,55.86 69.3,55.66 PU17.10
N83178683: length 2
  TOP w0.14: PU2.18 230.39,214.24 230.8,214.65 231.41,214.65 231.57,214.81 PR18.2
N83179815:
  vias: v1(284.7,123.7)
N83250563: length 4.4
  TOP w0.14: v1(208.11,76.39) 208.11,74.95 208.75,74.31 209.51,74.31 TP50.1
  BOTTOM w0.102: v1(208.11,76.39) 208.36,76.14 U49.T8
N83250570: length 2.2
  TOP w0.14: TP46.1 207.67,77.2 v1(207.45,77.43)
  BOTTOM w0.102: v1(207.45,77.43) 207.78,77.1 208.37,77.1 U49.T7
N83308892: length 7.9
  BOTTOM w0.079: U42.B3 175.66,129.84 176.17,129.33 176.61,129.33 177.07,128.87 177.07,127.5 178.59,125.97 178.59,125.59
  BOTTOM w0.14: 178.59,125.59 178.59,124.27 TP115.1
N83308905: length 7.3
  BOTTOM w0.079: 179.2,125.59 179.2,126.1 177.22,128.08 177.22,128.93 176.67,129.48 176.23,129.48 175.99,129.73 175.99,130.18 U42.B4
  BOTTOM w0.14: TP113.1 179.2,125.59
N83308928: length 15.1
  TOP w0.102: 176.99,149.35 173.66,149.35 v1(173.28,148.96)
  TOP w0.14: 176.99,149.35 180.69,149.35 182.15,147.89 182.15,146.29 182.58,145.86 184.2,145.86 184.56,146.22 TP13.1
  BOTTOM w0.102: U42.E34 173.66,149.5 173.28,149.12 v1(173.28,148.96)
N83379619:
  vias: v1(193.01,165.58)
N83379972:
  vias: v1(190.94,165.55)
N83382742: length 5.5
  BOTTOM w0.102: 124.03,130.7 124.26,130.47 126.56,130.47 127.08,130.99 128.38,130.99 U42.CR4
  BOTTOM w0.14: TP110.1 124.03,130.7
N83382743: length 6.3
  BOTTOM w0.079: U42.CP4 129.11,130.23 129.11,128.05
  BOTTOM w0.102: 129.11,125.59 129.11,128.05
  BOTTOM w0.14: 129.11,125.59 129.11,125.25 TP114.1
N83382768: length 2.8
  TOP w0.14: TP65.1 214.86,63.59 215.09,63.36 215.09,62.56 v1(215.55,62.1)
  BOTTOM w0.102: U49.AK37 215.57,62.1 v1(215.55,62.1)
N83382769: length 2.7
  TOP w0.14: v1(214.69,62.09) 214.13,62.65 214.13,63.27 213.66,63.73 TP67.1
  BOTTOM w0.102: v1(214.69,62.09) 214.72,62.09 U49.AH37
N83385689: length 1.4
  TOP w0.14: v1(211.12,63.7) 210.91,63.91 TP66.1
  BOTTOM w0.102: U49.Y33 210.68,63.26 v1(211.12,63.7)
N83442053: length 2.1
  TOP w0.14: TP2.1 148.96,208.55 148.2,207.79 U1.2
N83449779: length 2
  TOP w0.14: v1(208.77,60.19) 208.65,60.3 TPS3.1
  BOTTOM w0.102: v1(208.77,60.19) 208.9,60.32 U49.V39
N83519107: length 2.2
  TOP w0.14: v1(221.31,61.51) 221.69,61.51 221.75,61.46 222.77,61.46 TP73.1
  BOTTOM w0.102: U49.BA36 221.69,61.88 v1(221.31,61.51)
N84112149: length 3.6
  BOTTOM w0.254: LED7.2 246.62,218.65 245.95,217.98 245.95,216.51 R685.1
N84112155: length 1.7
  BOTTOM w0.254: R679.2 248.47,217.8 LED7.3
N84112164: length 4.4
  TOP w0.254: R14.2 245.43,217.01 v2(245.32,217.13)
  BOTTOM w0.254: v2(245.32,217.13) 245.56,217.37 245.56,218.15 246.91,219.5 LED7.1
N84112222: length 2.5
  TOP w0.508: Q5.3 248.68,214.67 247.37,214.67 247.17,214.87 v1(247.17,215.33)
  vias: v1(244.63,216.46)
N84113271: length 10.8
  TOP w0.254: v1(151,216.94) 148.83,219.11 v1(146.39,219.11)
  BOTTOM w0.254: v1(151,216.94) 150.9,216.94 148.31,214.35 R697.1 ; LED2.3 146.77,219.5 v1(146.39,219.11)
N84114122: length 1.9
  TOP w0.508: R322.2 302.01,78.87 Q34.6
N84117833: length 3.3
  TOP w0.14: U27.16 38.23,60.77 38.51,61.05 38.51,62.07 37.98,62.6 TP69.1
N84117877: length 3
  TOP w0.14: TP79.1 38.46,54.32 38.46,55.41 37.73,56.14 U27.22
N84357192: length 1.3
  TOP w0.14: v1(221.31,58.97) 221.71,59.37 R551.2
  BOTTOM w0.102: U49.AY42 v1(221.31,58.97)
N84561731: length 7.3
  BOTTOM w0.14: v1(167.52,161.38) 167.52,161.39 UG5.1 168.9,161.39 169.32,160.97 172.48,160.97 172.62,160.83 173.92,160.83 UG4.4
N84562167: length 1.8
  TOP w0.14: R588.2 171.46,55.84 171.51,55.89 U23.38
N84718764: length 2.1
  TOP w0.14: R669.2 16.62,13.65 v1(16.68,13.59)
  BOTTOM w0.14: v1(16.68,13.59) 16.64,13.59 16.57,13.66 CN24.6
N84917166: length 3.9
  BOTTOM w0.508: v1(54.13,70.28) 54.54,70.69 57.09,70.69 v1(57.64,70.14)
N84917339: length 3.4
  TOP w0.203: v1(55.86,70.04) 55.9,70.09 PU13.4
  BOTTOM w0.14: PR613.2 56.81,68.5 v1(56.9,68.42)
  BOTTOM w0.254: v1(55.86,70.04) PC482.1 56.36,69.39 56.36,69.38 PR613.2
N84917398: length 1.3
  TOP w0.14: PU13.12 55.5,73.45 55.63,73.58 PC172.1
N84917400: length 1.3
  TOP w0.14: PC173.1 56.3,73.94 PU13.10
N85188370:
  vias: v1(283.1,205.12)
N86880418: length 1.5
  BOTTOM w0.508: Q104.1 297.8,90.28 297.83,90.25 R855.1
N87340512: length 1.3
  BOTTOM w0.178: PU19.5 247.93,212.56 247.75,212.74
  BOTTOM w0.203: 247.75,212.74 PR379.1
N87722142: length 3.7
  BOTTOM w0.14: U37.15 262.93,212.88 263.25,213.2 263.25,214.21 263.01,214.45 R693.1
N87723974: length 6.6
  BOTTOM w0.14: TP84.1 264.6,216.07 264.6,214.33 264.2,213.93 264.2,213.76 262.69,212.24 U37.14
N87723989: length 8
  BOTTOM w0.14: TP85.1 266.49,216.02 265.48,216.02 264.88,215.42 264.88,214.22 264.48,213.82 264.48,213.64 262.45,211.61 U37.13
N87724004: length 5.8
  BOTTOM w0.14: U37.12 262.21,210.97 264.76,213.52 264.76,213.7 265.43,214.38 TP86.1
N88138320: length 9.5
  TOP w0.14: PR14.1 250.34,214.92 251.02,214.24 251.02,212.89 251.12,212.79 PC6.1 251.12,211.94 251.02,211.84 250.84,211.84 250.7,211.98 250.7,212.64 250.55,212.79 250.55,213.76 250.33,213.97 248.66,213.97 v1(248.48,213.79)
  BOTTOM w0.178: PU19.6 249.02,213.62 248.84,213.79 v1(248.48,213.79)
N88138401: length 3
  TOP w0.14: PR14.2 249.89,215.87 v1(250.24,216.22)
  BOTTOM w0.203: v1(250.24,216.22) 250.02,215.99 250.02,215.62 249.66,215.26 PR366.1 249.66,214.97 249.36,214.67 PR369.1
N88264121: length 1.7
  BOTTOM w0.14: TP156.1 278.39,55 U50.C3
N88389596: length 2.1
  TOP w0.14: R15.1 271.69,216.02 271.66,215.99 QG1.3 270.84,215.99 270.72,215.86 270.72,215.63 270.86,215.49 QG1.2
N88395011: length 4.7
  BOTTOM w0.14: U39.4 275.34,201.18 275.01,200.85 274.4,200.85 274.15,200.6 U40.1 274.15,199.4 v1(275.09,198.46)
N88516223: length 5.2
  BOTTOM w0.14: R826.2 303.79,96.86 303.78,96.86 R824.2 302.07,96.86 301.91,97.02 R828.2 301.61,97.38 301.56,97.33 Q102.3 300.31,97.33 v1(299.72,96.74)
N89714009: length 2.7
  TOP w0.14: PU16.5 261.26,58.75 260.56,58.75 v1(260.53,58.78) 260.29,59.02 PR668.2 260.29,59.7 260.1,59.89 259.9,59.98 259.86,60.02 PR667.2
N89714060: length 2.3
  TOP w0.254: PU16.4 262.3,58.82 v1(261.39,59.73)
  BOTTOM w0.203: PR619.2 261.55,59.88 v1(261.39,59.73)
N90053363: length 5
  TOP w0.14: v1(199.12,73.57) 199.12,73.84 198.98,73.98 C872.1
  BOTTOM w0.102: v1(199.12,73.57) 199.14,73.55 199.14,73.12 199.79,72.46 201.59,72.46 U49.C14
N90053364: length 1.4
  TOP w0.14: v1(203.32,73.04) 202.95,73.42 C871.1
  BOTTOM w0.102: U49.D14 203.25,73.09 203.3,73.04 v1(203.32,73.04)
N90053389: length 7.7
  TOP w0.14: TP178.1 198.72,78.67 199.37,78.02 200.08,78.02 202.73,75.36 v1(203.19,75.36)
  BOTTOM w0.102: v1(203.19,75.36) 203.2,75.36 203.2,75.36 203.19,75.36 202.85,75.03 202.68,75.03 202.3,74.65 U49.C11
N90053390: length 7.7
  TOP w0.14: v1(203.83,75.11) 203.49,74.77 202.82,74.77 200.03,77.56 199.14,77.56 TP179.1
  BOTTOM w0.102: U49.D11 203.05,74.78 203.21,74.95 203.67,74.95 v1(203.83,75.11)
N90053415: length 5.2
  TOP w0.14: TP180.1 199.16,76.14 200.91,76.14 C871.2
N90053416: length 0.9
  TOP w0.14: C872.2 198.56,75.08 TP181.1
N90112976: length 19.9
  BOTTOM w0.14: PQ73.2 301.45,106.63 301.91,106.17 301.91,104.91 303.08,103.74 303.08,102.75 303.21,102.63 PQ72.3 303.21,100.56 302.69,100.05 301.77,100.05 v1(301.5,99.78) 300.99,99.28 299.73,99.28 299.41,98.96 299.41,97.24 297.89,95.72 297.44,95.72 297.21,95.49 PR669.2 296.69,95.04 296.55,95.18 296.55,95.7 296,96.24 PR671.1
N90112978: length 10.5
  TOP w0.203: PR670.2 294.34,107.68 294.01,107.35 294.01,105.45 v1(294.24,105.22)
  BOTTOM w0.14: PQ73.3 297.55,108.63 297.23,108.32 295.81,108.32 v1(295.34,107.85) 294.24,106.74 v1(294.24,105.22)
N90352201: length 1
  TOP w0.14: 62.49,67.4 v1(62.49,68.42)
N90352464: length 3
  BOTTOM w0.14: v1(151.77,165.57) 151.91,165.43 R1198.1 152.51,165.81 152.53,165.83 R1199.2 152.53,166.56 152.95,166.98 Q118.2
N90352782: length 4.3
  BOTTOM w0.14: Q121.2 158.66,167.4 157.94,168.12 R1197.2 157.26,168.12 157.03,168.35 v1(156.24,168.35) Q118.3
N90353103: length 11
  BOTTOM w0.14: R1200.2 162.2,167.1 162.37,167.27 Q122.2 165.46,167.27 v1(165.48,167.25) 165.74,167.51 165.74,167.72 166.29,168.27 167.69,168.27 168.08,167.88 168.99,167.88 169.12,168.01 171.04,168.01 171.42,168.39 Q119.3
N90353130: length 5.1
  BOTTOM w0.14: R1202.1 169.25,165.86 168.81,166.3 R1201.2 v1(167.64,166.3) 167.55,166.4 167.55,166.91 167.98,167.34 168.92,167.34 169.03,167.44 Q119.2
N90353305: length 13.5
  IN2 w0.089: v1(167.46,167.76) 168.37,168.67 171.77,168.67 172.41,168.03 172.41,165.26 v1(171.68,164.53)
  BOTTOM w0.14: R1203.2 172.21,163.48 172.46,163.73 Q120.3 172.02,164.86 v1(171.68,164.53) ; v1(167.46,167.76) 167.13,167.43 Q123.2
N90353332: length 2.9
  BOTTOM w0.14: R1205.1 168.8,164.84 169.23,165.27 R1204.2 169.65,165.27 170.46,164.46 Q120.2
N90355820: length 11.9
  TOP w0.14: R1210.2 191.98,53.15 v1(191.13,52.3) 190.12,51.29 190.12,49.75 190.32,49.54 191.03,49.54 191.19,49.7 191.67,49.7 193.31,51.35 R1209.1 193.94,51.66 194.19,51.91 Q124.3 195.46,51.28 R1192.1
N91210140: length 3.8
  TOP w0.356: 165.85,199.23 165.93,199.42 Q126.3
  TOP w0.508: R1212.2 167.54,198.87 167.14,198.46 v1(166.88,198.46) 166.35,198.46 165.85,198.96 165.85,199.23
N91210142: length 4.3
  TOP w0.356: 166.66,200.84 164.88,200.84 164.63,201.1 Q126.6
  TOP w0.508: R1213.2 v1(167.01,200.5) 166.66,200.84
N91210144: length 2.1
  TOP w0.508: R1214.2 249.7,209.38 249.44,209.12 Q127.3
N850938110: length 5.6
  BOTTOM w0.508: R763.1 186.43,161.8 186.85,161.38 v1(187.59,161.38) 188.27,161.38 189.48,162.59 Q94.1
N852060628: length 1.5
  BOTTOM w0.14: U51.C3 284.4,54.56 284.42,54.55 TP157.1
N852184901: length 1.5
  BOTTOM w0.14: v1(204.47,180.3) 204.97,180.8 R746.2
N914122781: length 1.4
  BOTTOM w0.203: PC396.2 298.41,104.17 298.9,103.68 PR517.1
N914244551: length 2.3
  TOP w0.14: PR124.1 v1(288.69,115.42)
  TOP w0.508: PR124.1 289.44,116.41 289.57,116.54 PC102.2
N9142277211: length 2.1
  TOP w0.203: PU2.31 227.07,210.98 226.24,210.14 TP1.1

## Copper pours and planes (outline as drawn)
+0.85V_VCCLDOSTD on BOTTOM (solid shape): 227.79,79.17 227.79,78.54 227.75,78.5 227.27,78.5 226.74,77.97 224.56,77.97 224.36,77.76 223.98,77.76 223.56,78.18 223.56,78.41 223.59,78.44 223.95,78.44 224.18,78.66 226.55,78.66 227.08,79.19 227.76,79.19
+1.2V_U3 on TOP (solid shape): 15.75,68.26 15.75,68.03 16.11,67.67 16.78,67.67 17.5,66.95 17.5,66.1 17.47,66.08 16.57,66.08 15.22,67.43 14.71,67.43 14.63,67.5 14.63,68.34 14.74,68.44 15.57,68.44
+1.2V_U3 on BOTTOM (solid shape): 22.91,65.76 22.91,61.86 22.86,61.79 22.76,61.65 22.67,61.51 22.58,61.37 22.5,61.22 22.43,61.07 22.39,60.99 18.06,60.99 17.57,61.47 15.98,61.47 15.77,61.69 15.77,62.41 15.93,62.58 17.35,62.58 17.73,62.2 18.44,62.2 18.56,62.08 20.74,62.08 20.98,62.32 20.98,63.64 21.67,63.64 21.67,63.59 21.68,63.53 21.7,63.48 21.72,63.43 21.75,63.38 21.79,63.34 21.83,63.3 21.88,63.27 21.93,63.24 21.98,63.23 22.04,63.22 22.1,63.22 22.15,63.23 22.21,63.24 22.26,63.27 22.3,63.3 22.35,63.34 22.38,63.38 22.41,63.43 22.44,63.48 22.45,63.53 22.46,63.59 22.46,63.64 22.45,63.7 22.44,63.75 22.41,63.8 22.38,63.85 22.35,63.89 22.3,63.93 22.26,63.96 22.21,63.98 22.15,64 22.1,64.01 22.04,64.01 21.98,64 21.93,63.98 21.88,63.96 21.83,63.93 21.79,63.89 21.75,63.85 21.72,63.8 21.7,63.75 21.68,63.7 21.67,63.64 20.98,63.64 20.98,65.03 21.8,65.85 22.82,65.85
+1.2VSUS on TOP (solid shape): 14.1,69.71 14.1,69.29 14.08,69.21 14.08,69.13 14.08,69.06 14.1,68.98 14.1,68.9 14.16,68.84 14.2,68.78 14.24,68.73 14.25,68.72 14.25,68.7 14.25,67.58 14.07,67.4 13.21,67.4 12.92,67.69 12.92,69.67 13.29,70.04 13.77,70.04
+1.2VSUS on TOP (solid shape): outline of 33120 points within 113.41,52.85 188.45,142.19
+1.2VSUS on BOTTOM (solid shape): 198.05,101.61 198.05,99.3 197.92,99.18 196.27,99.18 196.14,99.31 196.14,101.46 196.47,101.79 197.87,101.79
+1.2VSUS on BOTTOM (solid shape): 210.7,50.76 210.7,50.33 210.9,50.12 211.3,50.12 211.31,50.13 211.49,50.13 211.68,49.94 211.68,49.6 211.55,49.46 211.11,49.46 210.66,49.92 210.66,49.96 210.41,50.21 210.41,50.81 210.43,50.83 210.63,50.83
+1.2VSUS on BOTTOM (solid shape): 135.46,54.22 135.46,53.91 135.07,53.52 135.07,53.1 134.64,52.67 132.03,52.67 131.68,52.31 128.43,52.31 127.83,52.91 126.26,52.91 126.22,52.91 124.58,52.91 124.5,52.99 124.5,54.26 124.61,54.37 135.31,54.37
+1.2VSUS on BOTTOM (solid shape): 314.63,100.86 314.63,100.08 314.61,100.06 312.75,100.06 312.65,100.17 311.74,100.17 311.58,100.01 310.98,100.01 310.67,99.71 310.67,99.48 310.47,99.28 309.98,99.28 309.86,99.4 306.78,99.4 306.53,99.15 304.7,99.15 304.42,99.43 304.42,99.77 304.6,99.95 310.15,99.95 310.71,100.51 311.17,100.51 311.54,100.89 311.63,100.93 314.56,100.93
+1.2VSUS on BOTTOM (solid shape): 152.59,135.36 152.59,135.33 152.69,135.23 152.69,135.1 152.57,134.98 152.57,134.7 152.84,134.43 153,134.43 153.15,134.28 153.15,134.1 153.02,133.97 152.8,133.97 152.44,134.33 152.44,134.37 152.27,134.55 152.01,134.55 151.83,134.36 151.67,134.36 151.59,134.44 151.59,134.56 151.72,134.7 151.72,134.98 151.52,135.19 151.24,135.19 151.06,135 150.29,135 150.11,135.18 149.82,135.18 149.65,135.01 149.52,135.01 149.34,135.18 149.06,135.18 148.88,135 148.74,135 148.57,135.18 148.3,135.18 148.03,134.91 147.36,134.91 147.03,134.58 146.92,134.58 146.69,134.36 146.56,134.36 146.39,134.53 146.1,134.53 145.92,134.36 145.8,134.36 145.7,134.46 145.7,134.57 145.7,134.59 145.71,134.61 145.74,134.64 145.76,134.67 146.56,135.47 146.65,135.47 146.92,135.74 147.07,135.74 147.27,135.93 147.31,135.96 147.33,135.97 147.49,135.97 147.9,135.56 148.16,135.56 148.33,135.72 148.53,135.72 148.7,135.55 148.93,135.55 149.08,135.7 149.08,135.79 149.28,135.98 149.64,135.98 149.89,135.74 150.05,135.74 150.24,135.54 151.1,135.54 151.35,135.79 151.51,135.79 151.71,135.99 151.97,135.99
+1.2VSUS on BOTTOM (solid shape): 154,136.54 154.08,136.49 154.09,136.4 154.08,136.34 154.07,136.28 154.12,136.1 154.26,135.98 154.26,135.98 154.46,135.78 154.47,135.76 154.55,135.62 154.72,135.56 154.9,135.63 154.97,135.81 154.91,135.98 154.77,136.06 154.75,136.07 154.71,136.11 154.7,136.14 154.73,136.22 154.73,136.28 154.73,136.34 154.71,136.4 154.72,136.49 154.8,136.54 156.41,136.54 156.49,136.5 156.5,136.41 156.49,136.36 156.49,136.31 156.58,136.07 156.82,135.97 156.87,135.97 156.91,135.93 156.91,135.9 156.9,135.85 156.9,135.81 157.15,135.56 157.41,135.81 157.39,135.89 157.36,135.97 157.36,136.06 157.16,136.25 157.15,136.27 157.14,136.36 157.13,136.41 157.15,136.5 157.23,136.54 159.18,136.54 159.31,136.41 159.31,135.43 158.77,134.89 156.3,134.89 156.01,135.18 155.72,135.18 155.51,134.97 154.69,134.97 154.47,135.19 154.2,135.19 153.99,134.98 153.69,134.98 153.59,135.09 153.59,135.9 153.38,136.1 153.38,136.34 153.58,136.54
+1.2VSUS on IN1 (solid shape): 14.13,70.65 14.13,68.7 13.82,68.39 12.94,68.39 12.74,68.59 12.74,70.59 13.01,70.85 13.92,70.85
+1.2VSUS on IN1 (solid shape): 105.51,76.44 105.51,75.5 105.34,75.32 104.83,75.32 104.82,75.34 104.79,75.34 104.78,75.34 104.54,75.43 104.29,75.45 104.26,75.46 103.25,76.47 103.25,77.18 103.41,77.33 104.63,77.33
+1.2VSUS on IN1 (solid shape): outline of 275 points within 25.58,75.25 31.8,78.02
+1.2VSUS on IN2 (solid shape): 197.26,101.36 197.26,99.99 196.8,99.53 195.53,99.53 191.82,103.24 191.8,103.24 189.89,105.14 187.73,105.14 187.28,105.6 187.28,107.38 187.68,107.79 190.83,107.79
+1.2VSUS on IN2 (solid shape): outline of 18003 points within 120.78,82.54 184.64,105.42
+1.2VSUS on IN3 (solid shape): outline of 34433 points within 118.44,82.34 184.74,136.62
+1.2VSUS on IN4 (solid shape): 106.34,75.51 107.09,75.51 107.36,75.23 107.36,74.23 106.98,73.85 106.23,73.85 105.3,74.77 105.3,74.93 104.75,75.48 104.19,75.48 104.07,75.6 104.07,75.86 104.27,76.06 105.79,76.06
+1.2VSUS on IN4 (solid shape): 118.95,74.03 118.95,73.62 118.8,73.48 118.78,73.46 118.76,73.46 118.72,73.47 118.69,73.47 118.6,73.46 118.52,73.43 118.51,73.42 118.42,73.42 118.01,73.01 116.64,73.01 116.41,73.24 116.41,73.75 116.64,73.98 117.68,73.98 117.86,74.16 118.82,74.16
+1.2VSUS_TEMP on TOP (solid shape): 134.68,49.71 135.51,49.71 135.89,49.33 135.89,46.37 135.84,46.32 130.86,46.32 130.76,46.42 130.76,47.97 129.95,48.78 126.7,48.78 126.69,48.79 126.18,48.79 125.99,48.98 125.99,51.8 126.24,52.06 132.33,52.06
+1.2VSUS_TEMP on BOTTOM (solid shape): 127.67,52.74 127.74,52.74 127.79,52.7 127.79,52.08 128.07,51.8 132.01,51.8 132.18,51.98 132.18,52.24 132.24,52.29 133.48,52.29 133.57,52.2 133.57,50.58 133.86,50.29 133.86,49.72 133.91,49.67 134.17,49.67 134.21,49.66 134.24,49.66 134.52,49.66 134.55,49.66 134.58,49.67 135.3,49.67 135.48,49.49 135.48,49.14 135.48,49.13 135.48,48.58 135.47,48.54 135.44,48.51 135.4,48.46 135.4,48.41 135.38,48.39 135.38,47.97 135.43,47.92 135.43,47.71 135.41,47.65 135.4,47.6 135.4,47.32 135.41,47.26 135.43,47.2 135.43,47.07 135.4,47.04 135.4,46.93 135.4,46.9 135.4,46.62 135.4,46.59 135.4,46.53 135.41,46.52 135.31,46.41 130.86,46.41 130.76,46.52 130.76,47.49 130.64,47.61 126.77,47.61 126.55,47.84 126.55,51.8 126.6,51.86 127.08,51.86 127.21,51.98 127.21,52.23 127.26,52.27 127.27,52.33 127.27,52.71 127.27,52.74 127.66,52.74
+1.2VSUS_VIN on TOP (solid shape): outline of 147 points within 120.15,38.93 126.42,44.92
+1.2VSUS_VIN on BOTTOM (solid shape): 122.13,44.54 125.99,44.54 126.08,44.46 126.08,43.45 125.96,43.33 125.37,43.33 125.29,43.25 125.23,43.24 124.56,43.24 124.51,43.19 124.51,42.46 124.87,42.1 126.67,42.1 126.85,41.92 126.85,41.24 127.36,40.73 127.82,40.73 128.02,40.53 128.02,38.94 127.98,38.89 126.07,38.89 125.94,39.03 125.94,40.65 125.8,40.78 122.38,40.78 122.25,40.91 121.21,40.91 120.73,41.39 120.48,41.39 120.37,41.49 120.37,41.77 121.16,42.56 121.16,44.34 121.17,44.34 121.17,44.49 121.23,44.55 122.12,44.55
+1.05V_PWRGD_G1 on TOP (solid shape): 155.71,74.05 155.71,71.67 155.69,71.66 155.08,71.66 155.05,71.69 155.05,72.36 154.75,72.66 153.25,72.66 153.11,72.79 153.11,74.13 153.22,74.24 153.25,74.25 153.27,74.25 153.37,74.23 153.47,74.22 153.58,74.23 153.7,74.27 155.49,74.27
+1.05V_PWRGD_G2 on TOP (solid shape): 153.99,72.37 154.54,72.37 154.78,72.13 154.78,70.93 155.3,70.41 155.3,69.27 155.21,69.18 153.31,69.18 153.16,69.33 153.16,70.74 153.16,70.75 153.19,70.84 153.2,70.93 153.2,71.13 153.09,71.41 152.81,71.52 152.65,71.49 152.52,71.39 152.49,71.38 152.42,71.38 151.74,72.06 151.17,72.06 151.09,72.15 151.09,72.3 151.16,72.38 153.99,72.38
+1.8V on TOP (solid shape): 158.02,75.89 158.02,74.04 157.93,73.95 157.26,73.95 157.26,73.96 156.79,73.96 156.77,73.98 156.77,74.24 156.8,74.26 157.26,74.26 157.26,74.26 157.43,74.26 157.57,74.4 157.57,75.24 157.15,75.65 157.15,75.91 157.33,76.09 157.82,76.09
+1.8V on TOP (solid shape): 300.67,63.44 300.71,63.42 300.72,63.39 300.72,62.43 300.73,62.41 300.74,62.38 300.72,62.35 300.7,62.33 300.7,62.3 300.69,62.29 300.69,61.34 300.66,61.31 300.66,61.08 300.65,61.07 300.63,61.01 300.62,60.95 300.62,59.77 300.63,59.76 300.63,59.57 300.64,59.5 300.68,59.43 300.69,59.42 300.69,59.32 300.6,59.23 299,59.23 298.96,59.27 298.96,59.67 298.98,59.7 299.01,59.72 299.6,59.72 299.81,59.93 299.81,60.53 300.22,60.94 300.22,61.25 300.49,61.51 300.49,62.4 300.52,62.43 300.52,62.43 300.52,63.39 300.54,63.42 300.57,63.44
+1.8V on TOP (solid shape): 236.44,115.7 236.42,115.65 236.41,115.65 236.35,115.53 236.33,115.41 236.33,115.4 236.45,115.13 236.73,115.01 237.25,115.02 237.65,114.62 237.65,113.91 237.77,113.78 238.74,113.78 239.45,113.07 239.45,112.76 239.58,112.64 240.54,112.64 240.65,112.74 240.69,112.74 241.07,112.74 241.12,112.75 241.17,112.78 241.18,112.79 241.38,112.79 241.96,112.21 241.96,111.82 241.94,111.8 239.37,111.8 238.79,112.38 238.79,112.69 238.28,113.2 236.6,113.2 236.35,112.94 235.69,112.94 235.61,113.02 235.61,113.25 235.69,113.32 236.15,113.32 236.3,113.48 236.3,114.47 235.97,114.79 235.97,114.94 235.93,115.04 235.83,115.08 235.69,115.08 235.5,115.27 235.5,115.67 235.66,115.84 236.3,115.84
+1.8V on TOP (solid shape): outline of 711 points within 251.84,41.54 266.68,65.77
+1.8V on BOTTOM (solid shape): 316.28,60.59 316.28,59.4 316.16,59.27 314.99,59.27 314.82,59.44 314.81,59.47 314.82,59.5 314.87,59.61 314.88,59.72 314.85,59.87 314.77,59.99 314.77,60.76 314.86,60.85 316.03,60.85
+1.8V on IN2 (solid shape): 316.61,59.73 316.61,59.25 316.6,59.23 314.75,59.23 314.73,59.25 314.73,59.37 315.27,59.91 316.44,59.91
+1.8V on IN2 (solid shape): outline of 528 points within 259.61,39.16 300.56,68.61
+1.8V on IN3 (solid shape): 316.61,59.73 316.61,59.25 316.6,59.23 314.75,59.23 314.73,59.25 314.73,59.37 315.27,59.91 316.44,59.91
+1.8V_5G on TOP (solid shape): 300.81,85.15 300.81,84.39 301.15,84.05 301.15,83.51 301.06,83.43 300.25,83.43 300.17,83.51 300.17,84.55 299.49,85.23 299.49,85.23 299.1,85.63 299.1,85.97 299.38,86.25 299.71,86.25
+1.8V_5G on TOP (solid shape): 314.2,85.28 314.2,84.93 314.04,84.76 314.04,83.82 313.78,83.56 313.78,83.51 313.72,83.45 313.46,83.45 313.42,83.49 313.42,84.02 313.36,84.07 313.36,85.21 313.54,85.38 314.1,85.38
+1.8V_5G on TOP (solid shape): 281.34,58.4 282.66,58.4 282.74,58.32 283.06,58.32 283.19,58.32 284.33,57.19 287.81,57.19 287.94,57.12 288.09,57.09 288.24,57.12 288.37,57.19 288.39,57.19 288.62,56.96 288.62,56.28 288.41,56.07 287.99,56.07 287.89,56.17 286.41,56.17 286.39,56.15 284.2,56.15 282.77,57.58 281.12,57.58 280.35,58.36 279.81,58.36 279.78,58.36 279.76,58.38 279.76,59.01 279.78,59.05 279.81,59.06 280.67,59.06
+1.8V_5G on BOTTOM (solid shape): 298.86,87.99 298.92,87.99 298.92,87.28 299.71,86.49 299.71,85.76 299.61,85.65 299.19,85.65 299.09,85.75 299.09,86.28 298.83,86.53 298.45,86.53 298.35,86.63 298.35,86.95 297.41,87.88 297.41,88.57 297.48,88.63 298.22,88.63
+1.8V_5G on IN2 (solid shape): outline of 257 points within 308.36,77.99 314.07,84.69
+1.8V_AON on TOP (solid shape): 200.78,148.62 200.78,148.4 201.12,148.06 201.12,147.48 201.12,147.47 200.9,147.47 200.88,147.49 200.88,148.03 200.66,148.26 200.42,148.26 200.27,148.41 200.27,148.69 200.38,148.8 200.6,148.8
+1.8V_AON on TOP (solid shape): 274.89,162.24 274.89,162.01 274.77,161.89 274.58,161.89 274.38,161.69 274.38,161.57 274.39,161.56 274.39,161.34 274.2,161.14 273.55,161.14 273.53,161.16 273.53,162.13 273.78,162.38 274.76,162.38
+1.8V_AON on TOP (solid shape): 287.63,137.2 287.63,135.42 287.33,135.12 283.8,135.12 283.52,134.84 283.21,134.84 282.95,135.1 282.95,135.41 282.93,135.42 282.93,137.28 283.16,137.5 287.33,137.5
+1.8V_AON on TOP (solid shape): 269.75,81.88 269.75,79.72 269.55,79.52 268.84,79.52 268.84,79.52 268.84,79.98 268.3,80.52 267.34,80.52 267.26,80.59 267.26,81.09 267.36,81.19 268.48,81.19 268.79,81.5 268.79,81.93 269.01,82.16 269.47,82.16
+1.8V_AON on TOP (solid shape): 233.8,115.49 233.8,113.41 233.94,113.27 234.03,113.27 234.04,113.26 234.07,113.24 234.11,113.23 234.52,113.23 234.52,112.87 234.39,112.74 233.23,112.74 232.34,113.63 232.34,114.54 232.39,114.59 232.74,114.59 232.93,114.78 232.93,115.3 233.31,115.69 233.61,115.69
+1.8V_AON on TOP (solid shape): 275.37,147.67 275.3,147.6 275.3,144.67 275.32,144.65 275.32,144.45 275.28,144.4 274.76,144.4 274.66,144.3 274.4,144.3 274.22,144.48 273.37,144.48 273.23,144.63 273.23,144.91 273.28,144.96 273.28,145.61 273.82,146.16 273.82,146.16 274.36,146.69 274.36,147.74 274.5,147.88 275.37,147.88
+1.8V_AON on TOP (solid shape): 196.24,157.04 196.24,154.78 195.94,154.47 195.94,154.45 195.1,153.61 191.52,153.61 191.01,154.11 191.01,154.75 191,154.76 191,155.56 191.02,155.58 191.09,155.58 191.1,155.57 192.57,155.57 192.92,155.92 194.36,155.92 194.62,155.66 195.41,155.66 195.53,155.79 195.53,155.94 195.53,156.83 195.53,157.04 195.61,157.11 196.17,157.11
+1.8V_AON on TOP (solid shape): 216.6,173.37 216.79,173.18 216.79,172.61 216.93,172.47 217.6,172.47 217.61,172.46 217.61,172.26 217.55,172.2 216.58,172.2 216.46,172.09 216.06,172.09 215.96,172.19 215.96,172.74 215.79,172.91 215.21,172.91 215.17,172.93 215.16,172.96 215.16,173.11 215.2,173.14 216.03,173.14 216.25,173.37
+1.8V_AON on TOP (solid shape): 259.9,117.49 262.6,117.49 262.8,117.69 264.57,117.69 264.82,117.44 264.82,117.07 264.54,116.79 264.21,116.79 263.85,117.15 262.9,117.15 262.79,117.04 262.79,116.72 262.73,116.66 260.66,116.66 260.53,116.79 259.98,116.79 259.9,116.86 259.9,116.97 259.52,117.36 259.39,117.36 259.36,117.39 259.36,117.79 259.37,117.8 259.59,117.8
+1.8V_AON on TOP (solid shape): 252.49,172.63 252.5,172.61 252.5,172.59 252.5,171.62 253.67,170.46 253.94,170.46 254.17,170.23 254.17,169.75 254.07,169.65 254.05,169.64 254.03,169.63 253.15,169.63 253.13,169.64 253.11,169.65 252.96,169.8 252.96,170.66 252.27,171.36 252.27,172.27 252.26,172.61 252.28,172.64 252.32,172.66 252.46,172.66
+1.8V_AON on TOP (solid shape): 238.14,116.52 238.14,116.5 238.27,116.26 238.53,116.16 238.57,116.16 239.07,115.66 239.07,115.23 239.14,115.16 239.14,114.86 239.13,114.83 239.04,114.76 239.01,114.68 239.01,114.3 239.05,114.21 239.13,114.16 239.15,114.16 239.97,113.34 239.97,112.83 239.93,112.79 239.73,112.79 239.59,112.93 239.59,113.13 238.8,113.92 238.69,113.92 238.65,113.94 238.64,113.97 238.64,114.45 238.61,114.53 238.52,114.6 238.51,114.63 238.51,115.07 238.14,115.44 238.02,115.44 237.71,115.75 237.71,115.99 237.7,116.03 237.68,116.07 237.67,116.09 237.67,116.41 237.8,116.55 238.11,116.55
+1.8V_AON on TOP (solid shape): 242.07,122.81 242.07,121.84 241.61,121.38 241.61,120.54 241.01,119.94 240.85,119.94 240.64,119.74 240.59,119.7 240.52,119.61 240.52,118.96 240.69,118.78 241.38,118.78 241.46,118.71 241.46,118.56 241.04,118.56 240.94,118.52 240.9,118.42 240.9,118.08 240.94,117.98 241.04,117.94 241.1,117.94 241.2,117.84 241.2,116.48 241.23,116.44 241.23,116.43 241.37,116.19 241.62,116.09 241.69,116.1 241.75,116.11 241.77,116.12 242.08,115.82 242.08,115.3 242.01,115.24 241.46,115.24 241.25,115.45 240.43,115.45 239.87,116.01 239.87,116.87 240.3,117.3 240.3,118.01 240.32,118.06 240.33,118.09 240.33,118.47 240.29,118.57 240.19,118.61 239.95,118.61 239.86,118.71 239.86,119.83 240.22,120.19 240.63,120.19 240.64,120.21 240.87,120.21 240.87,120.99 240.82,120.99 240.82,122.43 241.42,123.03 241.86,123.03
+1.8V_AON on TOP (solid shape): outline of 174 points within 259.44,133.79 265.97,145.43
+1.8V_AON on TOP (solid shape): outline of 1892 points within 249.64,111.37 280.32,136.74
+1.8V_AON on TOP (solid shape): outline of 2344 points within 213.7,124.99 231.42,135.24
+1.8V_AON on BOTTOM (solid shape): 21.54,37.17 21.54,36.64 21.42,36.51 20.55,36.51 20.25,36.82 20.25,37.33 20.35,37.43 21.29,37.43
+1.8V_AON on BOTTOM (solid shape): 261.5,133.88 261.5,133.64 261.43,133.56 259.39,133.56 259.32,133.63 259.32,134.09 259.49,134.26 261.12,134.26
+1.8V_AON on BOTTOM (solid shape): 287.07,136.78 287.07,135.25 286.6,134.79 283.13,134.79 282.91,135.01 282.91,137.08 283.22,137.39 286.46,137.39
+1.8V_AON on BOTTOM (solid shape): 17.28,37.5 18.16,37.5 18.29,37.38 18.29,36.92 18.19,36.82 16.61,36.82 16.06,37.38 16.06,37.94 16.28,38.16 16.61,38.16
+1.8V_AON on BOTTOM (solid shape): 196.03,155.45 196.03,154.46 194.97,153.4 192.31,153.4 191.33,154.38 191.33,155.62 191.73,156.02 195.47,156.02
+1.8V_AON on BOTTOM (solid shape): 245.84,213.92 245.84,213.72 246.24,213.32 246.35,213.32 246.44,213.23 246.44,212.88 246.4,212.83 246.23,212.83 246.18,212.89 246.18,212.93 245.87,213.23 245.73,213.23 245.29,213.67 245.29,213.99 245.34,214.04 245.72,214.04
+1.8V_AON on BOTTOM (solid shape): 215.96,130.97 215.96,130.76 215.87,130.67 215.87,126.75 215.86,126.69 215.85,126.63 215.85,125.76 215.76,125.66 215.04,125.66 214.93,125.78 214.93,126.14 215.02,126.24 215.02,128.88 214.53,129.38 214.53,130.54 214.21,130.86 214.02,130.86 213.68,130.52 213.56,130.52 213.54,130.53 213.52,130.54 213.49,130.58 213.46,130.61 213.44,130.63 213.44,130.65 213.44,130.77 213.54,130.87 213.62,130.87 213.86,131.11 213.86,131.28 214,131.41 215.52,131.41
+1.8V_AON on BOTTOM (solid shape): 250.47,134.52 250.5,134.51 250.52,134.5 250.55,134.46 250.61,134.39 250.69,134.34 250.7,134.32 250.7,133.45 250.48,133.22 250.45,133.22 250.34,133.2 250.25,133.15 249.95,133.15 249.92,133.17 249.6,133.49 249.6,134.13 249.62,134.21 249.63,134.27 249.62,134.34 249.6,134.41 249.6,134.45 249.66,134.51 249.67,134.52 249.69,134.52
+1.8V_AON on BOTTOM (solid shape): 267.96,136.72 268.13,136.72 268.25,136.72 269.23,136.72 269.51,137 269.55,137.03 269.59,137.08 269.78,137.27 271.76,137.27 271.94,137.09 271.94,135.95 272.08,135.8 272.08,135.49 271.99,135.4 271.72,135.4 271.55,135.56 271.55,135.76 271.63,135.84 271.63,136.07 271.63,136.91 271.47,137.07 271.42,137.07 271.38,137.09 271.34,137.09 271.14,137.09 271.04,137.05 271,136.95 271,136.92 270.98,136.9 270.98,136.46 270.73,136.2 270.48,136.2 270.49,136.29 270.49,136.49 270.45,136.59 270.35,136.63 269.97,136.63 269.87,136.59 269.83,136.49 269.83,136.35 269.7,136.22 268.63,136.22 268.43,136.02 268.4,135.99 268.15,135.74 268.15,135.73 267.64,135.22 267.08,135.22 266.7,134.84 265.03,134.84 264.8,135.07 264.8,136.76 265.4,137.36 267.32,137.36
+1.8V_AON on BOTTOM (solid shape): outline of 97 points within 261.7,121.36 275.41,131.92
+1.8V_AON on BOTTOM (solid shape): outline of 101 points within 259.14,115.13 265.99,120.14
+1.8V_AON on BOTTOM (solid shape): outline of 226 points within 226.08,132.31 231.12,135.07
+1.8V_AON on IN1 (solid shape): 266.83,136.16 266.83,134.46 265.51,133.14 265.51,132.14 265.89,131.76 265.89,131.18 265.59,130.87 263.6,130.87 263.32,131.15 263.32,134.1 264.9,135.68 264.9,136.23 265.18,136.51 266.47,136.51
+1.8V_AON on IN1 (solid shape): outline of 107 points within 249.8,124.91 253.29,134.2
+1.8V_AON on IN1 (solid shape): outline of 1697 points within 223.19,127.4 233.23,135.05
+1.8V_AON on IN2 (solid shape): outline of 776 points within 264.32,116.98 285.35,137.78
+1.8V_AON on IN2 (solid shape): outline of 4867 points within 216.04,114.95 254.72,135.28
+1.8V_AON on IN2 (solid shape): outline of 41615 points within 195.23,125.63 278.9,187.34
+1.8V_AON on IN3 (solid shape): 218.87,126.84 218.87,125.54 218.6,125.26 214.91,125.26 214.76,125.41 214.76,126.71 215.12,127.06 218.65,127.06
+1.8V_AON on IN4 (solid shape): outline of 12179 points within 192.46,124.32 278.79,186.83
+1.8V_CLKLDO on TOP (solid shape): 210.62,65.47 210.62,65.06 210.52,64.96 210.44,64.96 210.26,64.78 210.26,64.28 210.25,64.27 209.1,64.27 208.87,64.04 208.87,63.48 208.58,63.19 207.8,63.19 207.66,63.33 207.62,63.41 207.62,63.84 207.62,64.61 207.72,64.71 207.72,65.09 207.95,65.32 209.15,65.32 209.15,64.85 209.45,64.55 209.78,64.55 210.01,64.78 210.01,64.96 210.01,65.44 210.05,65.49 210.6,65.49
+1.8V_DEEP_SUS on TOP (solid shape): 228.78,70.12 228.78,69.74 228.86,69.66 228.86,68.67 228.6,68.42 227.97,68.42 227.92,68.47 227.92,69.3 228.09,69.47 228.09,70.16 228.11,70.18 228.12,70.18 228.13,70.19 228.71,70.19
+1.8V_DEEP_SUS on TOP (solid shape): 224.92,81.85 224.92,81.27 223.88,80.23 222.79,80.23 222.77,80.21 222.23,80.21 221.46,79.45 221.44,79.44 221.41,79.44 221.21,79.44 221.18,79.44 221.15,79.43 221.07,79.43 221.03,79.39 221.03,78.93 220.96,78.86 220.37,78.86 220.25,78.98 220.25,79.59 221.21,80.56 221.77,80.56 222.37,81.15 222.93,81.15 223.88,82.11 224.67,82.11
+1.8V_DEEP_SUS on TOP (solid shape): 214.37,69.57 214.36,69.48 214.36,69.43 214.36,68.78 214.36,68.71 214.39,68.63 214.39,66.87 214.3,66.78 213.84,66.78 213.64,66.58 213.64,66.01 213.49,65.87 213.04,65.87 212.64,65.47 212.64,65.22 212.56,65.13 211.84,65.13 211.55,65.42 211.55,65.93 211.31,66.17 210.8,66.17 210.63,65.99 210.63,65.83 210.6,65.8 210.11,65.8 210.06,65.85 210.06,65.92 209.99,66 209.99,66.49 210.18,66.68 211.18,66.68 211.4,66.9 211.4,67.42 211.45,67.47 211.98,67.47 212.16,67.65 212.16,69.76 212.25,69.85 214.09,69.85
+1.8V_DEEP_SUS on TOP (solid shape): 226.09,66.92 226.12,66.9 226.14,66.87 226.14,66.36 226.38,66.36 226.38,66.87 226.4,66.9 226.43,66.92 226.83,66.92 226.9,66.84 226.9,66.41 227.1,66.21 227.1,65.67 226.95,65.52 225.78,65.52 225.7,65.61 225.68,65.7 225.68,66.05 225.87,66.24 225.87,66.35 225.88,66.36 225.88,66.37 225.89,66.38 225.94,66.5 225.96,66.62 225.95,66.7 225.93,66.78 225.94,66.87 226.03,66.92
+1.8V_DEEP_SUS on BOTTOM (solid shape): 223.53,53.26 223.56,53.26 223.61,53.24 223.65,53.24 223.9,53.24 224.56,52.57 224.56,52.11 224.46,52.01 223.29,52.01 223.25,52.05 223.25,52.42 222.66,53.02 222.62,53.05 222.58,53.07 221.77,53.88 221.77,54.32 221.91,54.46 222.33,54.46
+1.8V_DEEP_SUS on BOTTOM (solid shape): outline of 123 points within 246.85,60.44 251.36,65.49
+1.8V_DEEP_SUS on IN2 (solid shape): outline of 5616 points within 210.02,62.09 251.97,76.49
+1.8V_DEEP_SUS on SVCC (solid shape): 218.48,70.57 218.52,70.56 218.56,70.57 218.61,70.57 228.6,70.57 228.82,70.5 229.05,70.57 229.57,70.57 229.58,70.54 229.71,70.34 229.93,70.27 230.03,70.28 230.13,70.33 230.79,70.32 230.8,70.31 230.89,70.27 230.99,70.25 231.22,70.33 231.34,70.54 231.35,70.57 238.79,70.57 245.27,64.1 250.04,64.1 250.33,63.94 250.62,64.1 250.88,64.1 251.59,63.39 251.59,61.13 249.23,58.76 246.26,58.76 239.02,66 230.54,66 230.27,66 230.26,66.04 229.91,66.33 229.56,66.04 229.55,66 228.62,66 228.4,66.08 228.18,66 226.82,66 226.8,66.04 226.46,66.3 226.12,66.04 226.11,66 218.82,66 218.53,66.14 218.25,66 218.05,66 217.75,66.16 217.45,66 211.35,66 211.23,66.09 211.08,66.13 210.94,66.1 210.83,66.02 210.81,66 210.7,66 210.7,69.74 211.53,70.57 218.43,70.57
+1.8V_DEEP_SUS on IN3 (solid shape): outline of 765 points within 209.65,62.31 215.85,70.3
+1.8V_DEEP_SUS on IN4 (solid shape): outline of 1156 points within 202.43,61.71 214.43,69.4
+1.8V_S5 on TOP (solid shape): 254.89,67.45 254.89,66.18 254.69,65.98 252.86,65.98 252.73,66.11 252.73,67.22 253.16,67.65 254.69,67.65
+1.8V_S5 on TOP (solid shape): 254.1,62.05 254.1,61.35 254.29,61.17 254.29,60.83 254.37,60.74 255.66,60.74 255.81,60.59 255.81,59.65 255.6,59.45 254.28,59.45 253.14,60.59 253.14,62 253.34,62.2 253.96,62.2
+1.8V_S5 on BOTTOM (solid shape): 254.41,61.55 254.41,60.38 254.18,60.16 252,60.16 251.82,60.34 251.82,62.14 252,62.32 253.63,62.32
+1.8V_S5 on BOTTOM (solid shape): 300.11,90.23 304.53,90.23 304.83,89.93 304.83,88.2 304.4,87.76 304.4,87.56 304.37,87.49 304.3,87.46 303.9,87.06 304.3,86.67 304.37,86.64 304.4,86.57 304.4,85.62 303.87,85.09 303.7,85.09 303.5,85.29 303.5,86.53 303.41,86.62 303.38,86.68 303.35,86.72 303.13,86.95 303.13,86.96 302.72,87.37 302.72,88.23 301.7,89.26 300.26,89.26 299.51,90.01 299.35,90.01 299.15,90.2 299.15,90.57 299.19,90.6 299.74,90.6
+1.8V_S5 on IN4 (solid shape): outline of 126 points within 251.89,60.19 254.84,67.88
+1.8V_VCC on TOP (solid shape): 156.93,150.44 156.93,150.12 156.92,150.09 156.88,150.07 156.68,150.07 156.64,150.08 156.6,150.08 156.56,150.08 156.52,150.07 156.37,150.07 156.16,149.86 156.16,149.61 155.99,149.44 155.44,149.44 155.32,149.32 155.32,148.42 155.19,148.29 154.29,148.29 154.26,148.32 154.26,149.7 154.45,149.9 154.57,149.9 154.74,150.07 154.74,150.5 154.8,150.57 156.81,150.57
+1.8V_VCC on BOTTOM (solid shape): outline of 82 points within 152.97,148.15 156.42,150.67
+1.8V_VCC on IN1 (solid shape): outline of 2013 points within 155,147.01 173.83,156.03
+1V8_AON_U on BOTTOM (solid shape): 243.29,121.62 243.29,120.5 243.58,120.21 243.58,120.19 243.84,119.93 243.84,119.04 243.76,118.96 243.45,118.96 242.75,118.26 241.93,118.26 241.85,118.19 241.85,117.88 241.64,117.67 241.64,117.22 241.43,117.01 241.24,116.81 241.24,116.59 241.03,116.39 240.7,116.39 240.67,116.41 240.67,117.05 240.98,117.36 240.98,117.59 240.98,118.46 241.23,118.71 241.23,118.71 241.29,118.76 241.76,118.76 241.81,118.82 242.35,118.82 242.61,119.08 242.61,120.14 242.37,120.37 242.37,121.58 242.7,121.91 243,121.91
+1V_GFX on TOP (solid shape): 239.66,121.31 239.66,118.8 239.17,118.3 237.67,118.3 237.54,118.43 237.54,121.27 237.8,121.53 239.45,121.53
+1V_GFX on TOP (solid shape): 242.91,135.78 243.15,135.65 243.51,135.29 244.15,135.29 244.35,135.5 244.62,135.5 244.76,135.36 244.76,135.05 244.88,134.94 244.88,134.82 245.01,134.69 245.54,134.69 245.79,134.94 245.8,134.97 245.87,135.06 245.9,135.17 245.9,135.22 246.08,135.4 246.85,135.4 246.87,135.42 246.9,135.43 246.93,135.44 247.51,135.44 247.68,135.27 248.89,135.27 248.92,135.25 248.92,135.03 248.89,135.01 248.87,135 248.64,135 248.55,134.91 248.55,132.87 248.33,132.64 247.78,132.64 247.73,132.69 247.73,133.4 247.51,133.62 246.95,133.62 246.93,133.6 244.63,133.6 244.59,133.62 244.55,133.63 244.48,133.63 244.27,133.83 244.27,134 244.15,134.13 243.91,134.13 243.87,134.13 243.84,134.14 243.7,134.14 243.49,134.35 243.17,134.35 243.15,134.35 243.08,134.4 243.01,134.41 242.93,134.41 242.88,134.46 242.88,135.15 242.75,135.28 242.67,135.28 242.6,135.35 242.6,135.73 242.68,135.81 242.76,135.81 242.76,135.82 242.85,135.82
+1V_GFX on TOP (solid shape): 234.84,134.94 235.54,134.94 235.61,134.86 236.33,134.86 236.36,134.84 236.36,134.79 236.52,134.63 236.7,134.63 236.83,134.56 237,134.56 237.03,134.55 237.3,134.55 237.67,134.93 237.9,134.93 237.92,134.91 237.92,134.52 237.75,134.36 236.61,134.36 236.48,134.23 236.48,133.74 236.66,133.56 237.32,133.56 237.5,133.38 237.5,133.18 237.55,133.13 237.76,133.13 237.76,133.13 238,133.13 238.01,133.12 238.14,133.12 238.21,133.05 238.21,130.75 238.09,130.64 237.99,130.64 237.97,130.66 237.36,130.66 237.31,130.7 237.31,132.61 236.58,133.34 236.58,133.35 236.34,133.59 236.34,133.66 236.29,133.72 236.26,133.75 236.24,133.78 236.16,133.85 235.79,133.85 235.41,133.47 233.63,133.47 233.52,133.36 233.52,133.36 233.52,133.16 233.4,133.04 233.19,133.04 233.06,133.17 233.06,133.36 232.95,133.48 232.93,133.48 232.92,133.47 232.55,133.47 232.54,133.49 232.23,133.8 231.75,133.8 231.68,133.87 231.68,134.48 232.08,134.88 232.96,134.88 232.98,134.89 233.02,134.9 233.16,134.9 233.34,135.09 233.34,135.49 233.34,135.5 233.53,135.69 234.09,135.69
+1V_GFX on BOTTOM (solid shape): 206.02,108.7 206.99,107.74 206.99,107.38 207,107.37 207,106.78 207.01,106.77 207.01,105.69 206.91,105.58 204.46,105.58 204.42,105.63 204.42,106.69 204.11,107.01 204.1,107.01 204,107.11 203.32,107.11 203.2,107.23 203.2,108.86 203.44,109.1 205.62,109.1
+1V_GFX on BOTTOM (solid shape): outline of 457 points within 231.3,116.82 248.57,135.49
+1V_GFX on IN2 (solid shape): 240.29,120.93 240.29,117.77 240.24,117.67 240.23,117.57 240.23,117.52 240.24,117.46 240.23,117.44 240.22,117.42 240.12,117.39 240.05,117.46 239.92,117.64 239.71,117.71 239.46,117.61 239.35,117.36 239.35,117.32 239.33,117.24 239.25,117.21 238.38,117.21 238.08,117.51 238.08,121.02 238.53,121.47 239.75,121.47
+1V_GFX on IN3 (solid shape): 240.01,122.15 240.01,121.19 240.03,121.17 240.03,120.43 239.81,120.22 238.7,120.22 238.62,120.3 238.21,120.3 236.13,122.37 233.4,122.37 231.01,119.98 225.56,119.98 224.63,119.06 216.68,119.06 215.56,117.94 211.02,117.94 204.94,111.86 204.94,107.44 204.49,106.99 202.85,106.99 202.26,107.58 202.26,113.21 209.61,120.55 214.16,120.55 214.23,120.63 214.32,120.63 215.44,121.75 223.69,121.75 226.99,125.04 237.12,125.04
+1V_GFX_S on TOP (solid shape): 206.92,104.02 206.92,100.84 206.71,100.63 205.45,100.63 205.36,100.71 205.36,101.22 205.29,101.29 204.75,101.29 204.59,101.45 204.59,101.97 204.6,101.98 204.6,102.17 204.5,102.27 204.5,102.99 204.3,103.19 201.55,103.19 201.4,103.34 201.4,104.68 201.69,104.96 205.97,104.96
+1V_GFX_S on BOTTOM (solid shape): 207.64,104.99 207.64,104.22 207.71,104.15 207.71,104.14 207.82,103.96 208,103.85 208.02,103.85 208.23,103.63 208.23,102.05 208.08,101.91 205.35,101.91 205.22,102.03 205.22,103.32 204.45,104.09 204.45,105.02 204.63,105.2 207.43,105.2
+1V_S5_VIN on TOP (solid shape): 245.97,42.67 245.97,42.38 246.22,42.13 247.88,42.13 248.58,41.42 248.58,39.61 248.43,39.46 246.87,39.46 246.8,39.52 246.41,39.52 246.27,39.65 246.27,39.91 245.68,40.5 244.45,40.5 244.38,40.58 244.38,41.02 244.9,41.54 244.9,42.7 244.99,42.8 245.84,42.8
+1V_S5_VIN on BOTTOM (solid shape): 248.32,42.41 248.32,40.25 248.56,40.02 248.56,39.64 248.35,39.43 246.84,39.43 245.16,41.11 242.89,41.11 242.54,41.47 242.54,41.88 242.7,42.05 244.36,42.05 245.12,42.81 247.92,42.81
+2.5V_SUS on TOP (solid shape): 188.96,90.44 188.96,86.88 188.85,86.77 187.72,86.77 187.5,86.98 187.5,88.29 187.66,88.45 188.03,88.45 188.23,88.65 188.23,90.47 188.33,90.56 188.84,90.56
+2.5V_SUS on TOP (solid shape): 189.31,105.96 189.31,104.25 189.3,104.23 189.28,104.18 189.27,104.12 189.27,103.82 189.28,103.75 189.3,103.7 189.31,103.68 189.31,102.63 189.18,102.5 189.18,101.28 189.12,101.22 189.1,101.22 188.96,101.21 188.82,101.18 188.45,101.18 188.29,101.33 188.29,103.01 187.99,103.32 187.99,104.81 188.62,105.45 188.62,105.98 188.73,106.08 189.18,106.08
+2.5V_SUS on BOTTOM (solid shape): 187.89,90.89 188.05,90.73 188.05,88.3 188.14,88.21 188.14,87.81 188.17,87.79 188.17,87.74 188.55,87.36 188.55,86.86 188.39,86.7 187.36,86.7 187.13,86.93 187.13,88.14 187.13,88.21 187.13,88.65 187.15,88.67 187.65,88.67 187.65,90.43 187.4,90.43 187.4,88.67 187.15,88.67 187.15,90.43 187.13,90.45 187.13,90.65 187.38,90.9 187.85,90.9
+2.5V_SUS on BOTTOM (solid shape): 198.89,98.18 201.25,98.18 202.11,97.32 202.64,97.32 203.2,96.76 203.2,95.37 202.87,95.04 202.85,95.04 202.8,95.07 202.75,95.08 201.37,95.08 201.33,95.08 201.2,95.21 201.2,96.48 200.84,96.84 198.73,96.84 198.2,97.37 197.66,97.37 197.65,97.38 197.5,97.4 197.36,97.38 197.35,97.37 197.13,97.37 196.9,97.6 196.9,98.59 197.16,98.85 198.22,98.85
+2.5V_SUS on BOTTOM (solid shape): outline of 84 points within 187.17,100.92 189.33,105.54
+2.5V_SUS on IN1 (solid shape): outline of 440 points within 186.97,86.7 189.51,103.47
+2.5V_SUS on IN2 (solid shape): 195.27,99.19 197.98,99.19 198.35,98.82 198.35,97.6 198.12,97.37 193.91,97.37 190.17,101.11 190.03,101.11 189.95,101.15 189.93,101.24 189.94,101.28 189.94,101.33 189.92,101.47 189.84,101.59 189.8,101.66 189.84,101.74 189.92,101.86 189.94,101.99 189.59,102.35 189.23,101.99 189.26,101.86 189.34,101.74 189.37,101.66 189.34,101.59 189.26,101.47 189.23,101.33 189.24,101.29 189.23,101.25 189.22,101.21 188.93,101.21 188.65,101.11 188.64,101.11 188.45,101.11 188.24,100.9 187.81,100.9 187.59,101.12 187.59,103.68 187.91,104 190.45,104
+3V on TOP (solid shape): 65.18,68.72 65.18,65.29 65.1,65.22 63.2,65.22 63.07,65.34 63.07,68.81 63.18,68.92 64.98,68.92
+3V on TOP (solid shape): 204.2,106.68 204.2,105.76 204.06,105.62 203.51,105.62 203.32,105.81 203.32,106.73 203.47,106.88 204,106.88
+3V on TOP (solid shape): 124.58,213.99 124.58,213.47 124.77,213.27 124.77,212.02 124.64,211.88 124.05,211.88 123.76,212.17 123.76,213.84 124.02,214.09 124.48,214.09
+3V on TOP (solid shape): 287.76,82.99 287.76,82.69 287.25,82.18 287.25,81.91 287.18,81.84 286.78,81.84 286.69,81.93 286.69,82.42 287.18,82.91 287.18,82.95 287.36,83.13 287.62,83.13
+3V on TOP (solid shape): 187.28,90 187.28,87.51 187,87.23 186.58,87.23 186.56,87.23 186.54,87.24 186.47,87.32 186.47,89.72 186.81,90.05 187.23,90.05
+3V on TOP (solid shape): 23.31,12.38 23.31,12.08 23.15,11.92 22.81,11.92 22.52,11.64 22.52,11.33 22.44,11.25 22.05,11.25 21.99,11.31 21.99,11.92 22.06,11.99 22.06,12.42 22.12,12.49 23.19,12.49
+3V on TOP (solid shape): 100.88,99.11 100.88,94.01 100.68,93.81 99.13,93.81 98.97,93.97 98.97,94.17 98.94,94.2 98.94,97.18 98.9,97.21 98.43,97.21 98.36,97.28 98.36,99.04 98.52,99.19 100.8,99.19
+3V on TOP (solid shape): 308.33,70.8 308.33,70.42 308.46,70.3 308.71,70.3 308.84,70.17 308.84,69.81 308.77,69.74 308.46,69.74 308.33,69.87 308.33,70.06 307.9,70.49 307.9,70.83 307.98,70.91 308.23,70.91
+3V on TOP (solid shape): 112.59,116.62 112.59,116.35 112.76,116.17 112.78,116.17 113.29,115.67 113.29,115.1 113.88,114.51 113.88,113.74 113.59,113.45 112.88,113.45 112.08,114.25 112.08,116.65 112.1,116.68 112.13,116.7 112.52,116.7
